# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_PARITY: length 50
  IN4 w0.14: v7(117.41,43.6) 117.7,43.89 117.7,50.76 110.86,57.59 110.86,68.18 109.89,69.15 109.89,75.23 109.61,75.5 109.61,80.25 109.28,80.58 109,80.58 108.68,80.9 108.68,84.31 108.56,84.44 108.35,84.44 108.21,84.3 v3(108.21,83.5)
  BOTTOM w0.076: v3(108.21,83.5) 108.39,83.64 108.48,83.71 108.52,83.74 UC1.AT52
  BOTTOM w0.171: v7(117.41,43.6) 116.76,44.25 JDIMM1.143
DDR_B_ACT#: length 66.1
  IN1 w0.076: v3(107.29,85.43) 106.87,85.01 106.87,82.51 104.96,80.61 104.96,79.09 105.04,79.01 105.04,77.15 105.04,77.15 105.04,76.85 105.04,76.85 105.04,76.83 104.86,76.64 104.54,76.64 103.64,75.74 103.64,75.25
  IN1 w0.14: 103.64,75.25 103.64,49.67 104.37,48.94 104.37,42.16 103.6,41.38 103.6,35.17 105.94,32.83 105.94,30.41 108.3,28.04 v1(109.02,28.04)
  BOTTOM w0.076: UC1.AN53 107.38,85.43 v3(107.29,85.43)
  BOTTOM w0.171: JDIMM2.114 109.52,27.54 v1(109.02,28.04)
DDR_B_ALERT#: length 69.3
  IN1 w0.076: 108.69,74.79 108.69,75.48 110.65,77.44 110.65,79.03 110.75,79.13 110.75,80.15 110.55,80.35 110.55,82.39 110.56,82.39 110.56,85.57 110.75,85.76 111.19,85.76 111.59,86.17 112.15,86.17 112.57,85.75 112.57,85.67 v7(112.81,85.43)
  IN1 w0.14: 108.69,74.79 108.7,74.78 108.7,61.4 109.19,60.92 109.19,56.33 108.69,55.84 108.69,51.82 108.98,51.53 108.98,50.67 110.47,49.18 110.47,44.04 110.07,43.64 110.07,39.62 111.47,38.22 111.47,34.38 112.81,33.04 112.81,29.46 v1(112.86,29.4)
  BOTTOM w0.076: v7(112.81,85.43) 112.87,85.43 UC1.AN43
  BOTTOM w0.171: JDIMM2.116 110.02,28.15 111.26,29.4 v1(112.86,29.4)
DDR_B_BA0: length 65.5
  IN1 w0.076: 115.12,74.79 115.12,75.39 114.38,76.12 v3(113.8,76.12)
  IN1 w0.14: v1(123.01,28.67) 122.76,28.67 122.49,28.94 121.75,28.94 121.5,29.2 121.09,29.2 120.94,29.35 120.94,29.68 121.07,29.81 121.85,29.81 122.01,29.96 122.01,30.14 121.85,30.29 120.94,30.29 120.84,30.39 120.84,38.65 120.66,38.82 120.15,38.82 120.05,38.92 120.05,39.37 120.15,39.46 120.53,39.46 120.67,39.59 120.67,46.06 119.22,47.51 119.22,54.28 115.68,57.83 115.68,61.61 115.35,61.94 115.35,71.25 115.12,71.47 115.12,74.79
  BOTTOM w0.076: UC1.BB44 112.99,79.98 112.99,76.93 v3(113.8,76.12)
  BOTTOM w0.171: JDIMM2.150 120.52,28.32 120.87,28.67 v1(123.01,28.67)
DDR_B_BA1: length 65.9
  IN1 w0.076: v3(111.43,75.24) 111.66,75.01 111.66,74.79
  IN1 w0.14: 111.66,74.79 111.66,69.78 112.12,69.32 112.12,56.27 114.11,54.27 114.11,53.81 114.25,53.67 114.35,53.67 114.49,53.53 114.49,53.25 114.35,53.11 114.25,53.11 114.11,52.97 114.11,52.69 114.25,52.55 114.35,52.55 114.49,52.41 114.49,52.13 114.35,51.99 114.25,51.99 114.11,51.85 114.11,51.57 114.25,51.43 114.35,51.43 114.49,51.29 114.49,51.01 114.35,50.87 114.25,50.87 114.11,50.73 114.11,50.45 114.25,50.31 114.35,50.31 114.49,50.17 114.49,49.9 114.35,49.76 114.25,49.76 114.11,49.62 114.11,46.38 114.56,45.94 115.35,45.94 115.56,45.73 115.56,45.35 115.2,45 115.2,44.46 115.56,44.11 115.56,43.65 114.86,42.96 114.86,42.78 115.07,42.57 115.26,42.57 115.5,42.81 116.34,42.81 116.53,42.63 116.53,41.55 116.29,41.31 115.9,41.31 115.82,41.23 115.82,34.88 115.96,34.74 116.47,34.74 116.61,34.6 116.61,34.33 116.47,34.19 115.96,34.19 115.82,34.05 115.82,29.91 116,29.72 116.39,29.72 116.52,29.86 v1(116.52,30.11)
  BOTTOM w0.076: v3(111.43,75.24) 111.68,75.49 111.73,75.49 v6(111.98,75.73) 112.83,76.58 112.83,80.47 UC1.BA44
  BOTTOM w0.171: JDIMM2.145 119.27,31.43 118.55,30.72 117.13,30.72 v1(116.52,30.11)
DDR_B_BG0: length 67.3
  IN1 w0.076: 104.06,74.96 103.9,75.13 103.9,75.76 104.61,76.48 104.92,76.48 105.26,76.81 105.26,80.3 107.73,82.77 107.73,84.32 v3(108.21,84.8)
  IN1 w0.14: v1(108.07,30.21) 107.74,29.88 107.13,29.88 106.35,30.65 106.35,31.45 106.47,31.57 107.03,31.57 107.19,31.73 107.19,32.17 104.02,35.34 104.02,41.21 104.79,41.98 104.79,49.44 104.07,50.15 104.07,65.18 104.21,65.32 104.34,65.32 104.48,65.46 104.48,65.74 104.34,65.88 104.21,65.88 104.07,66.02 104.07,66.29 104.21,66.43 104.34,66.43 104.48,66.57 104.48,66.85 104.34,66.99 104.21,66.99 104.07,67.13 104.07,67.41 104.21,67.55 104.34,67.55 104.48,67.69 104.48,67.97 104.34,68.11 104.21,68.11 104.07,68.25 104.07,68.67 104.5,69.1 104.5,70.73 104.06,71.17 104.06,74.96
  BOTTOM w0.076: v3(108.21,84.8) 108.31,84.8 UC1.AP52
  BOTTOM w0.171: v1(108.07,30.21) 108.16,30.21 109.77,31.82 JDIMM2.115
DDR_B_BG1: length 67.7
  IN1 w0.076: 104.48,74.79 104.48,74.97 104.68,75.17 104.68,75.24 104.68,75.24 104.68,75.52 105.43,76.26 105.43,79.88 106.82,81.27 107.76,81.27 108.54,82.05 108.54,83.33 108.56,83.35 108.56,85.1 v3(108.19,85.48)
  IN1 w0.14: 104.48,74.79 104.48,71.34 104.92,70.9 104.92,65.27 104.49,64.85 104.49,64.42 104.63,64.28 104.78,64.28 104.92,64.14 104.92,63.86 104.78,63.72 104.63,63.72 104.49,63.58 104.49,50.55 105.21,49.83 105.21,41.81 104.44,41.03 104.44,39.3 104.58,39.16 104.71,39.16 104.89,38.98 104.89,38.75 104.74,38.6 104.58,38.6 104.44,38.46 104.44,35.52 104.66,35.29 104.94,35.29 105.07,35.42 105.07,35.88 105.16,35.98 105.45,35.98 105.62,35.8 105.62,34.33 107.61,32.34 107.61,31.56 106.92,30.87 106.92,30.68 107.18,30.42 107.37,30.42 107.81,30.86 v1(108.07,30.86)
  BOTTOM w0.076: UC1.AN52 108.34,85.48 v3(108.19,85.48)
  BOTTOM w0.171: JDIMM2.113 109.27,31.93 108.2,30.86 v1(108.07,30.86)
DDR_B_CKE0: length 65.3
  IN1 w0.076: v3(105.5,85.48) 105.01,85 105.01,84.01 104.82,83.82 104.82,81.22 104.33,80.73 104.33,79.24 103.97,78.88 103.97,76.73 102.8,75.56 102.8,75.3
  IN1 w0.14: v7(105.09,31.15) 105.09,29.98 104.95,29.84 104.44,29.84 104.3,29.98 104.3,33.28 102.76,34.82 102.76,41.73 103.53,42.5 103.53,48.59 102.8,49.32 102.8,75.3
  BOTTOM w0.076: UC1.AN56 105.6,85.48 v3(105.5,85.48)
  BOTTOM w0.171: v7(105.09,31.15) 105.29,31.15 105.41,31.04 106.88,31.04 108.27,32.42 JDIMM2.109
DDR_B_CKE1: length 65.4
  IN1 w0.076: v3(106.38,84.82) 105.85,84.3 105.85,81.8 104.53,80.48 104.53,79.21 104.13,78.81 104.13,76.66 103.22,75.75 103.22,75.33
  IN1 w0.14: 103.22,75.33 103.22,49.5 103.95,48.76 103.95,42.33 103.18,41.55 103.18,34.99 105.52,32.66 105.52,30.04 108.27,27.29 v1(109.03,27.29)
  BOTTOM w0.076: v3(106.38,84.82) 106.51,84.82 UC1.AP55
  BOTTOM w0.171: JDIMM2.110 108.52,27.12 108.69,27.29 v1(109.03,27.29)
DDR_B_CKE2: length 1.6
  TOP w0.076: v3(106.36,85.46) 106.49,85.46 T6209.1
  BOTTOM w0.076: UC1.AN55 106.5,85.46 v3(106.36,85.46)
DDR_B_CKE3: length 1.4
  TOP w0.076: T6210.1 107.35,84.77 v3(107.35,84.82)
  BOTTOM w0.076: UC1.AP53 107.43,84.82 v3(107.35,84.82)
DDR_B_CS#0: length 65.1
  IN1 w0.076: 115.96,74.79 115.96,75.57 115.75,75.78 115.19,75.78 114.26,76.72 114.26,77.01 113.98,77.28 v3(113.74,77.28)
  IN1 w0.14: 115.96,74.79 115.96,71.82 116.18,71.6 116.18,62.29 116.51,61.96 116.51,58.17 120.06,54.63 120.06,54.32 120.18,54.2 120.46,54.2 120.61,54.05 120.61,53.88 120.51,53.78 120.18,53.78 120.06,53.66 120.06,53.48 120.18,53.36 121,53.36 121.12,53.24 121.12,53.06 121,52.94 120.18,52.94 120.06,52.82 120.06,52.64 120.18,52.52 121,52.52 121.12,52.4 121.12,52.23 121,52.1 120.18,52.1 120.06,51.98 120.06,49.41 120.48,48.98 120.94,48.98 121.07,48.86 121.07,48.4 122.34,47.12 122.34,46.62 122.46,46.5 122.9,46.5 123.07,46.32 123.07,45.98 122.95,45.86 122.49,45.86 122.34,45.71 122.34,42.98 122.46,42.86 122.97,42.86 123.07,42.77 123.07,42.5 122.85,42.28 122.49,42.28 122.31,42.1 122.31,41.74 122.17,41.6 122.17,39.66 121.68,39.17 121.68,37.35 121.88,37.15 121.88,36.45 122.27,36.06 122.27,30.88 122.15,30.77 v1(121.27,30.77)
  BOTTOM w0.076: v3(113.74,77.28) 114.25,77.78 114.25,79.01 114.42,79.18 UC1.BB42
  BOTTOM w0.171: JDIMM2.149 120.27,32.54 120.49,32.31 120.49,31.54 v1(121.27,30.77)
DDR_B_CS#1: length 66.3
  IN1 w0.076: v3(113.74,77.84) 114.42,77.16 114.42,76.79 115.26,75.95 115.82,75.95 116.38,75.38 116.38,74.79
  IN1 w0.14: 116.38,74.79 116.38,71.99 116.6,71.77 116.6,62.46 117,62.06 117,58.28 121.56,53.72 121.56,51.68 121.43,51.56 120.68,51.56 120.56,51.44 120.56,51.26 120.68,51.14 121.43,51.14 121.56,51.02 121.56,50.85 121.43,50.72 120.68,50.72 120.56,50.6 120.56,50.43 120.68,50.3 121.43,50.3 121.56,50.18 121.56,50.01 121.43,49.88 120.94,49.88 120.81,49.76 120.81,49.59 120.94,49.47 121.43,49.47 121.56,49.34 121.56,48.5 123.5,46.56 123.5,42.34 122.59,41.42 122.59,39.49 122.36,39.27 122.36,36.56 122.69,36.24 122.69,35.64 122.81,35.52 123.29,35.52 123.42,35.39 123.42,35.22 123.29,35.1 122.81,35.1 122.69,34.98 122.69,34.8 122.81,34.68 123.29,34.68 123.42,34.56 123.42,34.38 123.29,34.26 122.81,34.26 122.69,34.14 122.69,33.96 122.81,33.84 123.29,33.84 123.42,33.72 123.42,33.54 123.29,33.42 122.81,33.42 122.69,33.3 122.69,32.8 123.42,32.07 123.42,31.62 123.28,31.48 v1(122.77,31.48)
  BOTTOM w0.076: v3(113.74,77.84) 114.08,78.18 114.08,79.07 114.25,79.24 114.25,79.73 114.15,79.82 114.15,80.19 114.19,80.27 114.19,80.52 114.15,80.65 114.15,80.84 114.22,81.03 114.42,81.23 UC1.AY42
  BOTTOM w0.171: JDIMM2.157 122.27,31.98 v1(122.77,31.48)
DDR_B_CS#2: length 3.6
  TOP w0.171: T6216.1 124.01,27.8 v1(124.01,27.8)
  BOTTOM w0.171: JDIMM2.162 123.52,27.3 v1(124.01,27.8)
DDR_B_CS#3: length 3.5
  TOP w0.171: v1(124.71,31.48) 124.06,30.83 T6215.1
  BOTTOM w0.171: v1(124.71,31.48) 124.65,31.48 124.27,31.87 JDIMM2.165
DDR_B_D0: length 75.9
  IN1 w0.089: v7(88.71,30.09) 88.5,29.88 88.15,29.88 88,30.03 88,38.07 88.2,38.27 88.2,42.29 88.11,42.37 87.58,42.37 87.49,42.46 87.49,42.64 87.58,42.73 88.11,42.73 88.2,42.82 88.2,43.12 88.11,43.21 87.87,43.21 87.77,43.31 87.77,43.5 87.84,43.57 88.11,43.57 88.2,43.66 88.2,46.39 91.85,50.04 91.85,51.97 92.21,52.33 92.21,57.49 92.76,58.04 92.76,79.93 91.63,81.06 91.63,85.33 92.56,86.27 95.28,86.27 95.87,86.86 96.58,86.86 97.85,88.13 100.13,88.13 v3(100.8,88.8)
  BOTTOM w0.076: UC1.AF65 101.12,89.12 v3(100.8,88.8)
  BOTTOM w0.108: v7(88.71,30.09) 88.07,30.09 87.27,30.89 JDIMM2.25
DDR_B_D1: length 74.7
  IN1 w0.089: v3(101.43,88.8) 101.01,88.38 100.72,88.38 100.26,87.92 98,87.92 96.63,86.55 95.9,86.55 95.18,85.84 92.56,85.84 91.93,85.21 91.93,81.18 93.06,80.05 93.06,57.91 92.52,57.37 92.52,52.2 92.16,51.84 92.16,49.92 88.71,46.47 88.71,44.27 88.8,44.18 89.17,44.18 89.26,44.09 89.26,43.91 89.17,43.82 88.8,43.82 88.71,43.73 88.71,43.55 88.8,43.47 89.17,43.47 89.26,43.38 89.26,43.2 89.17,43.11 88.8,43.11 88.71,43.02 88.71,42.84 88.8,42.75 89.17,42.75 89.26,42.67 89.26,42.49 89.17,42.4 88.8,42.4 88.71,42.31 88.71,38.34 88.31,37.94 88.31,30.97 88.44,30.85 v1(88.71,30.85)
  BOTTOM w0.076: UC1.AF64 101.77,89.14 v3(101.43,88.8)
  BOTTOM w0.108: JDIMM2.29 88.27,32.31 87.95,31.99 87.95,31.15 88.25,30.85 v1(88.71,30.85)
DDR_B_D2: length 75.1
  IN1 w0.089: v1(90.86,31.48) 91.26,31.88 91.26,33.19 91.17,33.28 90.85,33.28 90.76,33.36 90.76,33.54 90.85,33.63 91.17,33.63 91.26,33.72 91.26,33.9 91.17,33.99 90.85,33.99 90.76,34.08 90.76,34.25 90.85,34.34 91.17,34.34 91.26,34.43 91.26,35.24 91.18,35.32 90.84,35.32 90.76,35.4 90.76,35.67 91.4,36.31 91.4,43.15 91.56,43.31 91.74,43.31 91.83,43.22 91.83,41.49 91.88,41.44 92.1,41.44 92.2,41.54 92.2,42.75 92.37,42.91 92.72,42.91 92.85,43.05 92.85,43.45 92.75,43.55 92.59,43.55 92.43,43.71 92.43,45.64 92.16,45.91 92.16,46.04 92.31,46.19 92.52,46.19 92.77,45.94 92.95,45.94 93.07,46.07 93.07,46.19 92.73,46.53 92.73,46.66 92.86,46.78 92.98,46.78 93.32,46.44 93.45,46.44 93.57,46.57 93.57,46.69 93.23,47.03 93.23,47.16 93.36,47.28 93.48,47.28 93.82,46.95 93.95,46.95 94.29,47.29 94.29,47.5 94.19,47.59 93.73,47.59 93.61,47.72 93.61,48.27 93.73,48.4 94.16,48.4 94.29,48.53 94.29,50.96 95.19,51.86 95.19,80.87 95.34,81.01 96.61,81.01 97.78,82.18 97.78,83.63 98.45,84.3 98.45,85.14 99.7,86.4 100.53,86.4 100.6,86.48 100.96,86.48 v3(101.43,86.95)
  BOTTOM w0.076: UC1.AK65 101.12,87.27 v3(101.43,86.95)
  BOTTOM w0.108: JDIMM2.41 91.27,33.38 91.27,31.67 91.09,31.48 v1(90.86,31.48)
DDR_B_D3: length 75.9
  IN1 w0.076: 94.28,74.79 94.28,75.32
  IN1 w0.089: 94.28,75.32 94.28,80.73 94.17,80.84 94.17,80.84 93.48,81.52 93.48,81.93 93.41,82 93.28,82 93.2,82.08 93.2,82.36 93.33,82.49 93.66,82.49 96.28,85.1 97.04,85.1 99.25,87.32 101.71,87.32 v3(102.08,86.96) ; 94.28,74.79 94.28,54.9 93.74,54.37 93.74,51.7 93.37,51.34 93.37,49.41 92.48,48.51 92.48,47.73 90.49,45.73 90.49,39.3 90.4,39.21 90.02,39.21 89.93,39.12 89.93,38.95 90.02,38.86 90.4,38.86 90.49,38.77 90.49,38.59 90.4,38.5 90.02,38.5 89.93,38.41 89.93,38.24 90.02,38.15 90.4,38.15 90.49,38.06 90.49,36.84 90.33,36.69 89.98,36.69 89.85,36.56 89.85,30.89 90.61,30.13 90.61,28.82 90.52,28.73 90.22,28.73 90.13,28.64 90.13,28.46 90.22,28.37 90.52,28.37 90.61,28.28 90.61,27.98 90.49,27.85 90.38,27.85 90.1,27.57 90.1,27.14 90.28,26.96 90.81,26.96 v1(91.02,27.17)
  BOTTOM w0.076: v3(102.08,86.96) 101.77,87.26 UC1.AK64
  BOTTOM w0.108: JDIMM2.38 90.52,26.67 v1(91.02,27.17)
DDR_B_D4: length 75.8
  IN1 w0.076: v3(100.19,88.79) 99.8,88.41 96.99,88.41
  IN1 w0.089: v1(87.69,27.67) 87.47,27.9 87.47,37.67 87.11,38.03 87.11,38.63 87.2,38.72 87.63,38.72 87.72,38.81 87.72,38.98 87.63,39.07 87.2,39.07 87.11,39.16 87.11,45.76 91.55,50.2 91.55,52.1 91.91,52.46 91.91,57.62 92.45,58.16 92.45,79.8 91.32,80.93 91.32,86.35 92.14,87.17 95.75,87.17 96.99,88.41
  BOTTOM w0.076: UC1.AF66 100.47,89.07 v3(100.19,88.79)
  BOTTOM w0.108: JDIMM2.24 87.02,27 v1(87.69,27.67)
DDR_B_D5: length 75.1
  IN1 w0.089: v1(87.69,27.04) 87.17,27.57 87.17,37.55 86.81,37.9 86.81,45.89 91.24,50.32 91.24,52.22 91.6,52.58 91.6,57.37 90.91,58.06 90.91,59.52 91.86,60.47 92.15,60.76 92.15,79.67 91.02,80.8 91.02,86.47 92.11,87.57 95.82,87.57 97.04,88.78 v3(99.58,88.78)
  BOTTOM w0.076: UC1.AF67 99.82,89.02 v3(99.58,88.78)
  BOTTOM w0.108: JDIMM2.28 88.02,26.72 v1(87.69,27.04)
DDR_B_D6: length 73.6
  IN1 w0.076: 94.58,74.79 94.58,75.01
  IN1 w0.089: v3(100.14,86.96) 99.14,86.96 96.96,84.77 96.46,84.77 94.17,82.49 94.17,81.88 94.19,81.86 94.19,81.85 94.4,81.64 94.4,81.64 94.58,81.46 94.58,75.01 ; 94.58,74.79 94.58,54.4 94.5,54.31 94.16,54.31 94.05,54.19 94.05,54.04 94.13,53.95 94.5,53.95 94.58,53.86 94.58,53.69 94.5,53.6 94.16,53.6 94.05,53.48 94.05,53.33 94.13,53.24 94.5,53.24 94.58,53.15 94.58,52.97 94.5,52.89 94.16,52.89 94.05,52.77 94.05,52.62 94.13,52.53 94.5,52.53 94.58,52.44 94.58,52.11 93.68,51.21 93.68,49.28 92.78,48.39 92.78,47.6 90.79,45.61 90.79,36.56 90.15,35.93 90.15,31.02 91.01,30.16 91.17,30.16 91.26,30.07 91.26,29.89 91.17,29.8 91.01,29.8 90.92,29.72 90.92,29.54 91.01,29.45 91.17,29.45 91.26,29.36 91.26,29.18 91.17,29.09 91.01,29.09 90.92,29 90.92,28.41 91.05,28.28 91.36,28.28 91.82,27.82 91.82,27.61 91.6,27.39 91.42,27.39 v1(91.02,27.8)
  BOTTOM w0.076: UC1.AK67 99.82,87.28 v3(100.14,86.96)
  BOTTOM w0.108: JDIMM2.42 91.52,27.3 v1(91.02,27.8)
DDR_B_D7: length 74.1
  IN1 w0.076: v3(100.8,86.95) 100.45,86.6 99.4,86.6 97.34,84.54
  IN1 w0.089: v1(90.86,30.87) 90.46,31.28 90.46,35.8 91.1,36.44 91.1,43.28 91.44,43.62 91.9,43.62 92.13,43.85 92.13,44.51 92.04,44.6 91.8,44.6 91.71,44.69 91.71,44.86 91.8,44.95 92.04,44.95 92.13,45.04 92.13,45.22 92.04,45.31 91.8,45.31 91.71,45.4 91.71,46.09 93.09,47.47 93.09,48.26 93.53,48.71 93.86,48.71 93.98,48.83 93.98,51.08 94.89,51.99 94.89,81.12 95.16,81.4 96.45,81.4 96.73,81.67 96.73,82.08 96.63,82.19 95.08,82.19 94.96,82.31 94.96,82.87 95.82,83.73 96,83.73 96.06,83.67 96.06,83.46 95.85,83.25 95.85,83.15 95.95,83.05 96.12,83.05 96.61,83.53 96.76,83.53 96.9,83.39 96.9,83.21 96.48,82.79 96.48,82.61 96.56,82.54 97.27,82.54 97.34,82.61 97.34,83.53 97.04,83.83 97.04,84.24 97.34,84.54
  BOTTOM w0.076: v3(100.8,86.95) 100.47,87.28 UC1.AK66
  BOTTOM w0.108: v1(90.86,30.87) 90.26,31.47 JDIMM2.37
DDR_B_D8: length 82.2
  IN1 w0.089: v1(82.23,30.6) 81.38,31.45 81.38,36.12 81.29,36.21 80.83,36.21 80.74,36.3 80.74,36.47 80.83,36.56 81.29,36.56 81.38,36.65 81.38,36.83 81.29,36.92 80.7,36.92 80.61,37.01 80.61,37.19 80.7,37.27 81.29,37.27 81.38,37.36 81.38,37.54 81.29,37.63 80.83,37.63 80.74,37.72 80.74,37.9 80.83,37.99 81.29,37.99 81.38,38.07 81.38,41 81.99,41.61 81.99,43.74 81.83,43.9 81.83,46.09 83.63,47.89 83.63,48.3 84.49,49.16 85.92,49.16 86.55,49.79 86.55,55.36 87.61,56.42 87.61,60.37 89.21,61.97 89.21,72.91 88.47,73.65 88.47,78.94 88.08,79.33 88.08,88.58 91.46,91.96 93.76,91.96 94.4,91.32 95.39,91.32 v3(95.76,91.68)
  BOTTOM w0.076: v3(95.76,91.68) 95.76,91.45 97.65,89.56 UC1.AF70
  BOTTOM w0.108: v1(82.23,30.6) 82.36,30.6 82.77,31 JDIMM2.7
DDR_B_D9: length 84.1
  IN1 w0.089: v3(96.33,91.68) 95.79,91.14 94.2,91.14 93.69,91.65 91.58,91.65 88.39,88.45 88.39,79.45 88.78,79.06 88.78,73.78 89.52,73.04 89.52,61.85 87.91,60.24 87.91,56.22 86.93,55.23 86.93,49.74 84.16,46.98 83.28,46.98 82.14,45.84 82.14,44.03 82.3,43.86 82.3,41.48 81.68,40.87 81.68,40.23 81.8,40.11 81.8,39.81 81.68,39.7 81.68,39.23 81.77,39.14 82.66,39.14 82.79,39.01 82.79,38.87 82.7,38.78 81.77,38.78 81.68,38.69 81.68,38.52 81.77,38.43 82.71,38.43 82.84,38.3 82.84,38.16 82.75,38.07 81.77,38.07 81.68,37.98 81.68,37.81 81.77,37.72 82.75,37.72 82.84,37.63 82.84,37.45 82.75,37.36 81.77,37.36 81.68,37.27 81.68,31.78 v1(82.23,31.23)
  BOTTOM w0.076: UC1.AF68 98.83,89.62 98.66,89.8 98.11,89.8
  BOTTOM w0.102: 98.11,89.8 97.56,90.36 97.35,90.36 96.63,91.08 96.63,91.38 v3(96.33,91.68)
  BOTTOM w0.108: JDIMM2.3 81.77,31.57 82.1,31.23 v1(82.23,31.23)
DDR_B_D10: length 81.4
  IN1 w0.089: v3(95.79,88.11) 95.12,88.78 91.76,88.78 89.91,86.93 89.91,80.09 90.3,79.69 90.3,79.27 90.39,79.18 90.95,79.18 91.04,79.09 91.04,78.91 90.95,78.82 90.39,78.82 90.3,78.74 90.3,78.56 90.39,78.47 90.95,78.47 91.04,78.38 91.04,78.2 90.95,78.11 90.39,78.11 90.3,78.02 90.3,77.85 90.39,77.76 90.95,77.76 91.04,77.67 91.04,77.49 90.95,77.4 90.39,77.4 90.3,77.31 90.3,77.14 90.39,77.05 90.95,77.05 91.04,76.96 91.04,76.78 90.95,76.69 90.39,76.69 90.3,76.6 90.3,76.42 90.39,76.34 90.95,76.34 91.04,76.25 91.04,76.07 90.95,75.98 90.39,75.98 90.3,75.89 90.3,74.51 90.77,74.04 91.04,73.77 91.04,61.21 90.3,60.47 89.44,59.61 89.44,51.65 88.45,50.66 88.45,49.11 85.09,45.75 85.09,38.91 85.46,38.55 85.46,29.85 85.55,29.77 85.82,29.77 85.94,29.65 85.94,29.5 85.85,29.41 85.55,29.41 85.42,29.28 85.42,29.16 85.52,29.05 85.75,29.05 85.86,28.94 85.86,28.79 85.77,28.7 85.43,28.7 85.3,28.57 85.3,28.28 v7(85.6,27.99)
  BOTTOM w0.076: UC1.AH71 95.91,88.23 v3(95.79,88.11)
  BOTTOM w0.108: v7(85.6,27.99) 85.02,27.41 JDIMM2.16
DDR_B_D11: length 84.1
  IN1 w0.076: 93.79,89.52 93.66,89.52
  IN1 w0.089: v3(95.57,89.4) 95.44,89.52 93.79,89.52 ; 93.66,89.52 92.07,89.52 89.61,87.06 89.61,79.96 90,79.57 90,74.39 90.47,73.92 90.74,73.65 90.74,61.34 90.47,61.07 89.13,59.74 89.13,56.34 89.13,52.15 88.15,51.17 88.15,49.24 84.79,45.88 84.79,45.63 84.79,45.63 84.79,39.84 84.06,39.11 84.06,38.39 84.15,38.3 84.61,38.3 84.69,38.21 84.69,38.03 84.61,37.94 84.15,37.94 84.06,37.85 84.06,37.5 84.19,37.38 84.57,37.38 85.08,36.86 85.08,31.31 84.99,31.22 84.2,31.22 84.11,31.13 84.11,30.95 84.2,30.86 84.99,30.86 85.08,30.77 85.08,30.6 84.99,30.51 84.2,30.51 84.11,30.42 84.11,30.24 84.2,30.15 84.99,30.15 85.08,30.06 85.08,29.88 84.99,29.8 84.2,29.8 84.11,29.71 84.11,29.53 84.2,29.44 84.63,29.44 84.72,29.35 84.72,27.98 v1(85.53,27.17)
  BOTTOM w0.076: UC1.AH68 99.17,88.95 98.98,89.14 98.37,89.14 98.35,89.16 98.1,89.16 97.97,89.12 97.74,89.12 97.73,89.12 97.73,89.13 97.73,89.13 97.64,89.16 97.44,89.16 97.35,89.13 97.35,89.13 96.99,89.13 96.33,89.78 95.95,89.78 v3(95.57,89.4)
  BOTTOM w0.108: JDIMM2.20 86.02,26.68 v1(85.53,27.17)
DDR_B_D12: length 81.4
  IN1 w0.089: v3(95.18,91.68) 94.3,92.57 91.21,92.57 87.47,88.83 87.47,78.6 87.72,78.36 87.72,65.7 85,62.98 85,50.43 84.35,49.77 83.49,49.77 81.94,48.22 81.94,47.19 81.22,46.47 81.22,43.65 81.38,43.48 81.38,41.86 80,40.48 80,31.12 81.49,29.63 81.49,28.16 v1(82.48,27.17)
  BOTTOM w0.076: v3(95.18,91.68) 95.33,91.54 95.33,91.44 UC1.AF71
  BOTTOM w0.108: JDIMM2.4 82.02,26.7 v1(82.48,27.17)
DDR_B_D13: length 82.8
  IN1 w0.089: v3(94.55,91.68) 93.97,92.26 91.33,92.26 87.78,88.71 87.78,79.2 88.17,78.81 88.17,73.52 88.91,72.78 88.91,62.29 87.34,60.72 87.34,60.53 87.3,60.5 87.3,56.62 86.17,55.49 86.17,50.84 84.8,49.47 84.29,49.47 83.25,48.43 83.25,47.94 81.53,46.22 81.53,43.77 81.69,43.61 81.69,41.74 80.31,40.36 80.31,31.25 81.79,29.76 81.79,28.49 v1(82.48,27.8)
  BOTTOM w0.076: 95.33,90.65 95.56,90.43 95.92,90.43 97.06,89.29 97.32,89.29 97.41,89.33 97.67,89.33 97.76,89.29 97.97,89.29 98.05,89.32 98.15,89.36 98.41,89.36 UC1.AF69
  BOTTOM w0.108: v1(82.48,27.8) 83.02,27.27 JDIMM2.8 ; v3(94.55,91.68) 94.69,91.54 94.69,91.29 95.33,90.65
DDR_B_D14: length 82.3
  IN1 w0.089: v1(86.68,30.72) 86.67,30.72 86.67,27.25 86.93,26.99 86.93,26.1 86.65,25.82 86.17,25.82 86.02,25.97 86.02,27.67 86.24,27.9 86.24,29.91 85.81,30.34 85.81,37.49 85.91,37.59 85.91,42.41 85.65,42.67 85.65,45.88 88.76,48.98 88.76,50.53 89.74,51.52 89.74,59.49 91.35,61.09 91.35,79.34 90.22,80.47 90.22,86.81 91.88,88.47 94.82,88.47 v3(95.18,88.11)
  BOTTOM w0.076: UC1.AH70 97.72,88.23 97.57,88.08 97.32,87.96 97.03,87.96 96.93,88.07 96.43,88.07 96.07,87.71 95.58,87.71 v3(95.18,88.11)
  BOTTOM w0.108: v1(86.68,30.72) 86.32,30.72 85.27,31.78 JDIMM2.17
DDR_B_D15: length 82.7
  IN1 w0.089: v3(94.61,88.11) 91.95,88.11 90.52,86.68 90.52,80.6 91.65,79.47 91.65,60.96 90.05,59.36 90.05,57.3 90.14,57.22 90.88,57.22 90.97,57.13 90.97,56.95 90.88,56.86 90.14,56.86 90.05,56.77 90.05,56.59 90.14,56.5 90.88,56.5 90.97,56.42 90.97,56.24 90.88,56.15 90.14,56.15 90.05,56.06 90.05,55.08 90.14,54.99 91.02,54.99 91.11,54.9 91.11,54.72 91.02,54.64 90.14,54.64 90.05,54.55 90.05,54.37 90.14,54.28 91.02,54.28 91.11,54.19 91.11,54.01 91.02,53.92 90.14,53.92 90.05,53.84 90.05,53.66 90.14,53.57 91.02,53.57 91.11,53.48 91.11,53.3 91.02,53.21 90.14,53.21 90.05,53.12 90.05,52.87 90.14,52.78 90.75,52.78 90.84,52.69 90.84,52.52 90.75,52.43 90.14,52.43 90.05,52.34 90.05,52.03 90.14,51.94 90.58,51.94 90.67,51.85 90.67,51.67 90.58,51.59 90.14,51.59 90.05,51.5 90.05,51.22 90.15,51.12 90.41,51.12 90.52,51.01 90.52,50.8 90.41,50.69 89.62,50.69 89.06,50.13 89.06,48.86 85.96,45.75 85.96,43.25 86.29,42.91 86.29,37.55 86.11,37.36 86.11,31.51 86.24,31.38 v1(86.72,31.38)
  BOTTOM w0.076: v3(94.61,88.11) 95.23,87.49 96.09,87.49 96.5,87.9 96.86,87.9 96.91,87.85 96.91,87.85 96.96,87.8 97.36,87.8 97.43,87.83 97.92,87.83 98.31,88.23 UC1.AH69
  BOTTOM w0.108: JDIMM2.21 86.27,31.84 v1(86.72,31.38)
DDR_B_D16: length 62.4
  IN1 w0.089: v1(92.77,31.48) 92.37,31.88 92.37,35.1 92.54,35.27 92.54,37 92.82,37.28 93.22,37.28 93.31,37.37 93.31,37.54 93.22,37.63 92.61,37.63 92.52,37.72 92.52,37.9 92.61,37.99 93.22,37.99 93.31,38.08 93.31,38.25 93.22,38.34 92.61,38.34 92.52,38.43 92.52,38.61 92.61,38.7 93.22,38.7 93.31,38.79 93.31,41.94 94.57,43.2 94.57,43.45 94.44,43.57 94.12,43.57 94.04,43.66 94.04,45.47 95.39,46.83 95.39,50.5 96.3,51.4 96.3,78.09 97.47,79.26 97.47,80.51 98.51,81.54 98.51,82.95 99.08,83.53 v3(99.9,83.53)
  BOTTOM w0.108: v1(92.77,31.48) 92.37,31.48 92.26,31.59 JDIMM2.45 ; v3(99.9,83.53) 100.11,83.53 UC1.AT66
DDR_B_D17: length 61.8
  IN1 w0.089: v1(92.77,30.85) 92.77,29.64 92.9,29.5 93.18,29.5 93.28,29.6 93.28,32.25 92.67,32.86 92.67,34.12 93.17,34.62 93.17,35.47 93.61,35.91 93.61,41.81 94.93,43.13 94.93,45.91 95.7,46.68 95.7,50.37 96.6,51.28 96.6,78.14 97.65,79.19 97.65,80.37 99.42,82.13 99.42,82.45 v3(99.93,82.97)
  BOTTOM w0.108: JDIMM2.49 93.26,32.21 93.17,32.12 93.17,31.26 v1(92.77,30.85) ; v3(99.93,82.97) 100.17,83.2 UC1.AU66
DDR_B_D18: length 64.9
  IN1 w0.076: 101.48,82.67 101.48,83.61 101.25,83.83 101.25,84.46 v3(100.89,84.82)
  IN1 w0.089: 101.48,82.67 99.25,80.44 99.25,78.25 98.41,77.41 98.41,75.92 98.17,75.68 98.17,75.11 98.43,74.85 98.43,50.29 97.53,49.39 97.53,39.34 97.44,39.25 96.78,39.25 96.66,39.13 96.66,38.95 96.76,38.84 97.44,38.84 97.53,38.75 97.53,38.57 97.4,38.44 96,38.44 95.87,38.32 95.87,38.11 95.95,38.04 96.94,38.04 97.03,37.95 97.03,37.75 96.94,37.66 95.97,37.66 95.87,37.55 95.87,37.42 96,37.29 96.37,37.29 96.44,37.22 96.44,37.06 96.51,36.99 96.92,36.99 97.01,36.9 97.01,36.72 96.92,36.63 96.63,36.63 96.54,36.55 96.54,31.81 v1(96.14,31.41)
  BOTTOM w0.108: JDIMM2.59 95.77,32.32 95.69,32.25 95.69,31.85 v1(96.14,31.41) ; v3(100.89,84.82) 101.02,84.82 UC1.AP65
DDR_B_D19: length 65.4
  IN1 w0.076: 101.66,82.6 101.66,83.68 101.44,83.9 101.44,84.94 100.9,85.48
  IN1 w0.089: 100.9,85.48 v3(100.9,85.48) ; v1(96.14,30.72) 96.14,29.39 96.4,29.12 96.63,29.12 96.84,29.33 96.84,35.81 97.34,36.3 97.34,37.44 97.83,37.94 97.83,46.33 97.92,46.42 98.15,46.42 98.24,46.51 98.24,46.69 98.15,46.78 97.92,46.78 97.83,46.87 97.83,47.04 97.92,47.13 98.15,47.13 98.24,47.22 98.24,47.4 98.15,47.49 97.92,47.49 97.83,47.58 97.83,49.26 98.74,50.16 98.74,74.8 100.02,76.08 100.02,80.96 101.66,82.6
  BOTTOM w0.108: JDIMM2.63 96.77,31.35 v1(96.14,30.72) ; UC1.AN65 101.03,85.48 v3(100.9,85.48)
DDR_B_D20: length 65
  IN1 w0.089: v1(93.02,27.14) 92.33,27.83 92.33,28.14 91.76,28.71 91.76,35.97 91.9,36.11 91.9,39.03 92.7,39.83 92.7,42.19 93.35,42.84 93.35,45.65 94.78,47.08 94.78,50.75 95.69,51.66 95.69,79.7 98.08,82.09 98.08,83.49 v3(100,85.42)
  BOTTOM w0.108: UC1.AN66 100.05,85.42 v3(100,85.42) ; v1(93.02,27.14) 92.52,26.64 JDIMM2.46
DDR_B_D21: length 64.1
  IN1 w0.089: v3(99.99,84.81) 98.25,83.07 98.25,81.67 97.09,80.51 97.09,79.99 95.99,78.9 95.99,51.53 95.09,50.63 95.09,46.95 93.66,45.53 93.66,42.72 93,42.06 93,39.71 92.2,38.9 92.2,35.98 92.06,35.84 92.06,28.84 92.63,28.26 92.63,28.13 v1(93.02,27.75)
  BOTTOM w0.108: JDIMM2.50 93.52,27.25 v1(93.02,27.75) ; v3(99.99,84.81) 100.1,84.81 UC1.AP66
DDR_B_D22: length 63.4
  IN1 w0.076: v3(100.93,83.55) 101.31,83.18 101.31,82.74 98.97,80.4 98.97,78.45 98,77.48 98,74.97 98.13,74.84
  IN1 w0.089: 98.13,74.84 98.13,50.42 97.22,49.51 97.22,41.76 96.51,41.04 96.51,39.41 95.49,38.4 95.49,37.37 96.23,36.63 96.23,35.38 95.57,34.72 95.57,34.04 95.65,33.95 95.98,33.95 96.07,33.86 96.07,33.68 95.98,33.59 95.65,33.59 95.57,33.5 95.57,28.25 v1(96.02,27.8)
  BOTTOM w0.108: JDIMM2.58 95.52,27.3 v1(96.02,27.8) ; UC1.AT65 101.05,83.55 v3(100.93,83.55)
DDR_B_D23: length 63.3
  IN1 w0.089: v3(100.93,82.87) 100.93,82.74 98.7,80.52 98.7,79.23 98.23,78.75 98.23,78.07 97.7,77.53 97.7,74.99 97.82,74.87 97.82,50.68 96.92,49.78 96.92,46.17 96.34,45.59 96.34,43.84 96.56,43.63 96.78,43.63 96.92,43.49 96.92,41.93 96.53,41.54 95.72,41.54 95.54,41.36 95.54,38.87 95.19,38.52 95.19,37.24 95.93,36.5 95.93,35.54 95.26,34.87 95.26,27.34 95.44,27.17 v1(96.02,27.17)
  BOTTOM w0.108: JDIMM2.62 96.52,26.67 v1(96.02,27.17) ; UC1.AU65 101.02,82.87 v3(100.93,82.87)
DDR_B_D24: length 61.6
  IN1 w0.076: 102.25,82.9 102.74,83.39
  IN1 w0.089: 102.25,82.9 102.25,82.43 100.56,80.74 100.56,75.59 99.84,74.88 99.84,49.12 99.34,48.62 99.34,43.06 98.94,42.66 98.94,35.57 97.95,34.58 97.95,32.39 98.07,32.27 98.32,32.27 98.55,32.03 98.55,31.47 98.44,31.36 98.25,31.36 98.16,31.27 98.16,30.63 98.32,30.47 99.08,30.47 99.25,30.63 v1(99.25,30.85) ; 102.74,83.39 v3(102.74,83.53)
  BOTTOM w0.108: UC1.AT61 102.86,83.53 v3(102.74,83.53) ; v1(99.25,30.85) 98.05,30.85 97.55,31.36 97.55,31.99 97.77,32.21 JDIMM2.67
DDR_B_D25: length 61.3
  IN1 w0.089: v1(99.25,31.48) 98.86,31.88 98.86,32.5 98.73,32.63 98.34,32.63 98.25,32.72 98.25,32.93 98.37,33.05 99.01,33.05 99.25,33.29 99.25,33.52 99.17,33.59 98.56,33.59 98.51,33.64 98.51,33.99 98.6,34.07 99.15,34.07 99.25,34.18 99.25,42.53 99.76,43.04 99.76,45.41 99.96,45.61 99.96,47.93 100.14,48.11 100.14,48.44 99.96,48.63 99.96,48.81 100.15,48.99 100.15,74.82 100.91,75.58 100.91,79.4 101.3,79.78 101.3,79.91 100.9,80.3 100.9,80.43 101.03,80.56 101.15,80.56 101.55,80.16 101.67,80.16 101.8,80.29 101.8,80.41 101.4,80.81 101.4,80.93 101.53,81.06 101.65,81.06 102.05,80.66 102.18,80.66 102.36,80.85 102.36,80.98 101.92,81.42 101.92,81.6 102.42,82.11 102.42,82.57 v3(102.75,82.9)
  BOTTOM w0.108: v3(102.75,82.9) 102.88,82.9 UC1.AU61 ; JDIMM2.71 98.77,31.97 v1(99.25,31.48)
DDR_B_D26: length 63.8
  IN1 w0.076: 104.4,82.44 104.4,82.96 104.04,83.32 104.04,84.44 v3(103.66,84.82)
  IN1 w0.089: v1(101.28,30.85) 101.28,29.43 101.84,28.87 102.12,28.87 102.5,29.25 102.5,31.33 101.97,31.86 101.97,33.67 101.93,33.7 101.93,42.07 102.4,42.53 102.4,48.56 101.98,48.98 101.98,75.23 102.1,75.36 103.07,76.32 103.07,79.96 104.4,81.29 104.4,82.44
  BOTTOM w0.108: JDIMM2.83 101.77,31.33 v1(101.28,30.85) ; UC1.AP60 103.77,84.82 v3(103.66,84.82)
DDR_B_D27: length 64
  IN1 w0.076: 104.22,84.93 104.22,83.37 104.65,82.94
  IN1 w0.089: v3(103.66,85.48) 103.66,85.48 104.22,84.93 ; v1(101.52,27.78) 102.25,27.78 102.8,28.33 102.8,34.04 102.24,34.6 102.24,41.94 102.7,42.41 102.7,48.69 102.28,49.11 102.28,75.28 103.25,76.25 103.25,79.89 104.65,81.29 104.65,82.94
  BOTTOM w0.108: v3(103.66,85.48) 103.78,85.48 UC1.AN60 ; v1(101.52,27.78) 102.02,27.28 JDIMM2.84
DDR_B_D28: length 63.6
  IN1 w0.076: 101.89,82.58 101.89,83.09 102.18,83.38 102.18,84.92 v3(102.74,85.48)
  IN1 w0.089: v1(98.02,27.09) 97.34,27.77 97.34,35.6 97.83,36.09 97.83,37.24 98.33,37.74 98.33,42.91 98.73,43.31 98.73,49.23 99.23,49.73 99.23,74.84 100.2,75.81 100.2,80.89 101.89,82.58
  BOTTOM w0.108: UC1.AN61 102.86,85.48 v3(102.74,85.48) ; v1(98.02,27.09) 97.52,26.59 JDIMM2.66
DDR_B_D29: length 62.7
  IN1 w0.076: v3(102.74,84.82) 102.35,84.44 102.35,83.32 102.07,83.04 102.07,82.5
  IN1 w0.089: v1(98.02,27.71) 97.64,28.08 97.64,35.47 98.64,36.47 98.64,42.79 99.04,43.19 99.04,49.05 99.54,49.55 99.54,74.84 100.38,75.68 100.38,80.81 102.07,82.5
  BOTTOM w0.108: JDIMM2.70 98.52,27.21 v1(98.02,27.71) ; UC1.AP61 102.85,84.82 v3(102.74,84.82)
DDR_B_D30: length 63.3
  IN1 w0.076: 103.66,83.42 104.02,83.07 104.02,82.62
  IN1 w0.089: 104.02,82.62 104.02,81.16 102.89,80.04 102.89,76.4 101.67,75.18 101.67,48.85 102.09,48.43 102.09,42.66 101.13,41.7 101.13,35.31 101.22,35.22 101.54,35.22 101.63,35.13 101.63,34.96 101.54,34.87 101.22,34.87 101.13,34.78 101.13,34.4 101.22,34.31 101.54,34.31 101.63,34.22 101.63,34.05 101.54,33.96 101.22,33.96 101.13,33.87 101.13,33.63 101.26,33.5 101.6,33.5 101.67,33.44 101.67,33.26 101.58,33.17 101.22,33.17 101.13,33.08 101.13,32.9 101.22,32.81 101.58,32.81 101.67,32.72 101.67,31.73 102.12,31.28 102.12,29.86 102.02,29.76 101.84,29.76 101.74,29.86 101.74,31.03 v1(101.28,31.48) ; v3(103.66,83.53) 103.66,83.42
  BOTTOM w0.108: v3(103.66,83.53) 103.77,83.53 UC1.AT60 ; v1(101.28,31.48) 100.86,31.91 100.86,32.21 100.77,32.3 JDIMM2.79
DDR_B_D31: length 62.3
  IN1 w0.089: v3(103.66,82.87) 103.66,81.06 102.5,79.9 102.5,79.1 102.13,78.73 102.13,75.89 101.37,75.13 101.37,48.73 101.79,48.31 101.79,42.79 100.83,41.83 100.83,29.84 100.39,29.4 100.39,29.02 100.57,28.84 101.18,28.84 101.25,28.77 101.25,28.53 101,28.28 100.54,28.28 100.39,28.13 100.39,27.73 100.95,27.17 v1(101.52,27.17)
  BOTTOM w0.108: v1(101.52,27.17) 101.02,26.67 JDIMM2.80 ; v3(103.66,82.87) 103.76,82.87 UC1.AU60
DDR_B_D32: length 65.1
  IN1 w0.089: v1(125.01,27.51) 126.53,29.02 126.53,32.53 125.87,33.19 125.87,38.62 126.53,39.28 126.53,43.24 127.18,43.89 127.18,51.32 119.95,58.55 119.95,60.89 119.31,61.52 119.31,72.29 118.95,72.65 118.95,74.77 118.58,75.14 118.58,78.28 115.56,81.3 115.56,81.92 v3(114.61,82.87)
  BOTTOM w0.108: UC1.AU40 114.73,82.87 v3(114.61,82.87) ; JDIMM2.170 125.52,27.01 v1(125.01,27.51)
DDR_B_D33: length 66
  IN1 w0.076: v3(114.61,83.5) 114.61,83.37 114.25,83.01 114.25,82.03
  IN1 w0.089: v1(125.01,28.18) 126.22,29.39 126.22,32.4 125.56,33.06 125.56,38.75 126.22,39.41 126.22,43.62 126.37,43.76 126.37,51.7 119,59.06 119,72.16 118.65,72.51 118.65,74.68 118.4,74.92 118.4,78.21 115.21,81.4 114.89,81.4 114.25,82.03
  BOTTOM w0.076: UC1.AT40 114.78,83.63 v3(114.61,83.5)
  BOTTOM w0.108: JDIMM2.174 126.52,26.7 125.03,28.18 v1(125.01,28.18)
DDR_B_D34: length 66.7
  IN1 w0.076: v3(116.44,83.5) 116.44,83.39 116.83,83.01 116.83,81.78 116.83,81.77 116.83,81.57 118.59,79.81 118.89,79.81 120.46,78.24 120.46,77.34 120.54,77.26 120.54,75.07 120.49,75.02
  IN1 w0.089: v1(129.01,27.75) 128.37,28.39 128.37,37.77 128.59,37.98 128.59,42.1 129.48,43 129.48,45.78 128.79,46.47 128.79,47.72 128.88,47.8 128.98,47.8 129.07,47.89 129.07,48.07 128.98,48.16 128.88,48.16 128.79,48.25 128.79,48.43 128.88,48.52 128.98,48.52 129.07,48.6 129.07,48.78 128.98,48.87 128.88,48.87 128.79,48.96 128.79,49.42 129.48,50.11 129.48,51.17 121.47,59.18 121.47,61.52 120.83,62.16 120.83,72.97 120.48,73.32 120.48,75 120.49,75.02
  BOTTOM w0.076: v3(116.44,83.5) 116.71,83.71 UC1.AT37
  BOTTOM w0.108: JDIMM2.182 128.52,27.25 v1(129.01,27.75)
DDR_B_D35: length 66.2
  IN1 w0.076: 120.3,75.17 120.38,75.25 120.38,77.2 120.3,77.27 120.3,78.17 118.82,79.65 118.52,79.65 116.67,81.5 116.67,81.7 116.66,81.71 116.66,82.63 v3(116.44,82.85)
  IN1 w0.089: v1(129.01,27.09) 128.07,28.04 128.07,37.9 128.16,37.99 128.16,42.1 129.18,43.12 129.18,45.55 128.4,46.33 128.4,50.08 128.48,50.17 128.62,50.17 128.71,50.25 128.71,50.47 128.66,50.52 128.48,50.52 128.4,50.61 128.4,50.79 128.48,50.88 128.8,50.88 128.89,50.97 128.89,51.14 128.8,51.23 128.48,51.23 128.4,51.32 128.4,51.83 121.17,59.05 121.17,61.39 120.53,62.03 120.53,72.84 120.17,73.2 120.17,75.04 120.3,75.17
  BOTTOM w0.076: UC1.AU37 v3(116.44,82.85)
  BOTTOM w0.108: v1(129.01,27.09) 129.52,26.59 JDIMM2.186
DDR_B_D36: length 66.6
  IN1 w0.076: v7(114.61,84.16) 114.25,83.78 114.25,83.3 114,83.05
  IN1 w0.089: v1(125.82,31.48) 125.51,31.48 125.42,31.57 125.42,32.75 125.13,33.05 125.13,38.75 125.92,39.54 125.92,41.48 125.83,41.57 125.35,41.57 125.26,41.66 125.26,41.84 125.35,41.93 125.83,41.93 125.92,42.02 125.92,42.2 125.83,42.28 125.35,42.28 125.26,42.37 125.26,42.55 125.35,42.64 125.83,42.64 125.92,42.73 125.92,42.91 125.83,43 125.35,43 125.26,43.08 125.26,43.26 125.35,43.35 125.83,43.35 125.92,43.44 125.92,43.75 126.06,43.89 126.06,50 125.98,50.09 125.66,50.09 125.57,50.18 125.57,50.36 125.66,50.45 125.98,50.45 126.06,50.54 126.06,50.71 125.98,50.8 125.66,50.8 125.57,50.89 125.57,51.07 125.66,51.16 125.98,51.16 126.06,51.25 126.06,51.57 118.7,58.94 118.7,72.03 118.34,72.39 118.34,74.55 118.22,74.67 118.22,78.13 115.14,81.22 114.68,81.22 114,81.9 114,83.05
  BOTTOM w0.076: UC1.AR40 v7(114.61,84.16)
  BOTTOM w0.108: v1(125.82,31.48) 126.27,31.93 JDIMM2.173
DDR_B_D37: length 67.1
  IN1 w0.076: 114.05,83.37 114.05,84.24 v3(114.61,84.82)
  IN1 w0.089: 114.05,83.37 113.82,83.14 113.82,81.49 117.38,77.93 117.38,75.39 117.92,74.85 117.92,72.38 118.39,71.9 118.39,58.81 125.26,51.94 125.26,51.11 125.18,51.02 124.81,51.02 124.72,50.93 124.72,50.75 124.81,50.67 125.18,50.67 125.26,50.58 125.26,43.76 124.96,43.46 124.96,39.54 124.5,39.08 124.5,38.57 124.37,38.44 123.87,38.44 123.75,38.32 123.75,38.13 123.91,37.96 124.65,37.96 124.75,37.86 124.75,37.61 124.65,37.5 123.82,37.5 123.75,37.43 123.75,37.24 124.83,36.17 124.83,32.92 125.12,32.63 125.12,31.04 125.31,30.85 v1(125.82,30.85)
  BOTTOM w0.108: UC1.AP40 114.74,84.82 v3(114.61,84.82) ; JDIMM2.169 125.27,31.41 v1(125.82,30.85)
DDR_B_D38: length 68.4
  IN1 w0.076: v3(116.44,84.8) 117,84.24 117,83.3 117.16,83.14 117.16,81.7 118.63,80.23 119.26,80.23
  IN1 w0.089: 119.26,80.23 119.78,80.23 120.57,79.44 120.57,78.77 120.8,78.54 120.8,77.48 120.88,77.4 120.88,75.57 121.09,75.36 121.09,73.58 121.44,73.22 121.44,62.41 122.69,61.16 122.69,58.82 130.09,51.42 130.09,50.9 130.18,50.81 130.53,50.81 130.62,50.72 130.62,50.54 130.53,50.45 130.18,50.45 130.09,50.36 130.09,50.19 130.18,50.1 130.53,50.1 130.62,50.01 130.62,49.83 130.53,49.74 130.18,49.74 130.09,49.65 130.09,49.47 130.18,49.39 130.53,49.39 130.62,49.3 130.62,49.12 130.53,49.03 130.18,49.03 130.09,48.94 130.09,48.76 130.18,48.67 130.53,48.67 130.62,48.59 130.62,48.41 130.53,48.32 130.18,48.32 130.09,48.23 130.09,48.05 130.18,47.96 130.53,47.96 130.62,47.87 130.62,47.7 130.53,47.61 130.18,47.61 130.09,47.52 130.09,38.63 128.98,37.52 128.98,34.64 129.07,34.55 129.28,34.55 129.37,34.47 129.37,34.29 129.28,34.2 129.07,34.2 128.98,34.11 128.98,33.93 129.07,33.84 129.28,33.84 129.37,33.75 129.37,33.58 129.28,33.49 129.07,33.49 128.98,33.4 128.98,31.88 v1(129.38,31.48)
  BOTTOM w0.108: JDIMM2.183 128.77,32.1 v1(129.38,31.48) ; v3(116.44,84.8) UC1.AP37
DDR_B_D39: length 67.6
  IN1 w0.076: v3(116.44,84.14) 116.82,83.76 116.82,83.25 117,83.07 117,81.63 118.66,79.98 119.79,79.98 120.4,79.37 120.4,78.7 120.63,78.47 120.63,77.41 120.71,77.33 120.71,75.5 120.78,75.43 120.78,74.79
  IN1 w0.089: v1(129.38,30.85) 128.97,30.85 128.68,31.14 128.68,37.64 128.89,37.86 128.89,38.52 128.99,38.62 129.63,38.62 129.7,38.7 129.7,38.88 129.58,39 129.02,39 128.89,39.13 128.89,39.36 129,39.47 129.18,39.47 129.7,39.47 129.79,39.56 129.79,39.73 129.7,39.82 129.56,39.82 129.47,39.91 129.47,40.09 129.56,40.18 129.7,40.18 129.79,40.27 129.79,40.44 129.7,40.53 129.56,40.53 129.47,40.62 129.47,40.8 129.56,40.89 129.7,40.89 129.79,40.98 129.79,41.16 129.7,41.25 129.56,41.25 129.47,41.33 129.47,41.51 129.56,41.6 129.7,41.6 129.79,41.69 129.79,41.87 129.7,41.96 129.29,41.96 129.17,42.08 129.17,42.25 129.79,42.87 129.79,51.3 122.39,58.7 122.39,61.03 121.14,62.28 121.14,73.09 120.78,73.45 120.78,74.79
  BOTTOM w0.076: UC1.AR37 v3(116.44,84.14)
  BOTTOM w0.108: v1(129.38,30.85) 129.86,31.32 129.86,32.27 129.77,32.36 JDIMM2.187
DDR_B_D40: length 67
  IN1 w0.076: v3(118.27,83.5) 118.06,83.3 118.06,83.17 117.91,83.01 117.91,82.47 119.65,80.73 120.27,80.73 121.08,79.93 121.08,79 121.24,78.83
  IN1 w0.089: 121.24,78.83 121.41,78.67 121.74,78.67 122.08,78.32 122.08,75.67 122.19,75.57 122.19,74.03 122.55,73.68 122.55,72.6 123.04,72.1 123.04,62.37 123.8,61.62 123.8,59.28 131.93,51.15 131.93,41.51 131.61,41.19 131.61,38.58 130.49,37.45 130.49,29.47 130.63,29.33 131.02,29.33 131.23,29.53 131.23,29.73 130.92,30.03 130.92,30.6 131.05,30.72 v1(131.27,30.72)
  BOTTOM w0.076: UC1.AT33 118.5,83.68 118.44,83.63 118.33,83.55 v3(118.27,83.5)
  BOTTOM w0.108: v1(131.27,30.72) 131.77,31.22 JDIMM2.195
DDR_B_D41: length 67.1
  IN1 w0.089: v1(131.27,31.36) 130.94,31.36 130.8,31.5 130.8,33.64 130.88,33.73 131.39,33.73 131.48,33.82 131.48,34 131.39,34.09 130.88,34.09 130.8,34.18 130.8,34.35 130.88,34.44 131.39,34.44 131.48,34.53 131.48,34.71 131.39,34.8 130.88,34.8 130.8,34.89 130.8,35.07 130.88,35.15 131.39,35.15 131.48,35.24 131.48,35.42 131.39,35.51 130.88,35.51 130.8,35.6 130.8,35.78 130.88,35.87 131.39,35.87 131.48,35.95 131.48,36.13 131.39,36.22 130.88,36.22 130.8,36.31 130.8,36.49 130.88,36.58 131.27,36.58 131.35,36.67 131.35,36.84 131.27,36.93 130.88,36.93 130.8,37.02 130.8,37.33 132.41,38.95 132.41,41.15 132.38,41.19 132.38,51.13 124.1,59.41 124.1,61.75 123.35,62.5 123.35,72.23 122.85,72.72 122.85,73.8 122.5,74.16 122.5,75.51 122.26,75.75 122.26,78.39 121.9,78.76 121.9,79.35 120.34,80.91 119.72,80.91 118.27,82.35 v3(118.27,82.87)
  BOTTOM w0.076: UC1.AU33 118.55,83.07 118.5,83.04 118.33,82.91 v3(118.27,82.87)
  BOTTOM w0.108: JDIMM2.191 130.77,31.86 v1(131.27,31.36)
DDR_B_D42: length 66.1
  IN1 w0.076: 123.23,79.22 123.23,79.55 121.07,81.71 121.07,82.36 v3(120.77,82.66)
  IN1 w0.089: v1(134.48,31.48) 134.3,31.48 134.08,31.71 134.08,32.57 134.17,32.66 134.36,32.66 134.45,32.75 134.45,32.92 134.36,33.01 134.17,33.01 134.08,33.1 134.08,33.28 134.17,33.37 134.36,33.37 134.45,33.46 134.45,33.63 134.36,33.72 134.17,33.72 134.08,33.81 134.08,33.99 134.17,34.08 134.36,34.08 134.45,34.17 134.45,34.35 134.36,34.43 134.17,34.43 134.08,34.52 134.08,34.7 134.17,34.79 134.36,34.79 134.45,34.88 134.45,35.06 134.36,35.15 134.17,35.15 134.08,35.23 134.08,35.54 134.17,35.63 134.37,35.63 134.46,35.72 134.46,35.89 134.37,35.98 134.17,35.98 134.08,36.07 134.08,37.59 135.49,39 135.49,41.68 135.58,41.77 135.88,41.77 135.97,41.86 135.97,42.03 135.88,42.12 135.58,42.12 135.49,42.21 135.49,42.39 135.58,42.48 135.88,42.48 135.97,42.57 135.97,42.75 135.88,42.83 135.58,42.83 135.49,42.92 135.49,43.1 135.58,43.19 135.88,43.19 135.97,43.28 135.97,43.46 135.88,43.55 135.58,43.55 135.49,43.63 135.49,52.52 127.31,60.7 127.31,61.55 125.51,63.35 125.51,73.08 125.16,73.43 125.16,77.67 124.03,78.81 123.64,78.81 123.23,79.22
  BOTTOM w0.076: UC1.AU30 120.55,82.88 v3(120.77,82.66)
  BOTTOM w0.108: JDIMM2.207 134.77,32.41 134.89,32.29 134.89,31.89 v1(134.48,31.48)
DDR_B_D43: length 66.4
  IN1 w0.076: 123.82,74.79 123.82,75.41 123.96,75.55 123.96,77.75 122.48,79.23 122.48,79.59 120.41,81.65 120.41,82.04 120.08,82.37 120.08,83.03 120.1,83.04 v7(120.1,83.5)
  IN1 w0.089: 123.82,74.79 123.82,74.56 124.07,74.31 124.07,73.23 124.58,72.72 124.58,62.99 125.62,61.95 125.62,61.02 134.57,52.07 134.57,39.38 133.17,37.97 133.17,28.45 v1(134.52,27.1)
  BOTTOM w0.108: UC1.AT30 120.21,83.5 v7(120.1,83.5) ; v1(134.52,27.1) 135.02,26.6 JDIMM2.208
DDR_B_D44: length 68.2
  IN1 w0.076: v7(118.27,84.16) 118.27,84.14 117.9,83.77 117.9,83.31 117.75,83.16 117.75,82.4 119.58,80.57 120.2,80.57 120.91,79.86 120.91,78.91 121.91,77.91 121.91,74.94 121.89,74.92 121.89,74.79
  IN1 w0.089: 121.89,74.79 121.89,73.91 122.24,73.55 122.24,62.74 123.49,61.49 123.49,59.16 131.63,51.02 131.63,41.63 131.31,41.31 131.31,38.71 130.19,37.59 130.19,28.89 130.29,28.79 130.72,28.79 130.82,28.69 130.82,28.45 130.71,28.33 130.47,28.33 130.33,28.2 130.33,27.91 130.44,27.8 v1(131.02,27.8)
  BOTTOM w0.108: v1(131.02,27.8) 131.42,27.39 131.42,26.7 131.52,26.61 JDIMM2.194 ; v7(118.27,84.16) UC1.AR33
DDR_B_D45: length 68.7
  IN1 w0.076: 121.58,75.11 121.05,75.64 121.05,76.63 121.63,77.2 121.63,77.96 120.74,78.84 120.74,79.51 119.85,80.4 119.51,80.4 117.58,82.33 117.58,83.23 117.73,83.38 117.73,84.26 118.27,84.8 v3(118.27,84.82)
  IN1 w0.089: v1(131.02,27.17) 130.08,27.17 129.88,27.37 129.88,37.71 130.89,38.72 130.89,41.33 131.32,41.76 131.32,50.89 123.19,59.03 123.19,61.37 121.94,62.61 121.94,73.42 121.58,73.78 121.58,75.11
  BOTTOM w0.108: UC1.AP33 v3(118.27,84.82) ; v1(131.02,27.17) 130.52,26.67 JDIMM2.190
DDR_B_D46: length 67.1
  IN1 w0.076: v3(120.1,84.18) 120.48,83.81 120.48,83.11 120.25,82.88 120.25,82.44 120.64,82.05 120.64,81.66 122.65,79.65 122.65,79.3
  IN1 w0.089: v1(134.51,27.71) 133.47,28.75 133.47,37.84 134.88,39.25 134.88,52.27 126.7,60.44 126.7,61.3 124.89,63.11 124.89,72.84 124.38,73.36 124.38,74.44 124.13,74.68 124.13,77.82 122.65,79.3
  BOTTOM w0.108: v1(134.51,27.71) 134.02,27.22 JDIMM2.204 ; v3(120.1,84.18) 120.24,84.18 UC1.AR30
DDR_B_D47: length 67.7
  IN1 w0.076: 121.49,81.05 120.84,81.7 120.84,82.08 120.41,82.51 120.41,82.81 120.64,83.04 120.64,84.28 v3(120.1,84.82)
  IN1 w0.089: v1(134.48,30.85) 134.3,30.67 134.3,29.58 134.07,29.35 133.97,29.35 133.77,29.55 133.77,37.72 135.18,39.12 135.18,52.39 127,60.57 127,61.43 125.19,63.24 125.19,72.97 124.68,73.48 124.68,74.56 124.43,74.81 124.43,77.76 122.82,79.38 122.82,79.72 121.49,81.05
  BOTTOM w0.108: JDIMM2.203 133.77,31.56 v1(134.48,30.85) ; UC1.AP30 v3(120.1,84.82)
DDR_B_D48: length 68.9
  IN1 w0.076: 124.95,78.87 124.78,79.05 124.78,79.42 124.06,80.13 123.58,80.13 121.92,81.79 v3(121.92,82.85)
  IN1 w0.089: v1(136.27,31.36) 135.87,31.76 135.87,32.94 136,33.07 136.13,33.07 136.26,33.2 136.26,33.39 136.13,33.52 136,33.52 135.87,33.65 135.87,33.83 136,33.96 136.13,33.96 136.26,34.09 136.26,34.28 136.13,34.41 136,34.41 135.87,34.54 135.87,37.36 137.4,38.89 137.4,42.02 137.53,42.15 138.29,42.15 138.42,42.28 138.42,42.46 138.29,42.59 137.6,42.59 137.53,42.67 137.53,43.04 137.6,43.12 138.29,43.12 138.42,43.25 138.42,45.73 138.29,45.86 137.8,45.86 137.73,45.94 137.73,46.29 137.8,46.36 138.29,46.36 138.42,46.49 138.42,46.68 138.29,46.81 137.71,46.81 137.58,46.93 137.58,47.11 137.71,47.24 138.25,47.24 138.38,47.37 138.38,47.55 138.24,47.68 137.71,47.68 137.58,47.81 137.58,52.42 128.74,61.26 128.74,62.69 127.52,63.92 127.52,73.61 126.92,74.21 126.92,74.98 126.6,75.3 126.6,78.09 126.18,78.5 125.82,78.87 124.95,78.87
  BOTTOM w0.108: v3(121.92,82.85) 122.03,82.85 UC1.AU27 ; v1(136.27,31.36) 135.77,31.86 JDIMM2.211
DDR_B_D49: length 69.3
  IN1 w0.076: v3(121.92,83.53) 121.92,83.4 121.57,83.04 121.57,81.91 123.51,79.97 124,79.97 124.61,79.35 124.61,78.97 125.87,77.71 125.87,75.43 126.34,74.96
  IN1 w0.089: 126.34,74.96 126.62,74.68 126.62,74.08 127.21,73.49 127.21,63.64 128.44,62.41 128.44,61.13 137.27,52.3 137.27,45.88 137.66,45.49 137.66,43.89 137.09,43.32 137.09,39.01 135.56,37.48 135.56,28.82 135.84,28.54 136.31,28.54 136.46,28.69 136.46,29.08 136.27,29.27 v1(136.27,30.72)
  BOTTOM w0.108: JDIMM2.215 136.77,32.3 136.68,32.21 136.68,31.13 v1(136.27,30.72) ; v3(121.92,83.53) 122.06,83.53 UC1.AT27
DDR_B_D50: length 68.5
  IN1 w0.076: 127.39,77.78 127.39,78.25 126.29,79.35 126.29,79.58 125.3,80.57 124.61,80.57 123.43,81.74 123.43,82.78 122.84,83.37 v3(122.84,83.53)
  IN1 w0.089: 127.39,77.78 127.39,77.13 129.32,75.2 129.32,73.78 130.46,72.64 130.46,61.64 139.95,52.16 139.95,46.37 140.26,46.06 140.26,40.37 139.92,40.03 139.92,39.21 138.08,37.37 138.08,32.78 138.24,32.63 138.24,28.94 139.13,28.06 v1(139.52,28.06)
  BOTTOM w0.108: JDIMM2.228 140.02,27.55 v1(139.52,28.06) ; UC1.AT25 122.97,83.53 v3(122.84,83.53)
DDR_B_D51: length 67.8
  IN1 w0.076: 127.21,78.19 127.21,78.2 126.13,79.28 126.13,79.51 125.24,80.4 124.54,80.4 123.26,81.68 123.26,82.44 v3(122.84,82.87)
  IN1 w0.089: 127.21,78.19 127.21,77 129.01,75.2 129.01,71.82 129.1,71.74 129.1,65.17 130.01,64.26 130.01,61.66 139.64,52.03 139.64,46.24 139.95,45.93 139.95,40.75 139.11,39.91 139.11,38.84 137.78,37.5 137.78,32.66 137.93,32.5 137.93,28.69 139.2,27.42 v1(139.52,27.42)
  BOTTOM w0.108: v1(139.52,27.42) 139.02,26.92 JDIMM2.224 ; v3(122.84,82.87) 122.96,82.87 UC1.AU25
DDR_B_D52: length 69.6
  IN1 w0.076: v3(121.93,84.82) 121.54,84.44 121.54,83.29 121.4,83.15 121.4,81.84 123.44,79.8 123.93,79.8 124.45,79.28 124.45,78.9 125.71,77.64 125.71,75.25 126.04,74.92
  IN1 w0.089: v1(136.52,27.8) 136.21,27.5 135.57,27.5 135.26,27.81 135.26,37.61 136.77,39.12 136.77,47.29 136.97,47.49 136.97,52.17 128.13,61 128.13,62.16 126.91,63.39 126.91,73.36 126.31,73.95 126.31,74.49 126.04,74.77 126.04,74.92
  BOTTOM w0.108: UC1.AP27 122.05,84.82 v3(121.93,84.82) ; JDIMM2.216 137.02,27.3 v1(136.52,27.8)
DDR_B_D53: length 70.2
  IN1 w0.076: 125.54,75.04 125.34,75.25 125.34,77.78 124.13,78.98 123.71,78.98 123.39,79.3 123.39,79.62 121.24,81.78 121.24,83.22 121.38,83.36 121.38,84.93 v3(121.93,85.48)
  IN1 w0.089: 125.54,75.04 125.66,74.92 125.66,74.71 126.01,74.37 126.01,73.83 126.6,73.23 126.6,62.96 127.83,61.73 127.83,60.88 136.66,52.04 136.66,47.88 136.47,47.68 136.47,39.25 134.95,37.74 134.95,27.55 135.52,26.99 136.34,26.99 v1(136.52,27.17)
  BOTTOM w0.108: v3(121.93,85.48) 122.06,85.48 UC1.AN27 ; JDIMM2.212 136.02,26.67 v1(136.52,27.17)
DDR_B_D54: length 70.4
  IN1 w0.076: 129.99,75.27 128.46,76.8 128.46,78 128.27,78.19 128.27,78.65 127.02,79.9 126.45,79.9 125.44,80.9 124.74,80.9 123.79,81.85 123.79,82.88 123.37,83.3 123.37,84.95 v3(122.84,85.48)
  IN1 w0.089: 129.99,75.27 129.99,74.59 131.07,73.51 131.07,61.9 140.56,52.41 140.56,46.62 140.87,46.31 140.87,42.85 140.96,42.76 141.3,42.76 141.39,42.67 141.39,42.49 141.3,42.4 140.96,42.4 140.87,42.31 140.87,42.14 140.96,42.05 141.3,42.05 141.39,41.96 141.39,41.78 141.3,41.69 140.96,41.69 140.87,41.6 140.87,40.06 141.02,39.9 141.02,39.45 139.25,37.68 139.25,34.92 139.47,34.71 139.47,30.85 139.34,30.72 v1(138.77,30.72)
  BOTTOM w0.108: v1(138.77,30.72) 139.38,30.72 140.27,31.61 JDIMM2.229 ; v3(122.84,85.48) 122.98,85.48 UC1.AN25
DDR_B_D55: length 69.1
  IN1 w0.076: 127.54,78.34 126.46,79.42 126.46,79.65 125.37,80.73 124.67,80.73 123.6,81.81 123.6,82.84 123.21,83.24 123.21,84.45 v3(122.84,84.82)
  IN1 w0.089: v1(138.77,31.34) 139.04,31.34 139.17,31.47 139.17,32.39 139,32.55 138.64,32.55 138.58,32.61 138.58,32.82 138.69,32.93 139.08,32.93 139.17,33.02 139.17,33.17 139,33.34 138.49,33.34 138.39,33.44 138.39,33.64 138.49,33.74 139.05,33.74 139.13,33.82 139.13,34.02 139.03,34.13 138.44,34.13 138.39,34.18 138.39,34.4 138.47,34.48 138.82,34.48 138.95,34.61 138.95,35.35 138.82,35.48 138.52,35.48 138.39,35.61 138.39,35.8 138.52,35.93 138.82,35.93 138.95,36.06 138.95,37.81 140.22,39.08 140.22,39.9 140.56,40.25 140.56,46.18 140.25,46.49 140.25,52.28 130.76,61.77 130.76,73.38 129.62,74.53 129.62,75.15 127.65,77.12 127.65,78.23 127.54,78.34
  BOTTOM w0.108: UC1.AP25 122.97,84.82 v3(122.84,84.82) ; v1(138.77,31.34) 139.27,31.84 JDIMM2.225
DDR_B_D56: length 72.7
  IN1 w0.076: v3(124.67,83.53) 124.67,83.35 124.31,83 124.31,82.03 124.85,81.49 125.55,81.49 126.65,80.39 127.22,80.39 128.77,78.84 128.77,78.39 130.15,77.01 130.15,76.53 131.05,75.63 131.05,75.09 131.35,74.79
  IN1 w0.089: v1(141.77,30.72) 141.77,28.61 141.68,28.52 141.42,28.52 141.29,28.66 141.29,29.26 141.16,29.39 140.83,29.39 140.7,29.52 140.7,29.7 140.83,29.83 141.16,29.83 141.29,29.96 141.29,30.14 141.16,30.28 140.83,30.28 140.7,30.41 140.7,30.59 140.83,30.72 141.16,30.72 141.29,30.85 141.29,31.41 140.78,31.92 140.78,36.95 143.22,39.4 143.22,41.29 142.58,41.93 142.58,48.3 141.66,49.22 141.66,52.87 132.17,62.36 132.17,73.97 131.35,74.79
  BOTTOM w0.108: v1(141.77,30.72) 142.27,31.22 JDIMM2.237 ; UC1.AT22 124.8,83.53 v3(124.67,83.53)
DDR_B_D57: length 71.4
  IN1 w0.076: 131.62,74.95 131.21,75.36 131.21,75.71 130.59,76.33 130.59,76.8 128.93,78.46 128.93,78.91 127.29,80.56 126.91,80.56 125.22,82.24 125.02,82.24 124.67,82.6 v3(124.67,82.85)
  IN1 w0.089: v1(141.77,31.36) 141.31,31.81 141.31,34.41 141.54,34.63 141.95,34.63 142.28,34.96 142.28,35.17 142.71,35.6 142.71,35.75 142.5,35.95 142.07,35.95 141.69,35.57 141.23,35.57 141.08,35.73 141.08,36.83 141.48,37.22 142.48,37.22 142.75,37.49 142.75,38.02 143.52,38.8 143.52,41.41 142.88,42.05 142.88,45.27 142.97,45.35 143.63,45.35 143.72,45.44 143.72,45.62 143.63,45.71 142.97,45.71 142.88,45.8 142.88,45.98 142.97,46.07 143.63,46.07 143.72,46.15 143.72,46.33 143.63,46.42 142.97,46.42 142.88,46.51 142.88,46.69 142.97,46.78 143.63,46.78 143.72,46.87 143.72,47.04 143.63,47.13 142.97,47.13 142.88,47.22 142.88,48.43 141.97,49.34 141.97,52.99 132.48,62.48 132.48,74.1 131.62,74.95
  BOTTOM w0.108: v3(124.67,82.85) 124.78,82.85 UC1.AU22 ; v1(141.77,31.36) 141.27,31.86 JDIMM2.233
DDR_B_D58: length 70.4
  IN1 w0.076: v3(125.58,82.85) 125.58,82.58 127.11,81.05 127.95,81.05 128.99,80.01 129.95,80.01 130.79,79.17 130.79,78.8 131.81,77.78 131.81,76.11 133.13,74.79 133.56,74.79
  IN1 w0.089: 133.56,74.79 133.7,74.65 133.7,62.99 143.19,53.5 143.19,49.92 144.94,48.17 144.94,45.9 145.33,45.51 145.33,43.83 145.08,43.57 144.64,43.57 144.46,43.4 144.46,43.16 144.55,43.07 145.24,43.07 145.33,42.98 145.33,40.98 145.55,40.76 145.55,39.1 144.06,37.61 144.06,31.74 143.91,31.59 143.6,31.59 143.47,31.46 143.47,30.75 143.32,30.6 143.19,30.6 143.06,30.47 143.06,30.32 143.24,30.14 144,30.14 144.16,30.29 144.16,30.72 144.28,30.85 v1(144.77,30.85)
  BOTTOM w0.108: JDIMM2.249 145.27,31.35 v1(144.77,30.85) ; v3(125.58,82.85) 125.69,82.85 UC1.AU21
