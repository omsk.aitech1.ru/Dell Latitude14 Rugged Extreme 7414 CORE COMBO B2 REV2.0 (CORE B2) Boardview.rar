# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.5V_LX on TOP (solid shape): 217.87,61.71 217.87,58.2 217.74,58.08 216.9,58.08 216.72,58.26 216.72,59.42 216.39,59.75 216.39,60.47 216.16,60.69 215.66,60.69 215.63,60.72 215.63,60.95 215.64,60.96 216.23,60.96 216.6,61.33 216.6,61.71 216.72,61.84 217.74,61.84
+1.5V_RUN on TOP (solid shape): 216.9,57.54 216.9,55.18 216.8,55.08 215.45,55.08 215.23,55.31 215.23,57.29 215.58,57.65 216.8,57.65
+1.5V_RUN on BOTTOM (solid shape): 216.32,46.88 216.32,46.17 216.14,45.99 215.23,45.99 215.02,46.19 215.02,46.98 215.17,47.13 216.06,47.13
+1.5V_RUN on IN1 (solid shape): 186.62,56 186.62,54.85 186.5,54.73 185.48,54.73 185.35,54.85 185.35,56 185.48,56.12 186.5,56.12
+1.5V_RUN on IN1 (solid shape): 187.64,50.03 187.64,49.65 186.62,48.63 186.27,48.63 186.09,48.81 186.09,48.98 186.1,49 186.1,49.25 187.01,50.15 187.51,50.15
+1.5V_RUN on IN3 (solid shape): 188.17,49.77 188.17,49.14 187.74,48.71 187.54,48.71 187.19,48.93 186.84,48.71 186.42,48.71 186.27,48.86 186.27,49.29 186.9,49.92 188.02,49.92
+1.5V_VIN on TOP (solid shape): 213.17,62.22 213.17,61.56 213.78,60.95 214.29,60.95 214.29,60.69 213.78,60.69 213.29,60.21 213.29,59.04 213.22,58.97 212.76,58.97 212.69,59.04 212.69,59.27 212.08,59.88 210.27,59.88 210.04,60.11 210.04,60.44 210.68,61.08 210.68,62.4 210.75,62.47 212.91,62.47
+1.5VSP on TOP (solid shape): 219.64,61.71 219.64,59.93 219.26,59.55 219.26,55.36 219.01,55.11 217.26,55.11 217.18,55.18 217.18,57.44 217.38,57.65 217.61,57.65 218.12,58.15 218.12,60.87 218.63,61.38 218.63,61.61 218.86,61.84 219.52,61.84
+1.8V_LX on TOP (solid shape): 191.27,112.46 191.27,111.74 191.04,111.51 190.45,111.51 190.23,111.29 190.23,110.99 190.16,110.91 189.65,110.91 189.29,110.55 189.29,109.64 189.27,109.61 189.06,109.61 189.04,109.64 189.04,110.22 188.17,111.09 188.17,112.21 188.35,112.38 190.08,112.38 190.28,112.59 191.15,112.59
+1.8V_VIN on TOP (solid shape): 189.04,108.05 189.1,108.14 189.21,108.12 189.29,108.04 189.29,107.66 189.39,107.56 189.8,107.56 190.16,107.2 190.16,105.78 190.21,105.72 190.42,105.43 190.78,105.45 191.13,105.45 191.27,105.31 191.27,104.1 191.17,104 189.99,104 189.99,103.98 188.66,103.98 188.66,107.2 189.04,107.58
+1.8VALWP on TOP (solid shape): 186.95,115.05 189.88,115.05 190.03,114.9 190.03,112.92 189.77,112.66 185.84,112.66 185.66,112.84 185.66,114.9 185.99,115.23 186.78,115.23
+1VALWP on TOP (solid shape): 140.51,119.98 140.6,119.98 140.7,119.98 140.79,120 143.15,120 143.22,120 143.3,120 146.87,120 147,119.88 147,118.35 146.62,117.97 142.3,117.97 141.73,117.4 139.37,117.4 138.49,116.52 137.68,116.52 136.33,115.18 131.25,115.18 131.16,115.27 131.16,118.26 131.25,118.35 135.39,118.35 136.76,119.72 139.1,119.72 139.38,120 140.41,120
+1VALWP on BOTTOM (solid shape): 139.74,119.42 139.74,118.2 138.62,117.08 138.62,116.47 138.47,116.32 133.49,116.32 132.85,116.96 132.85,119.14 133.72,120 139.15,120
+1VALWP_VIN on TOP (solid shape): 137.7,127.78 138.03,127.78 138.36,127.45 138.36,126.23 138.17,126.03 134.75,126.03 134.64,126.13 134.64,127.26 134.83,127.45 135.57,127.45 135.62,127.5 135.62,128.49 135.65,128.51 136.97,128.51
+1VALWP_VIN on BOTTOM (solid shape): 136.37,127.32 136.37,125.64 136.11,125.38 132.74,125.38 132.59,125.52 132.59,126.86 132.67,126.94 134.67,126.94 134.67,127.33 134.79,127.46 135.04,127.46 135.11,127.46 135.18,127.48 136.21,127.48
+1VS_VCCIOP on BOTTOM (solid shape): 175.19,89.68 175.19,89.02 175.07,88.89 174.69,88.89 174.56,88.76 174.56,83.81 174.31,83.55 170.24,83.55 170.11,83.68 170.11,85.21 170.24,85.33 171.64,85.33 171.69,85.38 171.69,89.65 171.79,89.75 175.12,89.75
+2.5V_LX on TOP (solid shape): 217.74,53.91 217.74,50.43 217.64,50.33 216.95,50.33 216.77,50.51 216.77,51.3 216.34,51.73 216.34,52.57 216.22,52.69 215.66,52.69 215.61,52.74 215.61,52.9 215.66,52.95 216.22,52.95 216.6,53.33 216.6,53.96 216.72,54.09 217.56,54.09
+2.5V_MEM on TOP (solid shape): 148.55,48.17 148.55,46.85 151.5,43.9 151.5,38.53 151.37,38.19 151.5,37.85 151.5,37.64 151.37,37.3 151.5,36.96 151.5,36.75 151.37,36.41 151.5,36.07 151.5,35.86 151.37,35.52 151.5,35.19 151.5,33.67 151.29,33.47 147.31,33.47 147.13,33.64 147.13,34.71 147.25,34.84 147.48,34.84 147.71,34.61 147.71,34.35 147.76,34.3 149.08,34.3 150.1,35.32 150.1,36.16 150.15,36.36 150.1,36.56 150.1,42.46 149.85,42.71 149.85,42.72 149.62,43.16 149.18,43.39 149.16,43.39 148.17,44.39 147.25,44.39 147.18,44.46 147.18,48.02 147.56,48.4 148.32,48.4
+2.5V_MEM on TOP (solid shape): outline of 154 points within 211.31,42.53 216.6,49.77
+2.5V_MEM on IN3 (solid shape): 214.44,43.02 214.44,42.33 213.88,41.77 211.14,41.77 210.98,41.92 210.98,42.56 212.13,42.56 212.76,43.19 214.26,43.19
+2.5V_MEM on IN3 (solid shape): 210.35,40.51 210.35,39.35 210.76,38.93 212.06,38.93 212.24,38.75 212.24,38.61 211.78,38.15 208.69,38.15 208.34,38.49 208.34,39.61 209.1,40.37 209.1,40.57 209.5,40.97 209.89,40.97
+2.5V_MEM on IN3 (solid shape): 150.46,48.27 151.78,48.27 153.16,46.89 153.16,46.87 153.41,46.21 154.06,45.93 154.67,45.21 155.59,45.45 156.27,45.45 156.53,45.2 156.53,43.8 156.27,43.55 153.8,43.55 153.07,44.28 152.75,44.6 152.74,44.62 152.6,44.84 152.36,44.96 152.34,44.97 151.95,45.35 150.33,45.35 148.91,46.77 147.56,46.77 147.2,47.13 147.2,48.48 147.46,48.73 150,48.73
+2.5V_VIN on TOP (solid shape): 213.68,52.95 214.26,52.95 214.29,52.92 214.29,52.72 214.26,52.69 213.68,52.69 213.29,52.31 213.29,50.38 212.62,48.11 212,47.49 211.26,47.49 211.14,47.61 211.14,50.03 211.26,50.15 211.97,50.15 212.66,51.58 212.66,53.35 212.74,53.43 213.19,53.43
+2.5VS on TOP (solid shape): 219.44,53.96 219.44,51.83 219.2,51.59 219.2,49.07 219.01,48.88 219.01,47.61 218.76,47.36 217.1,47.36 216.98,47.49 216.98,49.9 217.23,50.15 217.84,50.15 217.97,50.28 217.97,53.76 218.3,54.09 219.31,54.09
+3.3V_ALW on TOP (solid shape): 191.35,103.44 191.35,101.94 190.94,101.54 188.78,101.54 188.56,101.77 188.56,103.54 188.66,103.65 191.15,103.65
+3.3V_ALW on TOP (solid shape): 269.48,64.38 269.48,63.36 269.47,63.35 264.95,63.35 264.81,63.49 264.81,64.25 265.19,64.63 269.23,64.63
+3.3V_ALW on TOP (solid shape): 240.29,68.03 242.05,68.03 243.22,66.87 243.22,65.57 243.11,65.47 240.85,65.47 240.85,66.74 240.52,67.07 239.29,67.07 238.91,67.45 238.91,68.36 239.03,68.49 239.84,68.49
+3.3V_ALW on TOP (solid shape): 271.35,52.83 271.35,50.79 271.08,50.52 271.08,47.99 270.95,47.87 270.06,47.87 269.94,47.99 269.94,50.79 270.2,51.05 270.2,52.67 270.46,52.93 271.24,52.93
+3.3V_ALW on TOP (solid shape): 221.07,64.76 221.86,64.76 221.9,64.72 221.9,64.24 220.99,64.24 220.9,64.15 220.9,63.78 220.96,63.72 221.88,63.72 221.89,63.72 221.89,63.36 220.94,63.36 220.85,63.27 220.85,62.96 220.88,62.93 221.91,62.93 221.91,62.54 220.9,62.54 220.86,62.5 220.86,62.21 220.95,62.13 221.89,62.13 221.89,61.64 221.82,61.58 220.47,61.58 220.36,61.69 220.36,64.48 220.05,64.78 220.05,64.96 220.28,65.19 220.64,65.19
+3.3V_ALW on TOP (solid shape): 206.21,59.5 206.21,58.74 206.23,58.71 206.41,58.71 206.44,58.74 206.44,59.5 206.46,59.53 206.59,59.53 206.61,59.5 206.61,58.63 206.6,58.61 206.6,58.2 206.97,58.03 207.05,57.95 207.38,57.5 207.81,57.85 207.84,57.92 207.9,57.95 208.26,58.25 208.06,58.67 208.04,58.68 208.04,59.5 208.06,59.53 208.19,59.53 208.21,59.5 208.21,58.74 208.24,58.71 208.42,58.71 208.44,58.74 208.44,59.5 208.47,59.53 208.57,59.53 208.6,59.5 208.6,58.74 208.62,58.71 208.95,58.71 210.59,57.07 210.59,47.32 210.35,47.08 206.61,47.08 206.36,47.33 206.36,57.6 205.83,58.12 205.83,58.54 206.03,58.74 206.03,59.5 206.06,59.53 206.18,59.53
+3.3V_ALW on BOTTOM (solid shape): 53.76,128.46 53.76,127.8 53.55,127.6 53.02,127.6 52.84,127.78 52.84,127.95 52.69,128.11 51.93,128.11 51.9,128.13 51.9,128.26 51.93,128.28 52.69,128.28 52.72,128.31 52.72,128.49 52.69,128.51 51.93,128.51 51.9,128.54 51.9,128.66 51.93,128.69 53.53,128.69
+3.3V_ALW on BOTTOM (solid shape): 55.72,123.31 55.72,122.62 55.74,122.6 55.74,121.83 55.72,121.81 55.59,121.81 55.56,121.83 55.56,122.6 55.54,122.62 55.36,122.62 55.33,122.6 55.33,121.83 55.31,121.81 55.18,121.81 55.16,121.83 55.16,122.6 55.13,122.62 54.55,122.62 54.24,122.93 54.24,123.23 54.47,123.46 55.56,123.46
+3.3V_ALW on BOTTOM (solid shape): 59.07,123.71 59.07,123.37 58.81,123.12 58.6,123.12 58.11,122.62 57.8,122.62 57.75,122.57 57.75,121.83 57.72,121.81 57.6,121.81 57.57,121.83 57.57,122.6 57.54,122.62 57.37,122.62 57.34,122.6 57.34,121.83 57.32,121.81 57.19,121.81 57.16,121.83 57.16,123.31 57.49,123.64 57.49,123.74 57.64,123.89 58.89,123.89
+3.3V_ALW on BOTTOM (solid shape): outline of 165 points within 187.32,96.24 190.56,103.04
+3.3V_ALW on IN1 (solid shape): 171,122.92 171,121.78 170.88,121.65 169.35,121.65 169.1,121.91 169.1,122.8 169.35,123.05 170.88,123.05
+3.3V_ALW on IN1 (solid shape): 176.1,102.99 176.46,102.73 176.82,102.99 177.23,102.99 177.43,102.78 177.43,100.72 177.15,100.45 175.55,100.45 175.07,100.93 175.07,102.32 174.7,102.69 174.7,103.72 175.37,103.72
+3.3V_ALW on VCC (solid shape): outline of 745 points within 50.73,34.41 244.92,136.89
+3.3V_ALW on IN2 (solid shape): 171,122.92 171,121.78 170.88,121.65 169.35,121.65 169.1,121.91 169.1,122.8 169.35,123.05 170.88,123.05
+3.3V_ALW on IN3 (solid shape): outline of 178 points within 243.85,47.08 252.36,49.92
+3.3V_ALW on IN3 (solid shape): outline of 837 points within 168.11,97.75 190.38,107.2
+3.3V_ALW2 on BOTTOM (solid shape): 201,61.46 201,60.72 200.87,60.59 200.54,60.59 200.44,60.69 200.44,61.05 199.68,61.81 198.9,61.81 198.9,61.81 198.69,61.84 198.48,61.81 198.48,61.81 198.05,61.81 197.94,61.7 197.93,61.71 197.39,61.71 197.34,61.76 197.34,62.04 197.67,62.37 200.09,62.37
+3.3V_ALW_5048 on TOP (solid shape): 269.56,50.28 269.56,47.99 269.43,47.87 268.29,47.87 268.16,47.99 268.16,48.86 268.11,48.91 267.19,48.91 266.71,49.39 266.71,49.98 266.76,50.03 267.57,50.03 267.68,49.92 268.11,49.92 268.59,50.41 269.43,50.41
+3.3V_ALW_DSW on BOTTOM (solid shape): 138.16,74.13 138.16,73.88 138.01,73.72 136.03,73.72 135.67,74.08 135.67,74.23 135.72,74.28 138.01,74.28
+3.3V_ALW_PCH on TOP (solid shape): 134.3,112.56 134.3,111.67 134.2,111.57 131.43,111.57 131.35,111.65 131.35,112.05 131.98,112.68 134.18,112.68
+3.3V_ALW_PCH on TOP (solid shape): 183.45,100.11 183.45,99.12 183.75,98.82 184.92,98.82 184.95,98.79 184.95,98.67 184.92,98.64 184.16,98.64 184.14,98.62 184.14,98.44 184.16,98.41 184.92,98.41 184.95,98.39 184.95,98.26 184.92,98.24 183.53,98.24 183.51,98.22 182.62,98.22 182.56,98.29 182.56,100.09 182.71,100.24 183.32,100.24
+3.3V_ALW_PCH on BOTTOM (solid shape): 202.6,146.19 202.6,143.8 202.32,143.52 200.52,143.52 200.44,143.6 200.44,146.19 200.62,146.37 202.42,146.37
+3.3V_ALW_PCH on IN2 (solid shape): outline of 97 points within 193.46,140.55 196.76,142.33
+3.3V_ALW_U38 on TOP (solid shape): 243.11,65.06 243.11,64.53 242.91,64.33 241.95,64.33 241.72,64.1 241.72,63.13 241.51,62.93 241.03,62.93 240.7,62.6 240.35,62.6 240.22,62.73 240.22,63.36 240.73,63.87 240.73,65.04 240.83,65.14 243.04,65.14
+3.3V_ALWP on TOP (solid shape): 199.72,57.9 199.83,57.89 199.95,57.9 205.35,57.9 205.93,57.32 205.93,47.23 205.78,47.08 200.87,47.08 200.59,47.36 200.59,49.77 199.05,51.32 199.05,57.77 199.17,57.9
+3.3V_CAM on TOP (solid shape): 37.12,103.87 37.12,100.5 36.89,100.27 35.75,100.27 35.6,100.42 35.6,102.02 35.39,102.22 35.39,103.16 35.14,103.42 34.22,103.42 34.12,103.52 34.12,104.05 34.25,104.18 36.82,104.18
+3.3V_CAM_C on TOP (solid shape): 210.88,149.85 210.88,149.75 210.88,149.74 210.85,149.6 210.97,149.31 211.11,149.22 211.65,148.68 211.65,148.07 211.39,147.82 209.62,147.82 209.39,148.04 209.39,149.26 209.2,149.46 209.15,149.46 209.14,149.46 209.02,149.49 208.89,149.49 208.89,149.48 208.44,149.48 208.34,149.5 208.25,149.48 208.05,149.48 208.02,149.46 206.04,149.46 205.87,149.29 205.87,148.91 205.71,148.75 204.82,148.75 204.71,148.85 204.71,150.01 204.94,150.24 205.17,150.24 205.17,150.25 210.49,150.25
+3.3V_CAM_QC on TOP (solid shape): 211.81,147.16 211.81,146.37 211.01,146.37 210.78,146.14 210.78,144.97 210.73,144.92 209.18,144.92 208.54,145.56 208.54,146.85 208.7,147 209.1,147 209.38,147.28 211.7,147.28
+3.3V_FPM on TOP (solid shape): 185.65,25.71 185.65,24.42 185.53,24.3 184.81,24.3 184.63,24.48 184.11,24.48 184.06,24.53 184.06,24.97 184.24,25.15 184.77,25.15 184.9,25.29 184.9,26.05 185.31,26.05
+3.3V_FPM_LX on TOP (solid shape): 190.63,23.56 192.04,23.56 192.08,23.52 192.08,23.46 192.07,23.43 192.06,23.36 192.06,23.28 192.06,23.25 192.02,23.21 190.97,23.21 190.42,22.66 189.34,22.66 189.05,22.37 189.05,21.95 187.8,21.95 187.8,23.79 187.97,23.95 190.24,23.95
+3.3V_FPM_VIN on TOP (solid shape): 189.02,25.72 189.56,25.72 189.72,25.57 189.72,25.03 189.76,24.99 190.22,24.99 190.99,24.21 192.03,24.21 192.08,24.17 192.08,23.9 192.04,23.86 190.64,23.86 190.38,24.13 189.57,24.13 189.38,24.32 189.08,24.32 188.94,24.46 188.94,25.01 188.33,25.62 188.01,25.62 187.88,25.75 186.92,25.75 186.83,25.85 186.83,26.53 186.92,26.62 188.13,26.62
+3.3V_HDD on TOP (solid shape): 157.59,44.03 157.59,34.96 157.25,34.62 153.77,34.62 153.48,34.91 153.48,38.27 151.83,39.92 151.83,44.57 152.04,44.78 156.84,44.78
+3.3V_HDD on BOTTOM (solid shape): 153.48,45.96 153.48,43.42 153.24,43.18 151.13,43.18 150.68,43.63 150.68,46.95 150.89,47.16 152.28,47.16
+3.3V_HDD on BOTTOM (solid shape): 156.32,58.96 156.32,58.69 155.55,58.69 155.55,58.51 156.32,58.51 156.32,58.19 155.55,58.19 155.55,58.01 156.32,58.01 156.32,57.69 155.55,57.69 155.55,57.51 156.32,57.51 156.32,57.19 155.55,57.19 155.55,57.01 156.32,57.01 156.32,56.77 156.27,56.72 155.45,56.72 155.36,56.63 155.36,55.89 154.47,55 152.36,55 152.36,55.88 153.19,56.71 153.19,58.93 153.25,58.99 156.29,58.99
+3.3V_LAN on BOTTOM (solid shape): 151.37,128.72 151.37,127.42 151.06,127.12 150.15,127.12 149.91,127.36 149.91,127.51 150.68,128.28 150.68,128.74 150.8,128.85 151.23,128.85
+3.3V_LAN_OUT on TOP (solid shape): 150.68,137.25 154.06,137.25 154.9,136.41 154.9,135.27 154.72,135.09 153.17,135.09 152.44,135.83 150.35,135.83 149.64,136.54 146.95,136.54 146.26,135.85 146.26,134.79 146.06,134.79 146.06,136.59 147.15,137.68 150.25,137.68
+3.3V_LAN_OUT on BOTTOM (solid shape): outline of 177 points within 144.54,127.93 150.35,132.96
+3.3V_LAN_OUT on IN2 (solid shape): outline of 251 points within 144.46,130.06 154.82,135.5
+3.3V_LCD_VDD on BOTTOM (solid shape): 55.18,97.32 55.69,96.81 55.73,96.78 55.76,96.75 55.76,96.48 55.66,96.38 55.24,96.38 55.23,96.38 53.68,96.38 53.53,96.53 53.53,99.1 54.17,99.74 54.17,100.32 54.42,100.57 54.42,100.82 55.18,100.82
+3.3V_M on TOP (solid shape): 184.95,96.79 184.95,96.66 184.92,96.64 184.16,96.64 184.14,96.61 184.14,96.43 184.16,96.41 184.92,96.41 184.95,96.38 184.95,96.25 184.92,96.23 183.27,96.23 183.2,96.15 183.2,95.64 183.12,95.57 182.66,95.57 182.59,95.64 182.59,96.48 182.92,96.81 184.92,96.81
+3.3V_M_TPM on BOTTOM (solid shape): 200.01,146.34 200.01,143.52 199.07,143.52 198.97,143.63 198.97,144.54 198.79,144.72 196.53,144.72 196.43,144.82 196.43,146.34 196.56,146.47 199.88,146.47
+3.3V_RTC_LDO on TOP (solid shape): 191.2,68.31 191.2,66.03 191.07,65.9 190.08,65.9 189.42,66.56 189.42,68.31 189.55,68.44 191.07,68.44
+3.3V_RUN on TOP (solid shape): 181.29,105.14 181.29,100.22 181.14,100.06 180.02,100.06 179.89,100.19 179.89,105.14 180.02,105.27 181.16,105.27
+3.3V_RUN on TOP (solid shape): 89.14,117.39 91.78,117.39 91.78,116.6 91.77,116.59 88.82,116.59 88.5,116.9 88.5,117.46 88.66,117.62 88.91,117.62
+3.3V_RUN on TOP (solid shape): 184.31,122.14 183.35,121.17 181.01,121.17 180.91,121.27 180.91,121.45 180.9,121.52 180.88,121.59 180.88,122.7 181.82,123.64 184.31,123.64
+3.3V_RUN on TOP (solid shape): 163,37.55 163,35.85 162.44,35.29 161.05,35.29 160.67,34.91 158.13,34.91 158.08,34.96 158.08,38.9 158.35,39.18 161.38,39.18
+3.3V_RUN on TOP (solid shape): 269.96,53.05 269.96,51.32 269.73,51.09 268.77,51.09 268.77,51.55 269.34,51.55 269.37,51.58 269.37,51.78 269.34,51.8 268.77,51.8 268.77,52.06 269.34,52.06 269.37,52.08 269.37,52.29 269.34,52.31 268.77,52.31 268.77,52.57 269.39,52.57 269.42,52.59 269.42,52.77 269.39,52.79 268.77,52.79 268.77,53.28 269.73,53.28
+3.3V_RUN on TOP (solid shape): 212.79,64 212.79,62.85 212.66,62.73 211.39,62.73 211.26,62.6 210.53,62.6 210.42,62.5 210.42,61.08 210.2,60.85 208.47,60.85 208.44,60.87 208.44,61.66 208.42,61.68 208.24,61.68 208.21,61.66 208.21,60.87 208.19,60.85 208.06,60.85 208.04,60.87 208.04,62.24 208.54,62.75 208.54,63.13 208.65,63.23 209.56,63.23 209.64,63.31 209.64,64.05 209.71,64.12 212.66,64.12
+3.3V_RUN on BOTTOM (solid shape): 198.51,51.58 198.51,49.72 198.26,49.47 197.32,49.47 197.09,49.7 197.09,51.7 197.24,51.86 198.23,51.86
+3.3V_RUN on BOTTOM (solid shape): 188.76,56.76 188.78,56.73 188.94,56.73 188.99,56.78 188.99,57.87 189.27,57.87 189.27,56.76 189.29,56.73 189.44,56.73 189.49,56.78 189.49,57.87 189.67,57.87 189.72,57.82 189.72,55.33 189.49,55.11 189.06,55.11 188.48,55.69 188.48,57.77 188.58,57.87 188.76,57.87
+3.3V_RUN on BOTTOM (solid shape): 156.42,102.12 156.42,101.9 156.53,101.8 157.63,101.8 157.64,101.79 157.64,101.52 157.62,101.5 156.65,101.5 156.59,101.44 156.59,101.34 156.63,101.3 157.62,101.3 157.64,101.28 157.64,101.01 157.62,101 157.23,101 157.19,101.01 157.15,101.01 156.3,101.01 155.81,100.52 153.73,100.52 153.22,100.01 153.22,98.59 152.87,98.24 152.36,98.24 152.08,98.51 152.08,100.83 152.54,101.28 155.34,101.28 155.39,101.33 155.39,102.1 155.54,102.25 156.3,102.25
+3.3V_RUN on BOTTOM (solid shape): outline of 186 points within 177.18,99.43 184.19,108.47
+3.3V_RUN on IN1 (solid shape): 184.43,108.36 184.43,107.33 184.35,107.25 183.47,107.25 183.38,107.34 183.38,107.74 183.39,107.75 183.43,107.91 183.39,108.08 183.38,108.09 183.38,108.35 183.47,108.44 184.35,108.44
+3.3V_RUN on VCC (solid shape): outline of 192 points within 131.63,22.09 272.98,115.05
+3.3V_RUN on IN2 (solid shape): outline of 139 points within 81.54,108.92 84.91,115.74
+3.3V_RUN on IN2 (solid shape): outline of 1390 points within 152.04,96.73 180.33,103.72
+3.3V_RUN on IN3 (solid shape): 184.36,108.34 184.36,107.61 184.08,107.33 183.42,107.33 183.32,107.43 183.32,107.65 183.43,107.91 183.32,108.17 183.32,108.29 183.55,108.52 184.19,108.52
+3.3V_RUN on IN3 (solid shape): outline of 243 points within 95.31,113.68 99.6,115.76
+3.3V_RUN on IN4 (solid shape): outline of 638 points within 61.18,114.74 83.38,121.45
+3.3V_RUN_AUDIO on BOTTOM (solid shape): 50.58,128.66 50.58,128.54 50.56,128.51 49.79,128.51 49.77,128.49 49.77,128.31 49.79,128.28 50.56,128.28 50.58,128.26 50.58,128.13 50.56,128.11 49.79,128.11 49.77,128.08 49.77,125.64 49.08,124.96 47.32,124.96 47.18,124.98 47.04,124.96 46.87,124.96 46.32,124.4 46.32,121.25 46.11,121.04 45.27,121.04 45.1,121.22 45.1,126.15 45.5,126.56 46.67,126.56 46.77,126.66 46.77,127.62 46.57,127.83 46.57,128.51 46.75,128.69 50.56,128.69
+3.3V_RUN_FFS on BOTTOM (solid shape): 196.71,51.68 196.71,49.65 196.15,49.65 195.9,49.39 195.9,48.25 195.35,47.7 193.14,47.7 192.85,47.99 192.85,48.63 192.97,48.76 194.36,48.76 194.49,48.89 194.49,50.43 195.92,51.86 196.53,51.86
+3.3V_RUN_VDDA on TOP (solid shape): 86.98,131.6 86.98,131.59 87.04,131.45 87.16,131.37 87.65,130.89 87.65,130.88 87.7,130.8 87.76,130.75 87.79,130.73 87.79,130.59 87.76,130.57 87.71,130.53 87.68,130.49 87.49,130.49 87.46,130.53 87.4,130.58 87.37,130.65 87.29,130.65 86.88,131.05 86.88,131.06 86.81,131.18 86.69,131.25 86.67,131.26 86.45,131.48 86.45,131.71 86.58,131.84 86.74,131.84
+3.3V_RUN_VDDA on BOTTOM (solid shape): 87.79,131.13 87.79,130.57 87.72,130.49 87.34,130.49 86.88,130.95 86.44,130.95 86.43,130.96 86.23,130.98 86.05,130.89 85.95,130.79 85.95,130.65 85.75,130.46 85.61,130.46 85.61,130.21 84.92,129.53 84.06,129.53 83.79,129.26 83.11,129.26 83.04,129.32 83.04,129.83 82.54,130.34 81.82,130.34 81.65,130.52 81.65,131.28 81.68,131.32 82.68,131.32 83.09,130.9 83.91,130.9 84.08,130.72 84.62,130.72 84.63,130.71 85.35,130.71 85.61,130.98 85.63,130.98 85.86,131.07 85.96,131.29 86.12,131.36 86.24,131.48 87.44,131.48
+3.3V_RUN_VDDA on IN2 (solid shape): outline of 316 points within 84.49,126.53 87.77,131.18
+3.3V_RUN_VDDA on IN3 (solid shape): outline of 273 points within 86.96,124.51 91.4,128.27
+3.3V_RUN_VDDIO on BOTTOM (solid shape): 82.79,128.54 82.79,127.39 83.23,126.95 84.62,126.95 84.72,126.84 85.8,126.84 85.8,126.7 85.28,126.18 85.28,125.67 85.02,125.41 84.39,125.41 83.7,126.1 82.81,126.1 82.69,126.23 82.03,126.23 81.7,126.56 81.7,128.49 81.85,128.64 82.69,128.64
+3.3V_RUN_VDDIO on IN1 (solid shape): outline of 83 points within 85.15,126.51 91.7,134.68
+3.3V_RUN_VDDIO on IN2 (solid shape): 90.56,127.22 90.72,127.1 90.92,127.09 91.17,126.84 91.17,124.63 90.77,124.22 87.08,124.22 85.38,125.92 85.38,126.83 85.53,126.98 85.81,126.98 85.96,126.83 85.96,126.67 86.04,126.53 87.13,125.44 90.13,125.44 90.49,125.79 90.49,125.97 90.49,125.98 90.43,126.33 90.08,126.42 90.05,126.41 89.9,126.56 89.9,127.04 90,127.13 90.03,127.12 90.26,127.09 90.45,127.22
+3.3V_RUN_VMM on TOP (solid shape): 91.37,119.04 91.43,118.99 91.55,118.99 91.6,119.04 91.6,119.7 91.63,119.72 91.86,119.72 91.86,119.04 91.91,118.99 92.06,118.99 92.11,119.04 92.11,119.72 92.37,119.72 92.37,119.04 92.42,118.99 92.57,118.99 92.64,119.06 92.64,119.72 93.03,119.72 93.03,117.34 92.85,117.16 92.29,117.16 92.21,117.23 92.21,117.7 92.09,117.82 89.32,117.82 89.22,117.92 89.22,119.47 89.6,119.47 89.6,118.96 89.72,118.83 89.98,118.83 90.1,118.96 90.1,119.47 90.49,119.47 90.49,118.96 90.61,118.83 90.79,118.83 90.92,118.96 90.92,119.72 91.37,119.72
+3.3V_RUN_VMM on BOTTOM (solid shape): 81.77,137.36 81.84,137.29 81.84,131.8 81.49,131.46 81.48,131.46 81.48,131.45 81.34,131.31 81.34,130.49 81.72,130.11 82.51,130.11 82.76,129.86 82.76,129.07 82.64,128.94 81.44,128.94 81.27,129.12 81.28,129.14 81.21,129.49 80.89,129.63 80.35,130.17 80.35,131.31 80.52,131.47 80.52,131.58 80.54,131.62 80.56,131.65 80.58,131.78 80.56,131.9 80.56,131.91 80.56,132.28 80.56,132.28 80.58,132.4 80.56,132.51 80.56,132.56 80.52,132.61 80.52,132.64 80.45,132.71 80.45,133.1 80.53,133.14 80.7,133.39 80.63,133.69 80.64,133.71 80.64,136.4 81.07,136.83 81.16,136.89 81.22,136.97 81.34,137.1 81.34,137.25 81.47,137.38 81.71,137.38
+3.3V_SUS on TOP (solid shape): 206.61,63.11 206.61,60.87 206.59,60.85 206.46,60.85 206.44,60.87 206.44,61.68 206.41,61.71 206.23,61.71 206.21,61.68 206.21,60.87 206.18,60.85 206.06,60.85 206.03,60.87 206.03,61.66 206,61.68 205.7,61.68 205.5,61.89 205.5,61.96 205.47,61.99 205.47,63.23 205.6,63.36 206.36,63.36
+3.3V_USBHUB on TOP (solid shape): outline of 246 points within 181.42,123.97 191.53,135.04
+3.3V_WLAN on TOP (solid shape): 31.8,136.13 31.8,133.28 31.79,133.26 30.62,133.26 30.47,133.41 30.47,135.1 30.07,135.49 29.17,135.49 28.83,135.83 28.83,136.74 28.91,136.83 31.1,136.83
+3.3V_WLAN on BOTTOM (solid shape): 29.82,136.81 30.23,136.71 30.63,136.81 30.8,136.81 30.92,136.68 30.92,136.1 30.32,135.5 29.16,135.5 28.89,135.77 28.89,136.68 29.02,136.81
+3.3V_WLAN on BOTTOM (solid shape): 55.33,120.46 55.33,119.7 55.36,119.68 55.54,119.68 55.56,119.7 55.56,120.46 55.59,120.49 55.72,120.49 55.74,120.46 55.74,119.55 55.48,119.29 55.48,119.19 55.05,118.76 52.89,118.76 52.41,119.24 52.41,119.8 53.01,120.4 54.67,120.4 54.8,120.27 54.8,119.75 54.93,119.62 55.13,119.62 55.16,119.65 55.16,120.46 55.18,120.49 55.31,120.49
+3.3V_WLAN on BOTTOM (solid shape): 31.13,119.42 32.6,119.42 32.7,119.32 32.7,119.16 31.1,119.16 31.05,119.11 31.05,118.96 31.1,118.91 32.7,118.91 32.7,118.33 32.62,118.33 32.36,118.33 32.16,118.15 32.18,117.76 32.54,117.59 32.58,117.6 32.62,117.61 32.71,117.59 32.75,117.51 32.75,117.21 33.5,116.46 33.5,114.86 33.26,114.62 31.33,114.62 31.28,114.67 31.28,116.85 31.33,116.9 31.33,117.77 31.33,117.82 31.33,118.07 31.29,118.13 31.01,118.54 30.75,118.73 30.67,118.8 30.44,118.89 29.55,118.89 29.43,119.01 29.43,119.47 29.81,119.85 30.7,119.85
+3.3V_WLAN on IN1 (solid shape): 33.48,116.64 33.48,115.47 33.31,115.3 31.68,115.3 31.43,115.56 31.43,116.83 31.68,117.08 33.03,117.08
+3.3V_WLAN on IN1 (solid shape): 55,119.6 55,118.33 54.67,118 53.05,118 52.89,118.15 52.89,119.67 53.07,119.85 54.75,119.85
+3.3V_WLAN on IN2 (solid shape): outline of 573 points within 27.87,114.29 33.46,136.84
+3.3V_WWAN on BOTTOM (solid shape): 62.78,125.88 62.78,121.71 60.76,119.69 60.76,119.03 59.83,118.1 57.85,118.1 57.6,118.35 57.6,118.76 57.16,119.19 57.16,120.46 57.19,120.49 57.32,120.49 57.34,120.46 57.34,119.7 57.37,119.68 57.54,119.68 57.57,119.7 57.57,120.46 57.6,120.49 57.72,120.49 57.75,120.46 57.75,119.7 57.77,119.68 58.4,119.68 58.62,119.89 58.62,120.11 59.03,120.52 59.04,120.53 59.2,120.67 59.27,120.87 59.27,120.89 59.27,122.93 59.83,123.48 59.83,125.52 61.02,126.71 61.95,126.71
+3.3V_WWAN on BOTTOM (solid shape): outline of 143 points within 92.53,120.92 101.56,140.96
+3.3V_WWAN on IN2 (solid shape): outline of 1210 points within 60.29,125.06 94.78,143.5
+3.3VALW on TOP (solid shape): 135.29,128.99 135.29,127.85 135.2,127.76 134.42,127.76 134.35,127.69 134.35,126.05 134.33,126.02 134.15,126.02 134.15,128.97 134.3,129.12 135.16,129.12
+3V/5V_PWR_SRC on TOP (solid shape): 199.6,62.14 200.23,62.14 200.23,60.67 200.06,60.51 199.56,60.51 199.42,60.65 199.42,61.18 198,62.6 196.99,62.6 196.96,62.62 196.96,62.78 196.99,62.8 198.94,62.8
+3V/5V_PWR_SRC on TOP (solid shape): outline of 87 points within 182.6,55.11 192.54,70.35
+5V_ALW on TOP (solid shape): 209.19,149.08 209.19,149 209.11,148.91 209.11,147.44 208.85,147.18 208.09,147.18 207.86,147.41 207.86,149.06 208.12,149.32 208.95,149.32
+5V_ALW on TOP (solid shape): 180.55,107.53 180.94,107.53 181.29,107.18 181.29,105.7 181.11,105.53 179.77,105.53 179.64,105.65 179.64,107.66 179.77,107.79 180.3,107.79
+5V_ALW on TOP (solid shape): 26.42,97.77 27.22,97.77 27.47,97.52 28.37,97.52 28.41,97.49 28.41,96.48 28.24,96.32 27.04,96.32 26.08,97.27 26.06,97.29 24.62,97.29 24.42,97.49 24.42,97.9 24.56,98.05 26.14,98.05
+5V_ALW on TOP (solid shape): 80.96,53.89 82.56,53.89 82.71,53.73 83.86,53.73 83.88,53.71 83.88,53.56 83.86,53.53 82.74,53.53 82.38,53.18 80.25,53.18 80.12,53.3 80.12,54.14 80.25,54.27 80.58,54.27
+5V_ALW on TOP (solid shape): 188.56,87.59 188.56,86.17 188.91,85.81 190.33,85.81 190.61,85.54 190.61,84.42 191.32,83.71 191.32,74.92 191.07,74.66 188.66,74.66 188.53,74.79 188.53,82.11 188.43,82.21 183.83,82.21 183.83,84.44 183.93,84.54 185.02,84.54 185.22,84.74 185.22,85.29 185.41,85.48 185.74,85.48 186.29,86.04 186.29,86.25 187.13,86.25 187.18,86.3 187.18,86.42 187.13,86.48 186.32,86.48 186.29,86.5 186.29,86.65 187.2,86.65 187.79,86.99 187.17,87.26 186.29,87.26 186.29,87.44 187.11,87.44 187.36,87.69 188.46,87.69
+5V_ALW on TOP (solid shape): 60.74,130.44 61.68,128.89 63.44,128.47 65.13,128.47 65.59,128 65.59,125.85 62.55,125.85 61.66,126.73 60.77,126.73 60.02,127.48 58.47,130.03 55.66,129.02 52.77,129.02 52.64,129.15 52.64,131.05 53.15,131.56 59.62,131.56
+5V_ALW on TOP (solid shape): outline of 131 points within 197.5,43.73 209.41,46.93
+5V_ALW on BOTTOM (solid shape): 204.18,63.62 204.18,61.86 203.76,61.45 202.61,61.45 202.32,61.74 202.32,63.34 202.73,63.74 204.05,63.74
+5V_ALW on BOTTOM (solid shape): 209.21,48.07 209.21,46.27 208.82,45.89 207.27,45.89 206.89,46.27 206.89,48.22 207.35,48.68 208.59,48.68
+5V_ALW on BOTTOM (solid shape): 260.34,9.49 260.34,7.61 260.28,7.56 260.08,7.56 260.03,7.61 260.03,8.9 259.93,9.01 259.4,9.01 259.34,9.06 259.34,9.56 259.42,9.64 260.18,9.64
+5V_ALW on BOTTOM (solid shape): 199.58,46.47 199.58,46.29 199.35,46.06 199.17,46.06 199.05,45.94 199.05,44.64 198.72,44.31 197.88,44.31 197.67,44.51 197.67,46.29 198,46.62 199.43,46.62
+5V_ALW on BOTTOM (solid shape): 141.08,137.61 142.63,137.61 142.68,137.55 142.68,136.77 142.56,136.64 140.78,136.64 140.4,136.26 139,136.26 138.62,136.64 138.62,137.53 138.75,137.66 141.03,137.66
+5V_ALW on BOTTOM (solid shape): 26.23,98.02 26.23,97.15 25.7,96.62 24.11,96.62 24.1,96.63 24.1,96.87 24.12,96.89 24.12,97.6 24.66,98.14 26.12,98.14
+5V_ALW on BOTTOM (solid shape): 179.89,108.32 181.16,108.32 181.32,108.17 181.32,103.44 180.48,102.6 178.65,102.6 178.55,102.71 178.55,105.62 178.3,105.62 178.3,107.51 177.05,107.51 177.05,105.62 176.86,105.42 176.59,105.42 175.75,106.26 174.15,106.26 174.13,106.29 174.13,108.78 174.28,108.93 179.28,108.93
+5V_ALW on BOTTOM (solid shape): 53.94,130.75 53.94,130.42 53.89,130.37 53.64,130.37 53.39,130.11 51.9,130.11 51.88,130.14 51.88,130.26 51.9,130.29 52.61,130.29 52.64,130.32 52.64,130.49 52.61,130.52 51.93,130.52 51.9,130.54 51.9,130.67 51.93,130.7 52.77,130.7 52.94,130.87 53.81,130.87
+5V_ALW on BOTTOM (solid shape): 174.92,54.47 174.92,53 174.53,52.62 172.53,52.62 172.5,52.64 172.5,52.85 172.53,52.87 173.77,52.87 173.82,52.92 173.82,53.07 173.77,53.12 172.55,53.12 172.5,53.18 172.5,53.33 172.55,53.38 173.95,53.38 174,53.43 174,53.96 173.8,54.17 173.8,54.57 173.98,54.75 174.64,54.75
+5V_ALW on BOTTOM (solid shape): 22.93,94.93 22.93,92.84 22.67,92.57 20.52,92.57 20.36,92.74 20.36,93.28 20.94,93.86 21.74,93.86 22.17,94.28 22.17,94.93 22.19,94.95 22.42,94.95 22.43,94.93 22.43,94.31 22.48,94.27 22.63,94.27 22.66,94.31 22.66,94.92 22.69,94.95 22.91,94.95
+5V_ALW on BOTTOM (solid shape): outline of 87 points within 206.78,55.95 209.61,59.97
+5V_ALW on IN1 (solid shape): 191.53,83.67 191.53,79.1 191.27,78.84 189.89,78.84 189.54,79.19 189.54,83.56 189.98,84 191.2,84
+5V_ALW on IN1 (solid shape): outline of 670 points within 189.55,61.08 204.35,66.69
+5V_ALW on VCC (solid shape): outline of 959 points within 19.62,74.92 212.02,151.25
+5V_ALW on IN2 (solid shape): 26.33,97.9 26.33,97.18 26,96.84 24.28,96.84 22.67,95.23 22.67,92.95 22.29,92.57 20.54,92.57 20.35,92.76 20.35,96.33 22.17,98.15 26.09,98.15
+5V_ALW2 on TOP (solid shape): 200.29,63.79 200.29,62.78 200.16,62.65 199.55,62.65 199.2,63.01 196.99,63.01 196.96,63.03 196.96,63.18 196.99,63.21 198.36,63.21 199.2,64.05 200.04,64.05
+5V_ALWP on TOP (solid shape): 188.07,81.65 188.07,74.84 187.97,74.74 183.65,74.74 183.25,75.15 183.25,79.11 183.83,79.69 183.83,81.52 184.08,81.78 187.95,81.78
+5V_ALWP on BOTTOM (solid shape): 186.82,78.83 186.82,74.91 185.61,73.7 185.61,69.97 185.35,69.71 179.26,69.71 179,69.97 179,72.17 179.17,72.35 179.17,74.73 179,74.9 179,76.14 179.46,76.59 182.36,76.59 182.99,77.22 182.99,78.61 183.88,79.49 186.15,79.49
+5V_HDD on BOTTOM (solid shape): 155.14,66.46 155.14,62.61 155.27,62.48 156.55,62.48 156.83,62.2 156.83,60.99 156.55,60.71 154.19,60.71 153.91,60.99 153.91,61 156.35,61 156.35,61.23 155.51,61.23 155.51,61 153.91,61 153.91,61.51 156.35,61.51 156.35,61.71 155.51,61.71 155.51,61.51 153.91,61.51 153.91,61.99 156.35,61.99 156.35,62.22 155.48,62.22 155.48,61.99 153.91,61.99 153.91,63.58 153.71,63.78 153.71,66.41 153.9,66.6 155,66.6
+5V_ODD on BOTTOM (solid shape): 198.05,42.23 198.05,41.72 198.08,41.69 198.28,41.69 198.31,41.72 198.31,42.23 198.33,42.25 198.54,42.25 198.56,42.23 198.56,40.91 198.41,40.76 198.41,40.76 198.23,40.36 198.53,40.03 198.56,40.02 198.92,39.66 198.92,35.95 198.26,35.29 197.57,35.29 197.39,35.12 197.39,33.58 198.87,33.58 198.89,33.55 198.89,33.35 198.87,33.33 197.57,33.33 197.55,33.3 197.55,33.12 197.57,33.1 198.87,33.1 198.89,33.07 198.89,32.84 198.87,32.82 197.57,32.82 197.55,32.79 197.55,32.61 197.57,32.59 198.87,32.59 198.89,32.56 198.89,32.33 198.87,32.31 196.76,32.31 196.53,32.54 196.53,36.23 197.11,36.82 197.11,37.86 196.76,38.22 196.76,41.39 197.62,42.25 198.03,42.25
+5V_RUN on TOP (solid shape): 184.95,86.63 184.95,86.5 184.92,86.48 184.16,86.48 184.14,86.45 184.14,86.27 184.16,86.25 184.92,86.25 184.95,86.22 184.95,86.09 184.92,86.07 184.19,86.07 183.65,85.54 183.65,83.86 183.32,83.53 182.21,83.53 181.95,83.78 181.95,85.89 182.18,86.12 183.35,86.12 183.88,86.65 184.92,86.65
+5V_RUN on TOP (solid shape): 98.26,144.64 98.26,143.63 98.18,143.55 97.8,143.55 97.52,143.83 96.65,143.83 96.21,144.06 95.78,143.8 95.73,143.64 95.72,143.48 95.73,143.45 95.39,143.12 94.83,143.12 94.6,143.35 94.6,144.54 94.97,144.9 95.85,144.9 96.06,145.11 97.79,145.11
+5V_RUN on BOTTOM (solid shape): 196.43,41.62 196.43,38.57 196.22,38.37 195.26,38.37 195.11,38.52 195.11,41.45 195.32,41.66 196.39,41.66
+5V_RUN on BOTTOM (solid shape): 199.2,58.46 199.2,56.48 197.75,55.03 191.02,55.03 189.9,56.15 189.9,56.4 190.08,56.58 195.29,56.58 195.67,56.96 195.67,58.38 196.25,58.97 198.69,58.97
+5V_RUN on BOTTOM (solid shape): 202.8,31.61 202.8,30.62 201.86,29.68 201.86,29.17 201.69,28.99 201.23,28.99 201.1,29.12 201.1,30.9 201.1,30.9 201.1,31.47 201.46,31.82 202.59,31.82
+5V_RUN on BOTTOM (solid shape): 205.81,59.29 205.81,47.06 205.07,46.32 203.08,46.32 202.04,47.36 202.04,49.8 203.72,51.48 203.72,53.71 203.74,53.74 203.74,59.27 203.86,59.38 205.71,59.38
+5V_RUN on BOTTOM (solid shape): 153.3,66.84 153.3,64.22 153.24,64.15 152.56,64.15 152.51,64.2 152.51,65.84 152.11,66.24 152.1,66.25 151.93,66.4 151.7,66.43 151.69,66.43 150.89,66.43 150.3,65.85 149.97,65.85 149.59,66.23 149.59,67.07 150.14,67.62 152.53,67.62
+5V_RUN on IN1 (solid shape): outline of 1413 points within 171.44,84.16 184.29,117.23
+5V_RUN on VCC (solid shape): 183.96,85.28 183.96,76.06 183.97,76.01 183.99,75.97 185.26,74.7 185.31,74.67 185.35,74.66 191.4,74.66 191.83,74.23 191.83,70.78 191.36,70.31 191.33,70.27 191.32,70.22 191.32,68.44 191.33,68.39 191.36,68.35 196.31,63.4 196.35,63.37 196.4,63.36 205.17,63.36 205.67,62.85 205.67,58.33 205.5,58.15 202.68,58.15 201.32,59.51 201.28,59.54 201.23,59.55 199.71,59.55 199.66,59.54 199.62,59.51 199.11,59.01 199.08,58.96 199.07,58.92 199.07,57.44 198.64,57.01 177.03,57.01 175.81,58.23 175.78,58.71 175.3,58.79 175.27,58.77 173.67,60.37 173.67,84.11 174,84.44 175.45,84.44 175.5,84.45 175.54,84.48 176.01,84.95 180.28,84.95 180.32,84.96 180.36,84.99 180.96,85.59 183.65,85.59
+5V_RUN on IN2 (solid shape): 65.54,119.24 65.54,118.13 65.26,117.87 65.1,117.51 64.68,117.09 64.29,117.09 63.47,117.91 63.47,118.87 64.02,119.42 65.37,119.42
+5V_RUN on IN2 (solid shape): outline of 4242 points within 95.64,113.86 174.98,144.36
+5V_RUN on IN3 (solid shape): outline of 1266 points within 162.82,27.32 203.28,38.11
+5V_RUN_AUDIO on BOTTOM (solid shape): 43.83,128.61 43.83,126.99 43.57,126.73 42.63,126.73 42.51,126.86 42.51,128.72 42.56,128.77 43.67,128.77
+5V_RUN_AUDIO on BOTTOM (solid shape): 51.22,117.69 51.22,116.78 50.94,116.5 49.11,116.5 49.08,116.52 49.08,117.72 49.29,117.92 50.99,117.92
+5V_RUN_AUDIO on BOTTOM (solid shape): 50.63,132.32 50.63,131.59 50.56,131.51 49.92,131.51 49.79,131.38 49.79,130.72 49.82,130.7 50.56,130.7 50.58,130.67 50.58,130.54 50.56,130.52 49.82,130.52 49.79,130.49 49.79,130.32 49.82,130.29 50.56,130.29 50.58,130.26 50.58,130.14 50.56,130.11 49.34,130.11 48.75,130.7 48.75,130.98 48.47,131.26 48.47,132.17 48.68,132.37 50.58,132.37
+5V_RUN_AUDIO on IN2 (solid shape): outline of 252 points within 47.46,116.5 52.08,132.04
+5V_RUN_CRT on TOP (solid shape): outline of 301 points within 87.18,142.94 94.74,147.23
+5V_RUN_CRT on BOTTOM (solid shape): 95.36,146.09 95.36,145.35 95.18,145.17 94.02,145.17 93.94,145.25 93.94,146.16 93.56,146.55 93.56,146.75 93.78,146.98 94.47,146.98
+5V_RUN_PVDD on TOP (solid shape): 41.21,120.08 41.21,119.42 41.26,119.37 41.26,118.4 41.08,118.23 40.75,118.23 40.55,118.43 40.55,118.78 41.01,119.24 41.01,120.05 41.06,120.1 41.18,120.1
+5V_RUN_PVDD on TOP (solid shape): 43.22,120.05 43.22,119.34 43.44,119.11 43.72,119.11 43.98,118.86 43.98,118.48 43.83,118.33 43.47,118.33 43.22,118.58 43.22,118.91 43.01,119.11 43.01,120.08 43.04,120.1 43.17,120.1
+5V_RUN_PVDD on BOTTOM (solid shape): 50.66,119.24 50.66,118.17 50.61,118.12 40.88,118.12 40.57,118.43 40.57,118.91 41.01,119.34 50.56,119.34
+5V_TSP on TOP (solid shape): 43.24,103.95 43.24,101 43.14,100.9 43.14,100.37 43.04,100.27 42.63,100.27 42.45,100.45 42.45,102.63 42.48,103.06 42.08,103.23 42.06,103.23 41.87,103.42 39.61,103.42 39.48,103.54 39.48,104.05 39.53,104.1 43.09,104.1
+5V_USB on TOP (solid shape): 156.65,141.09 156.65,137.78 156.4,137.53 150.81,137.53 150.68,137.66 150.68,138.6 154.32,138.6 154.33,138.54 154.34,138.49 154.36,138.43 154.38,138.38 154.42,138.34 154.46,138.3 154.5,138.27 154.55,138.24 154.61,138.23 154.66,138.22 154.72,138.21 154.77,138.22 154.83,138.23 154.88,138.26 154.93,138.28 154.97,138.32 155.01,138.36 155.04,138.41 155.06,138.46 155.08,138.51 155.09,138.57 155.09,138.62 155.08,138.68 155.06,138.73 155.04,138.78 155.01,138.83 154.97,138.87 154.93,138.91 154.88,138.94 154.83,138.96 154.77,138.97 154.72,138.98 154.66,138.98 154.61,138.97 154.55,138.95 154.5,138.92 154.46,138.89 154.42,138.85 154.38,138.81 154.36,138.76 154.34,138.71 154.33,138.65 154.32,138.6 150.68,138.6 150.68,139.43 150.81,139.56 154.93,139.56 155.13,139.76 155.13,141.01 155.33,141.21 156.53,141.21
+5V_USB on BOTTOM (solid shape): outline of 87 points within 145.86,134.48 152.97,139
+5V_USB_CHG_PWR on TOP (solid shape): 20.14,101.14 20.14,98.42 19.76,98.03 17.59,98.03 17.46,97.91 17.46,97.02 17.14,96.7 13.69,96.7 13.37,97.02 13.37,97.65 13.77,98.05 14.4,98.05 15.26,98.91 15.26,101.43 15.55,101.72 19.57,101.72
+5V_USB_CHG_PWR on BOTTOM (solid shape): 21.93,101.08 21.93,96.66 21.09,96.66 20.92,96.84 20.92,97.09 19.92,98.08 16.62,98.08 15.3,96.76 13.91,96.76 13.65,97.02 13.65,98.54 14.16,99.05 15.56,99.05 16.45,99.94 16.45,101.84 16.7,102.1 20.91,102.1
+P1.0V_PEX_VDD on TOP (solid shape): 115,147.69 115,144.01 114.68,143.69 110.49,143.69 109.54,142.74 109.54,140.32 109.41,140.2 107.76,140.2 107.63,140.32 107.63,144.9 109.35,146.61 111.57,146.61 112.9,147.94 114.74,147.94
+P1.0V_PEX_VDD on BOTTOM (solid shape): 140.26,122.43 140.26,120.35 140.03,120.12 139.42,120.12 139.03,120.51 133.41,120.51 133.06,120.87 133.06,122.16 133.44,122.54 140.14,122.54
+P1.0V_PEX_VDD on BOTTOM (solid shape): 121.64,146.63 121.64,145.73 122.22,145.15 123.18,145.15 124.34,143.98 124.34,143.36 124.29,143.17 124.34,142.98 124.34,141.31 124.32,141.29 124.09,141.29 124.06,141.31 124.06,142.84 124.04,142.86 123.86,142.86 123.84,142.84 123.84,141.31 123.81,141.29 123.58,141.29 123.56,141.31 123.56,142.84 123.53,142.86 123.38,142.86 123.35,142.84 123.35,141.31 123.33,141.29 123.1,141.29 123.07,141.31 123.07,142.99 122.95,143.12 122.08,143.12 122.01,143.15 121.98,143.22 121.81,143.54 121.45,143.57 121.42,143.55 120.41,144.56 120.1,144.56 119.57,145.1 119.57,146.67 119.7,146.8 121.47,146.8
+P1.0V_PEX_VDD on IN1 (solid shape): 141.54,123.94 141.54,122.13 141.51,122.06 141.43,122.03 141.01,121.65 141.43,121.27 141.51,121.25 141.54,121.17 141.54,120.61 141.18,120.26 141.13,120.26 141.06,120.29 141.03,120.36 140.65,120.74 140.27,120.36 140.24,120.29 140.17,120.26 139.71,120.26 139.43,120.54 139.43,123.94 139.56,124.07 141.41,124.07
+P1.0V_PEX_VDD on IN1 (solid shape): 110.26,141.76 110.23,141.72 110.08,141.45 110.03,141.14 110.03,140.92 110.16,140.44 110.53,140.1 110.53,137.76 110.3,137.53 108.14,137.53 107.94,137.73 107.94,139.25 108,139.34 108.11,139.32 108.77,139.58 108.11,139.83 108,139.81 107.94,139.9 107.94,140.93 108.9,141.9 110.12,141.9
+P1.0V_PEX_VDD on IN2 (solid shape): 115.02,147.94 115.38,147.69 115.74,147.94 115.75,147.97 117.31,147.97 117.33,147.94 117.66,147.74 118,147.94 118.02,147.97 118.46,147.97 118.47,147.94 118.81,147.74 119.14,147.94 119.16,147.97 119.6,147.97 119.61,147.94 119.95,147.74 120.29,147.94 120.3,147.97 120.74,147.97 120.76,147.94 121.03,147.74 121.35,147.84 121.4,147.89 121.6,147.69 121.6,145.66 121.35,145.4 119.04,145.4 118.93,145.51 118.93,145.53 118.54,145.91 118.17,145.51 118.14,145.43 118.07,145.4 117.29,145.4 117.28,145.45 116.9,145.78 116.52,145.45 116.52,145.4 113.78,145.4 112.76,146.42 112.76,147.74 112.99,147.97 115.01,147.97
+VCC_CORE on TOP (solid shape): 120.07,118.95 120.07,115.88 119.85,115.66 114.46,115.66 114.11,115.3 114.11,109.82 113.7,109.41 107.96,109.41 107.75,109.61 107.75,116.83 108.65,116.83 108.9,117.08 108.9,117.59 109.24,117.93 111.67,117.93 111.8,117.81 112.46,117.81 112.58,117.83 112.68,117.88 112.95,117.88 113.14,118.07 113.14,119.41 113.5,119.77 119.25,119.77
+VCC_CORE on TOP (solid shape): outline of 214 points within 112.71,87.49 120.58,99.3
+VCC_CORE on BOTTOM (solid shape): 118.3,117.97 118.3,116.07 117.92,115.69 116.01,115.69 115.89,115.56 114.36,115.56 114.11,115.3 114.11,109.26 113.99,109.14 110.16,109.14 109.66,109.64 109.66,117.45 109.45,117.67 109.1,117.67 108.95,117.82 108.95,118.12 109.05,118.23 118.04,118.23
+VCC_CORE on BOTTOM (solid shape): 119.38,88.56 119.38,87.6 119.34,87.24 119.64,87.06 119.72,87.03 119.75,86.96 119.75,86.59 119.82,86.52 119.82,86.42 119.41,86.02 118.98,86.02 118.72,86.28 118.67,86.28 118.6,86.35 118.6,86.88 118.6,86.92 118.59,87 118.56,87.07 118.52,87.13 118.49,87.13 118.47,87.15 118.33,87.22 118.17,87.21 118.14,87.21 118.07,87.16 118.01,87.13 117.94,86.95 117.98,86.76 117.99,86.75 117.99,86.42 117.45,85.89 117.3,85.89 116.82,86.37 116.72,86.47 116.72,86.75 116.77,86.94 116.69,87.13 116.66,87.13 116.65,87.15 116.44,87.23 116.23,87.15 116.22,87.13 116.18,87.13 116.11,86.94 116.16,86.75 116.16,86.32 116.13,86.29 115.85,86.29 114.9,87.25 114.74,87.25 114.49,87.5 114.49,87.87 114.62,88 114.62,88.51 114.87,88.76 114.9,88.76 114.97,88.84 119.11,88.84
+VCC_CORE on BOTTOM (solid shape): outline of 393 points within 113.02,96.41 120.76,99.23
+VCC_CORE on IN1 (solid shape): outline of 5672 points within 103.03,85.97 121.09,117.32
+VCC_CORE on VCC (solid shape): 121.35,118.3 121.35,87.29 120.91,86.86 109.21,86.86 108.9,87.16 108.9,97.52 108.89,97.57 108.86,97.61 108.61,97.87 108.57,97.9 108.52,97.91 106.16,97.91 105.98,98.08 105.98,105.27 105.97,105.32 105.94,105.36 105.6,105.7 105.6,106.23 105.94,106.58 105.97,106.62 105.98,106.67 105.98,118.17 106.79,118.99 120.66,118.99
+VCC_CORE on IN2 (solid shape): outline of 5845 points within 102.93,87.49 122.74,116.59
+VCC_CORE on IN3 (solid shape): outline of 1149 points within 112.58,85.97 120.58,99.3
+VCC_GT on TOP (solid shape): outline of 895 points within 69.87,88.47 110.17,103.3
+VCC_GT on BOTTOM (solid shape): outline of 1199 points within 70.64,89.45 112.94,101.88
+VCC_GT on IN1 (solid shape): outline of 1256 points within 77.91,89.27 107.33,99.68
+VCC_GT on VCC (solid shape): 105.73,109.26 105.73,106.72 105.38,106.38 105.35,106.34 105.34,106.29 105.34,105.65 105.35,105.6 105.38,105.56 105.73,105.22 105.73,98.03 105.74,97.98 105.76,97.94 106.02,97.69 106.06,97.66 106.11,97.65 108.47,97.65 108.65,97.47 108.65,89.73 108.32,89.4 97.52,89.4 96.96,89.96 96.96,91.94 96.95,91.98 96.93,92.03 95.78,93.17 95.74,93.2 95.69,93.21 90.99,93.21 90.95,93.2 90.9,93.17 88.4,90.67 83.63,90.67 83.58,90.66 83.54,90.63 82.05,89.14 73.65,89.14 71.31,91.48 71.31,105.22 75.43,109.34 81.98,109.34 82.03,109.34 82.07,109.37 82.41,109.72 105.27,109.72
+VCC_GT on IN2 (solid shape): outline of 2625 points within 78.29,90.99 108.65,103.59
+VCC_GT on IN3 (solid shape): 102.63,103.47 104.33,103.47 104.56,103.24 110.37,103.24 110.7,102.91 110.7,102.58 110.39,102.26 102.31,102.26 101.84,102.73 100.29,102.73 100.01,103.01 100.01,103.52 100.29,103.8 102.3,103.8
+VCC_GT on IN3 (solid shape): outline of 1108 points within 78.29,89.7 109.03,98.64
+VCC_GT on IN4 (solid shape): outline of 1151 points within 80.45,89.7 109.03,99.68
+VCC_GTX on BOTTOM (solid shape): outline of 334 points within 103.83,86.18 114.22,88.46
+VCC_SA on TOP (solid shape): 123.99,98.82 123.99,98.26 124.24,98.01 124.24,97.3 124.19,97.24 123.94,97.24 123.76,97.07 123.76,95.62 123.63,95.49 121.98,95.49 121.85,95.62 121.85,97.52 121.91,97.57 121.94,97.57 122.11,97.74 122.11,98.73 122.3,98.92 123.89,98.92
+VCC_SA on TOP (solid shape): 124.39,90.74 124.39,88.81 124.5,88.71 124.5,88.27 124.26,88.02 124.26,87.61 124.1,87.45 122.81,87.45 122.67,87.59 122.67,87.8 122.87,88 123.63,88 123.67,88.04 123.67,88.6 124.01,88.94 124.01,90.72 124.09,90.79 124.34,90.79
+VCC_SA on TOP (solid shape): 125.54,117.68 126.17,117.68 126.26,117.69 126.34,117.72 128.59,117.72 128.89,117.41 128.89,109.28 125.11,109.28 124.72,109.69 124.34,109.28 123.2,109.28 123.12,109.36 123.12,115.1 123.56,115.53 123.56,117.41 123.86,117.72 125.5,117.72
+VCC_SA on BOTTOM (solid shape): 124.31,88.39 124.31,87.61 124.37,87.54 124.37,87.36 124.24,87.24 123,87.24 122.74,87.49 122.74,88.51 122.87,88.63 124.06,88.63
+VCC_SA on BOTTOM (solid shape): 124.79,98.3 124.79,98.17 124.27,97.65 124.27,96.64 124.14,96.51 120.58,96.51 120.47,96.62 120.47,97.59 120.46,97.61 120.39,97.69 120.38,97.8 120.48,97.91 121.04,97.91 121.06,97.92 121.07,97.92 121.29,98.1 121.28,98.37 121.27,98.39 121.27,98.77 121.4,98.9 121.55,98.9 121.62,98.83 121.68,98.83 121.69,98.82 121.93,98.73 122.17,98.82 122.18,98.83 122.23,98.83 122.3,98.9 122.47,98.9 122.59,98.78 122.59,98.39 122.84,97.92 123.09,98.39 123.09,98.86 123.18,98.95 124.14,98.95
+VCC_SA on IN1 (solid shape): outline of 2646 points within 121.27,87.52 130.08,114.42
+VCC_SA on VCC (solid shape): 131.38,114.26 131.38,107.36 131.04,107.01 131.01,106.97 131,106.92 131,106.54 131.01,106.49 131.04,106.45 131.38,106.11 131.38,97.58 130.4,96.6 130.37,96.56 130.36,96.51 130.36,95.29 129.93,94.86 125.41,94.86 125.36,94.85 125.32,94.82 124.69,94.18 124.66,94.14 124.65,94.1 124.65,88.94 124.3,88.6 124.28,88.56 124.27,88.51 124.27,87.82 123.81,87.36 122.06,87.36 121.6,87.82 121.6,114.26 122.01,114.67 130.97,114.67
+VCC_SA on IN3 (solid shape): outline of 439 points within 120.97,87.49 124.27,98.29
+VCC_SFR_OC on TOP (solid shape): 116.65,68.59 116.65,68.24 116.77,68.11 117.18,68.11 117.31,67.98 117.31,67.83 117.56,67.58 118.25,67.58 118.4,67.43 118.4,66.08 118.27,65.95 117.97,65.95 117.84,66.08 117.84,66.38 117.46,66.76 117.46,66.92 117.3,67.08 117.14,67.08 117.13,67.09 116.09,67.09 116.04,67.15 116.04,68.59 116.14,68.7 116.55,68.7
+VDDA_AVDD1 on BOTTOM (solid shape): 41.57,127.95 41.57,125.44 41.46,125.34 39.41,125.34 39.15,125.08 39.15,124.27 38.82,123.94 37.91,123.94 37.77,124.08 37.77,124.36 37.88,124.47 38.14,124.47 38.54,124.88 38.54,127.5 39.25,128.21 41.31,128.21
GND on TOP (solid shape): 272.99,15.33 266.64,15.33 266.64,25.67 272.99,25.67
GND on TOP (solid shape): 88.48,115.46 88.48,113.96 88.4,113.88 87.82,113.88 87.82,115.46 87.89,115.53 88.4,115.53
GND on TOP (solid shape): 145.12,59.45 145.12,58.26 142.71,58.26 142.53,58.43 142.53,60.77 142.68,60.92 143.65,60.92
GND on TOP (solid shape): 25.98,102.28 25.98,99.43 25.7,99.14 22.49,99.14 22.02,99.61 22.02,101.71 22.72,102.41 25.85,102.41
GND on TOP (solid shape): 32.98,130.55 32.98,128.79 32.85,128.66 32.23,128.66 32.17,128.72 32.17,130.47 32.45,130.75 32.78,130.75
GND on TOP (solid shape): 55.66,110.2 55.66,106.69 55.45,106.48 54.23,106.48 54.18,106.53 54.18,110.69 54.2,110.72 55.14,110.72
GND on TOP (solid shape): 85.79,26.66 85.79,25.39 85.66,25.26 85.15,25.26 85.02,25.39 85.02,26.66 85.15,26.79 85.66,26.79
GND on TOP (solid shape): 94.3,49.26 94.3,47.11 94.04,46.85 90.74,46.85 90.61,46.98 90.61,49.14 90.87,49.39 94.17,49.39
GND on TOP (solid shape): 94.42,38.32 94.42,37.1 94.22,36.89 93.74,36.89 93.53,37.1 93.53,38.29 93.64,38.39 94.35,38.39
GND on TOP (solid shape): 98.64,38.32 98.64,36.97 98.39,36.72 97.93,36.72 97.72,36.92 97.72,38.32 97.83,38.42 98.54,38.42
GND on TOP (solid shape): 100.85,33.58 100.85,32.06 100.66,31.87 100.29,31.87 99.88,32.27 99.88,33.57 99.99,33.68 100.75,33.68
GND on TOP (solid shape): 114.49,90.92 114.49,88.13 114.36,88 114.11,88 113.98,88.13 113.98,90.92 114.11,91.05 114.36,91.05
GND on TOP (solid shape): 123,65.6 123,64.3 122.85,64.15 121.85,64.15 121.58,64.43 121.58,65.57 121.78,65.77 122.82,65.77
GND on TOP (solid shape): 133.08,36.62 133.08,32.65 133.03,32.6 131.97,32.6 131.6,32.96 131.6,37.19 131.65,37.24 132.46,37.24
GND on TOP (solid shape): 140,35.22 140,34 139.57,33.57 138.44,33.57 138.2,33.81 138.2,35.32 138.25,35.38 139.85,35.38
GND on TOP (solid shape): 186.99,25.41 186.99,24.42 186.89,24.32 185.9,24.32 185.78,24.44 185.78,25.34 185.93,25.49 186.91,25.49
GND on TOP (solid shape): 188.2,107.07 188.2,104.48 187.95,104.23 187.54,104.23 187.34,104.43 187.34,107.15 187.44,107.25 188.02,107.25
GND on TOP (solid shape): 188.81,24.95 188.81,24.41 188.72,24.32 187.66,24.32 187.64,24.34 187.64,25.33 187.8,25.5 188.27,25.5
GND on TOP (solid shape): 206.36,151.09 206.36,150.51 206.26,150.41 204.25,150.41 204.13,150.53 204.13,151.04 204.33,151.25 206.21,151.25
GND on TOP (solid shape): 243.44,63.67 243.44,63.11 243.37,63.03 242.12,63.03 242.02,63.13 242.02,63.74 242.07,63.79 243.32,63.79
GND on TOP (solid shape): 266.36,21.22 266.36,14.72 266.17,14.54 262.78,14.54 262.47,14.85 262.47,20.5 263.55,21.58 266,21.58
GND on TOP (solid shape): 272.86,52.85 272.86,51.3 272.68,51.12 271.82,51.12 271.71,51.22 271.71,52.97 271.82,53.07 272.63,53.07
GND on TOP (solid shape): 36.97,94.48 36.97,94.13 36.89,94.05 34.94,94.05 34.86,94.12 34.86,94.5 36.43,94.5 36.49,94.55 36.89,94.55
GND on TOP (solid shape): 91.2,33.31 91.2,31.99 91.1,31.89 90.66,31.89 90.23,32.32 90.23,33.34 90.28,33.39 91.12,33.39
GND on TOP (solid shape): 124.98,49.44 124.98,48.45 123.86,47.33 109.73,47.33 109.32,47.74 109.32,49.39 110.21,50.28 124.14,50.28
GND on TOP (solid shape): 150.81,49.59 150.81,47.21 150.4,46.8 149.41,46.8 149.02,47.19 149.02,49.61 149.69,50.28 150.12,50.28
GND on TOP (solid shape): 151.6,32.91 151.6,31.87 147.33,31.87 147.15,32.04 147.15,33.03 147.33,33.21 151.29,33.21
GND on TOP (solid shape): 190.28,116.37 190.28,115.38 190.23,115.33 187.21,115.33 187.21,116.09 187.34,116.22 189.32,116.22 189.57,116.47 190.18,116.47
GND on TOP (solid shape): 212.13,52.97 212.48,52.62 212.48,51.68 211.87,50.38 211.26,50.38 211.14,50.51 211.14,52.9 211.67,53.43 212.13,53.43
GND on TOP (solid shape): 26.48,90.16 26.48,87.11 26.35,86.99 24.83,86.99 24.7,87.11 24.7,90.16 24.83,90.29 26.35,90.29
GND on TOP (solid shape): 40.07,115.81 40.07,114.97 39.81,114.72 34.86,114.72 34.78,114.8 34.78,115.63 35.09,115.94 39.94,115.94
GND on TOP (solid shape): 94.42,110.72 94.42,109.08 94.17,108.83 92.04,108.83 91.76,109.11 91.76,110.99 94.16,110.99
GND on TOP (solid shape): 100.01,49.52 100.01,46.98 99.88,46.85 96.96,46.85 96.71,47.11 96.71,49.77 96.84,49.9 99.63,49.9
GND on TOP (solid shape): 137.27,74.31 137.27,72.12 136.54,71.39 135.14,71.39 135.13,71.4 134.95,71.4 134.68,71.67 134.68,73.78 135.29,74.38 137.2,74.38
