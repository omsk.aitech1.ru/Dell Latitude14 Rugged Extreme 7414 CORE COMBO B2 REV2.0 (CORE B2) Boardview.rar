# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_PRX_DTX_N0: length 12.5
  BOTTOM w0.102: v6(193.17,38.34) 193.18,38.34 ; 193.18,38.34 193.18,38.95 193.1,39.03 CS3.2 ; 193.18,38.34 193.18,33.6 196.83,29.95 JODD1.6
SATA_PRX_DTX_P0: length 12.5
  BOTTOM w0.102: CS4.2 193.38,38.9 193.38,33.68 196.91,30.15 197.13,30.15 197.43,30.45 JODD1.7
SATA_PTX_C_DRX_N0: length 121
  IN3 w0.076: v3(125.91,105.04) 125.91,102.23 127.03,101.11 127.03,97.51 126.75,97.24 125.99,97.24 125.04,96.29 125.04,94.23 124.43,93.63 124.43,90.33 124.84,89.92 125.53,89.92 126.64,88.8 130.25,88.8 130.55,88.51 132.44,88.51 132.7,88.25 132.7,86.63 132.52,86.45 132.52,82.54 132.78,82.28
  IN3 w0.102: v1(190.94,46.6) 190.57,46.97 190.55,46.97 190.39,47.13 189.82,47.13 189.51,46.82 189.51,46.38 189,45.88 183.87,45.88 180.81,48.93 180.16,48.93 175.23,53.86 171.85,53.86 170.8,54.9 165.59,54.9 164.96,55.54 160.94,55.54 160.53,55.94 160.26,55.94 155.24,60.96 155.24,62.48 153.35,64.38 149.29,64.38 146.92,66.74 146.29,66.74 145.43,67.6 143.99,67.6 142.28,69.31 142.28,71.19 140.2,73.27 137.83,73.27 137.35,73.75 137.35,76.8 133.16,80.99 133.16,81.9 132.78,82.28
  BOTTOM w0.076: v3(125.91,105.04) 125.91,104.43 126.1,104.25 126.1,102.4 UC1.B21
  BOTTOM w0.102: 192.21,42.88 192.21,41.09 192.01,40.89 CS2.1 ; 192.21,42.88 v6(192.25,42.88) ; 192.21,42.88 192.21,45.08 191.23,46.06 190.92,46.06 190.76,46.22 190.76,46.41 v1(190.94,46.6)
SATA_PTX_C_DRX_P0: length 121
  IN3 w0.076: 132.36,82.34 132.36,86.52 132.54,86.7 132.54,88.18 132.37,88.34 130.48,88.34 130.19,88.63 126.57,88.63 125.46,89.75 124.78,89.75 124.27,90.26 124.27,93.69 124.88,94.3 124.88,96.36 125.92,97.4 126.69,97.4 126.86,97.58 126.86,101.04 125.75,102.16 125.75,104.67 125.68,104.74 125.44,104.74 125.35,104.82 v3(125.35,105.07)
  IN3 w0.102: v1(190.31,46.6) 190.31,46.75 190.18,46.88 189.93,46.88 189.76,46.71 189.76,46.28 189.1,45.62 183.76,45.62 180.71,48.67 180.05,48.67 175.12,53.61 171.74,53.61 170.7,54.65 165.49,54.65 164.85,55.28 160.83,55.28 160.43,55.69 160.15,55.69 154.99,60.86 154.99,62.38 153.25,64.12 149.18,64.12 146.82,66.49 146.18,66.49 145.32,67.35 143.88,67.35 142.02,69.21 142.02,71.08 140.09,73.01 137.73,73.01 137.09,73.64 137.09,76.7 132.9,80.89 132.9,81.8 132.36,82.34
  BOTTOM w0.076: v3(125.35,105.07) 125.75,104.67 125.75,104.36 125.93,104.18 125.93,102.88 UC1.A21
  BOTTOM w0.102: v1(190.31,46.6) 190.55,46.35 190.55,46.14 190.83,45.86 191.15,45.86 192.01,45 192.01,44.59 ; 192.01,44.59 192.01,41.17 191.7,40.87 191.34,40.87 191.2,40.73 CS1.1 ; 192.01,44.59 v6(191.98,44.59)
SATA_PTX_DRX_N0: length 14.6
  BOTTOM w0.102: JODD1.4 196.96,28.95 191.4,34.51 191.4,38.82 191.5,38.93 191.87,38.93 192.01,39.07 CS2.2
SATA_PTX_DRX_P0: length 14.6
  BOTTOM w0.102: JODD1.3 197.71,28.45 197.41,28.75 196.87,28.75 191.2,34.42 191.2,38.24 ; 191.2,38.24 CS1.2 ; 191.2,38.24 v6(191.18,38.24)
SATAGP1: length 17.3
  BOTTOM w0.076: 139.29,104.79 140,104.08 140,100.25 139.66,99.91 139.66,98.93 139.36,98.63 138.93,98.63 138.16,97.86 138.16,97.77 137.97,97.58 135.77,97.58 135.6,97.75 135.6,97.99 136.14,98.54 UC1.H3
  BOTTOM w0.108: RC467.1 141.21,108.65 141.04,108.65 139.95,107.56 139.95,106.93 139.29,106.27 139.29,104.79
SD_RCOMP: length 2.3
  TOP w0.203: v3(133.96,91) 134.1,90.86 RC96.2 134.11,90.4 v2(135,90.4)
  BOTTOM w0.152: UC1.AB7 133.96,91.02 v3(133.96,91)
SENS_DET#: length 151.2
  TOP w0.108: U37.A45 258.03,59.13 257.01,60.16 v1(257.01,60.64) 257.01,60.87 R9408.2
  IN1 w0.089: v1(254.06,25.52) 250.12,25.52 249.62,26.02 243.72,26.02 242.75,25.05 229.63,25.05 229.27,24.69 229.17,24.58 217.2,24.58 215.28,26.5 214.4,26.5 213.07,27.84 213.07,29.08 211.48,30.67 188.89,30.67 184.96,34.6 176.27,34.6 175.11,35.76 174.11,35.76 169.31,40.57 169.31,52.01 v1(169.86,52.57)
  BOTTOM w0.108: v1(257.01,60.64) 257.24,60.41 257.24,59.83 258.02,59.05 258.02,57.6 259.06,56.56 259.06,51.3 258.68,50.93 258.68,48.54 257.55,47.41 257.55,45.92 255.87,44.24 255.87,42.66 255.1,41.89 255.1,40.69 254.33,39.92 254.33,38.35 255.12,37.56 255.12,36.99 255.25,36.86 255.25,33.97 254.93,33.64 254.93,31.84 253.68,30.59 253.68,28.24 v2(253.73,28.18) 254.06,27.85 v1(254.06,25.52) ; JSH1.1 170.66,53.75 169.86,52.95 v1(169.86,52.57)
SIM_CLK: length 10.1
  TOP w0.108: JSIMUAJ2.1 249.96,101.08 250.14,100.9 251.75,100.9 251.87,100.78 U6220.6 U6220.5 253.25,100.78 253.38,100.92 253.38,101.11 252.94,101.54 v1(250.98,101.54)
  BOTTOM w0.108: v1(250.98,101.54) 250.98,101.55 JSIM1.3
SIM_DATA: length 15.6
  TOP w0.108: JSIMUAJ2.3 248.96,100.9 250.57,99.28 U6220.9 U6220.2 254.09,99.28 254.37,99.56 v2(254.37,100.57) 254.37,101.33 v1(253.45,102.25)
  BOTTOM w0.108: JSIM1.7 v1(253.45,102.25)
SIM_DE: length 23.7
  TOP w0.108: v1(250.68,102.69) 252.33,102.69 253.86,101.16 253.86,100.5 253.64,100.28 U6220.4 U6220.7 251.45,100.28 v2(251.27,100.47) 251.27,100.47 249.87,100.47 249.46,100.88 JSIMUAJ2.2
  BOTTOM w0.108: v1(250.68,102.69) 249.03,104.35 JSIM1.9 247.52,104.35 247.14,103.97 247.14,101.19 246.11,100.17 244.79,100.17 244.16,99.53 244.16,98.87 R7102.1 243.44,99.18 242.73,99.18 R7101.2
SIM_DET: length 138.3
  TOP w0.108: v1(13.14,139.33) 13.21,139.27 C266.1 13.74,139.08 14.43,139.08 17.1,136.41 18.88,136.41 v5(19.49,135.8) 19.87,135.42 v1(19.87,135.17)
  IN3 w0.089: v1(101.66,146.01) 101.46,146.01 95.65,140.2 87.09,140.2 86.74,139.85 79.12,139.85 78.11,138.84 75.79,138.84 68.69,131.74 68.69,127.57 62.69,121.57 59.34,121.57 58.43,120.67 57.88,120.67 57.4,120.19 51.75,120.19 51.07,119.51 50.29,119.51 48.49,117.71 48.1,117.71 48.1,117.71 47.08,117.71 45.21,115.84 44.47,115.84 41.15,112.53 34.97,112.53 34.38,111.94 29.2,111.94 28.61,112.53 28.11,112.53 24.8,115.84 24.8,131.35 21.34,134.81 20.23,134.81 v1(19.87,135.17)
  BOTTOM w0.108: JSIMUAJ1.17 13.23,139.24 v1(13.14,139.33) ; JWWAN1.66 101.48,137.83 103.66,140.01 103.66,141.57 101.66,143.57 v1(101.66,146.01)
SIM_DET#: length 314.1
  TOP w0.108: R9406.2 v1(253.68,46.72) 254.19,47.23 254.19,47.36 254.67,47.84 255.25,47.84 255.56,47.53 256.61,47.53 257.03,47.95 U37.A2
  IN2 w0.089: v1(16.62,135.62) 18.34,133.9 18.34,130.99 18.07,130.72 18.07,117.23 19.14,116.16 20.32,116.16 20.81,115.67 20.81,115.2 22.74,113.27 24.32,113.27 29.42,108.18 50.83,108.18 52.35,109.7 56.83,109.7 57.44,109.09 59.3,109.09 64.12,104.26 64.12,99.6 71.4,92.32 71.4,91.17 74.16,88.41 81.33,88.41 84.16,85.57 84.16,84.99 106.84,62.31 118.12,62.31 118.74,62.94 132.83,62.94 135.52,60.24 140.91,60.24 141.69,61.02 143.4,61.02 144.51,59.91 146.6,59.91 147.13,60.45 148.07,60.45 149,61.37 151.88,61.37 152.55,60.7 154.7,60.7 155.39,61.39 158.41,61.39 159.36,62.34 161.28,62.34 163.6,60.01 164.88,60.01 167.43,57.46 170.15,57.46 171.07,56.55 171.07,54.78 172.85,53 175.71,53 183.38,45.32 194.96,45.32 197.22,47.58 202.84,47.58 205.51,44.91 209.11,44.91 209.26,45.07 226.17,45.07 226.8,44.44 229.2,44.44 233.39,40.25 239.72,40.25 241.52,42.05 241.86,42.05 241.86,42.05 249.55,42.05 250.28,42.78 253.23,42.78 v1(254.06,41.95)
  BOTTOM w0.108: v1(253.68,46.72) 253.68,45.71 v2(254.06,45.33) 254.56,44.83 254.56,42.44 v1(254.06,41.95) ; JSIMUAJ1.13 15.23,137.73 16.52,136.44 16.52,135.73 v1(16.62,135.62)
SIM_GND: length 29.6
  TOP w0.254: v1(253.92,99.73) 253.87,99.78 U6220.3 U6220.8 251.74,99.78 v1(251.68,99.73)
  TOP w0.508: JSIMUAJ2.19 v1(250.27,104.4) ; JSIMUAJ2.19 251.61,105.69 ; JSIMUAJ2.19 253.15,104.4
  BOTTOM w0.305: JSIM1.16 256.91,107.19 ; JSIM1.16 258.64,107.97 ; JSIM1.16 255.61,107.97 ; 251.75,107.97 JSIM1.14 250.69,107.36
  BOTTOM w0.406: v1(241.56,99.61) R7101.1
  BOTTOM w0.457: v1(246.49,99.81) 246.11,99.43 C7106.2 C7112.2 v1(245.71,97.75)
  BOTTOM w0.508: JSIM1.11 246.66,95.29 246.64,95.3 ; JSIM1.11 247.65,96.54 ; JSIM1.11 248.67,95.29 248.67,95.29 ; JSIM1.15 256.91,94.08 ; JSIM1.15 255.91,93.64 ; JSIM1.15 257.92,93.64 ; JSIM1.15 256.91,93.19 ; 249,93.64 JSIM1.13 ; JSIM1.13 250.05,93.19 ; JSIM1.13 250.05,94.08 ; JSIM1.13 251.11,93.64 ; v1(248.85,99.45) JSIM1.5 246.86,99.45 v1(246.49,99.81) ; 247.76,97.54 JSIM1.10 v1(248.85,98.05) ; JSIM1.12 v1(248.7,105.43)
  vias: v1(239.13,100.01) v1(240.39,99.92) v1(240.85,99.05) v1(245.37,96.13) v1(246.73,103.94) v1(246.73,103) v1(246.87,100.31) v1(248.81,106.42) v1(248.73,103.85) v1(249.49,97.04) v1(249.54,103.09) v1(249.85,107.1) v1(250.79,91.73) v1(251.93,93.64) v1(252.23,107.46) v1(252.87,89.32) v1(252.99,98.06) v1(253.48,105.12) v1(253.83,95.7) v1(255.23,107.48) v1(255.48,102.15) v1(255.76,99.07) v1(256.91,94.91) v1(257.39,105.42) v1(257.41,106.87) v1(258.99,93.64) v1(259.24,107.86) v1(259.65,102.55) v1(259.7,98.51) v1(260.49,86.3) v1(262.6,106.67) v1(262.6,104.13) v1(262.6,101.59) v1(262.6,99.05) v1(262.61,96.1) v1(262.61,92.6) v1(262.61,89.19) v5(255.89,103.37)
SIM_RESET: length 16.2
  TOP w0.108: JSIMUAJ2.4 248.46,100.78 v2(249.78,99.46) 250.46,98.78 U6220.10 U6220.1 254.33,98.78 254.93,99.38 v1(254.93,100.04)
  BOTTOM w0.108: v1(254.93,100.04) 254.82,100.15 JSIM1.2
SIM_VPP: length 8.7
  TOP w0.127: v1(255.43,100.85) 255.43,100.73 T7101.1
  BOTTOM w0.108: v1(255.43,100.85) 252.14,100.85
  BOTTOM w0.127: 252.14,100.85 JSIM1.6
SIO_EXT_SCI#: length 177.5
  TOP w0.108: v1(237.88,62.65) 237.87,62.65 237.75,62.52 U38.A33
  IN1 w0.076: v3(133.82,85.46) 134.28,85 134.28,81.52 137.58,78.22 140.64,78.22 141.16,78.74
  IN1 w0.089: v1(155.64,87.87) 154.99,87.22 154.99,84.27 155.44,83.82 v1(156.27,83.82) 156.15,83.7 156.15,82.29 156.01,82.14 154.4,82.14 153.74,81.47 152.49,81.47 151.31,80.29 149.76,80.29 148.21,78.74 141.16,78.74
  IN2 w0.089: v1(249.41,57.6) 249.19,57.37 249.19,57.26 247.09,55.16 244.99,55.16 244.88,55.27 243.95,56.2 242.81,56.2 242.25,56.76 239.44,56.76 238.97,57.23 229.96,57.23 228.19,55.46 227.14,55.46 226.23,54.55 219.69,54.55 217.91,56.33 212.48,56.33 212.35,56.45 209.02,56.45 208.41,55.84 207.04,54.47 194.77,54.47 193.93,55.31 190.54,55.31 189.13,56.71 188.16,56.71 185.01,59.86 182.96,59.86 174.97,67.85 174.97,84.19 174.25,84.91 168.91,84.91 168.31,84.32 161.22,84.32 158.91,82.01 158.09,82.01 v1(156.27,83.82)
  IN3 w0.089: v1(249.41,57.6) 249.41,58.31 248.84,58.88 245.14,58.88 244.62,59.4 243.57,60.45 243,60.45 242.47,60.99 242.47,62.51 241.29,63.68 237.74,63.68 237.48,63.43 237.48,63.05 v1(237.88,62.65)
  BOTTOM w0.076: UC1.AN7 133.93,85.46 v3(133.82,85.46)
  BOTTOM w0.108: v1(155.64,87.87) RC199.2 ; v2(237.26,62.03) v1(237.88,62.65)
SIO_EXT_SMI#: length 155.9
  TOP w0.108: U38.A6 232.75,51.1 233.06,50.78 233.06,49.47 230.99,47.4 230.99,47.28 v1(230.57,46.85)
  IN1 w0.089: v1(221.8,55.49) 220.53,54.22 220.53,52.69 221.07,52.16 221.07,49.69 222.63,48.12 228.53,48.12 229.8,46.85 v1(230.57,46.85)
  IN2 w0.076: 141.16,99.53 140.75,99.94 137.75,99.94 v3(134.73,102.96)
  IN2 w0.089: v1(221.8,55.49) 220.51,56.78 219.37,56.78 218.93,57.22 212.85,57.22 212.72,57.34 208.66,57.34 206.67,55.36 195.13,55.36 194.3,56.2 190.91,56.2 189.5,57.6 188.63,57.6 185.39,60.84 184.23,60.84 179.23,65.84 179.23,83.08 178.9,83.4 178.32,83.4 176.82,84.9 176.82,92.22 172.54,96.5 169.02,96.5 167.96,95.44 162.56,95.44 162.33,95.67 161.76,95.67 160.38,97.05 158.43,97.05 157.21,95.83 155.57,95.83 154.46,96.94 151.25,96.94 150.39,97.8 142.89,97.8 141.16,99.53
  BOTTOM w0.076: 135.68,104.33 135.1,103.75 135.1,103.33 v3(134.73,102.96) 135,102.69 UC1.A6
  BOTTOM w0.108: RC481.1 134.99,108.95 135.68,108.26 135.68,104.33 ; v1(221.8,55.49) 221.8,55.72 v2(222.2,56.11)
SIO_EXT_WAKE#: length 153.5
  TOP w0.108: R316.1 230.25,44.12 230.57,44.44 v1(230.57,45.45)
  IN1 w0.089: v1(149.67,89.02) 150.81,89.02 153.85,92.05 157.53,92.05 v1(159.07,93.59) ; v1(226.81,56.4) 226.31,56.9 223.22,56.9 222.44,56.12 221.87,56.12 221.31,55.56 221.31,55.25 220.36,54.29 220.36,52.62 220.89,52.09 220.89,49.62 222.59,47.91 227.6,47.91 230.06,45.45 v1(230.57,45.45)
  IN2 w0.089: v1(226.81,56.4) 225.32,54.91 219.83,54.91 218.06,56.69 212.62,56.69 212.5,56.81 208.88,56.81 206.89,54.83 194.91,54.83 194.07,55.66 190.68,55.66 189.28,57.07 188.41,57.07 185.26,60.22 184.1,60.22 176.28,68.03 176.28,68.75 176.06,68.97 176.06,89.94 170.97,95.03 168.99,95.03 168.41,94.45 165.39,94.45 164.15,93.21 161.2,93.21 160.82,93.59 v1(159.07,93.59)
  IN4 w0.076: v3(140.78,89.52) 141.16,89.9
  IN4 w0.089: 141.16,89.9 141.18,89.92 147.36,89.92 147.51,89.78 148.91,89.78 v1(149.67,89.02)
  BOTTOM w0.076: UC1.AD3 136.74,89.92 137.13,89.52 137.6,89.52 137.71,89.49 139.24,89.49 139.58,89.83 140.47,89.83 v3(140.78,89.52) 141.03,89.52 141.16,89.65
  BOTTOM w0.108: 141.16,89.65 RC609.1 ; v2(149.67,88.38) v1(149.67,89.02)
SIO_EXT_WAKE#_R: length 12.2
  TOP w0.108: U38.B5 232,52.9 v1(232.29,53.2) ; v1(230.57,46.22) 230.16,45.81 230.16,45.32 229.84,45.01 R316.2
  BOTTOM w0.108: v1(230.57,46.22) 230.13,46.65 230.13,47.05 230.34,47.26 230.8,47.26 233.06,49.52 v2(233.06,51.72) 232.29,52.49 v1(232.29,53.2)
SIO_PWRBTN#: length 268.4
  TOP w0.108: v5(76.39,128.99) v1(76.39,128.31) ; v1(230.44,58.27) 230.44,58.11 229.97,57.63 U38.B58
  IN1 w0.089: v1(51.52,96.1) 51.23,96.39 51.23,98.68 53.06,100.52 53.06,105.63 54.51,107.08 54.51,112.87 59.94,118.29 61.49,118.29 64.09,120.89 64.09,122.46 66.2,124.58 66.21,124.58 67.18,125.55 67.18,126.65 67.7,127.17 75.25,127.17 v1(76.39,128.31)
  IN3 w0.089: v1(51.52,96.1) 52.15,96.73 55.69,96.73 55.75,96.67 57.01,96.67 58.17,97.83 63.61,97.83 63.94,97.5 74.62,97.5 85.7,86.43 86.9,85.22 91.47,85.22 92.13,85.89 94.63,85.89 95.24,85.28 95.9,85.28 97.78,83.4 97.78,81.8 100.52,79.06 100.52,76.59 104.25,72.86 104.25,71.64 104.99,70.9 108.25,70.9 109.77,72.42 123.65,72.42 124.86,71.2 126.53,71.2 130.62,75.29 130.62,77.16 v3(130.92,77.46) ; v1(141.55,73.36) 141.55,73.08 142.85,71.79 146.95,71.79 148.8,69.94 149.16,69.94 149.94,69.16 149.96,69.16 149.97,69.15 152.61,69.15 152.82,68.94 156.68,68.94 160.27,65.35 168.25,65.35 168.89,66 173.56,66 174.04,66.47 176.22,66.47 182.13,60.57 183.99,60.57 184.79,59.76 185.52,59.76 186.97,58.32 186.97,57.86 189.7,55.13 207.53,55.13 208.97,56.56 217.79,56.56 219.15,57.92 230.09,57.92 v1(230.44,58.27)
  BOTTOM w0.076: UC1.BA15 129.27,80.71 129.03,80.47 129.03,79.3 129.42,78.91 129.8,78.91 130.18,78.52 130.19,78.52 130.49,78.22 130.49,78.21 130.92,77.78 v3(130.92,77.46)
  BOTTOM w0.108: v3(130.92,77.46) 131.07,77.46 132.34,76.19 133.09,76.19 CC267.1 R9536.2 134.3,75.11 134.3,74.36 134.48,74.18 135.04,74.18 135.88,73.34 138.24,73.34 138.28,73.3 140,73.3 140.63,73.93 140.98,73.93 v1(141.55,73.36) ; 76.39,127.67 v1(76.39,128.31)
SIO_PWRBTN#_R: length 5.4
  BOTTOM w0.108: RC403.2 76.39,125.94 v2(76.44,125.89) 76.44,125.69 76.92,125.21 77.64,125.21 78.2,124.65 78.2,124.49 78.8,123.89 JXDP1.41
SIO_RCIN#: length 140.3
  TOP w0.108: U38.A27 v1(240.02,57.88)
  IN3 w0.089: v1(239.87,65.52) 239.44,65.09 236.88,65.09 235.54,66.43 233.58,66.43 233.34,66.19 233.34,65.47 232.94,65.06 231.74,65.06 231,64.33 226.85,64.33 226.05,63.53 218.59,63.53 215.27,60.2 206.38,60.2 205.68,59.5 204.31,59.5 202.68,57.87 195.93,57.87 194.14,59.65 190.96,59.65 188.23,62.39 186.23,62.39 182.92,65.7 182.22,65.7 173.78,74.13 167.17,74.13 165.88,75.43 158.06,75.43 157.66,75.83 156.68,75.83 154.04,78.47 150.62,78.47 149.79,77.65 v1(149.79,77.08)
  IN4 w0.089: v1(239.87,65.52) 239.87,63.77 239.09,63 239.09,62.01 238.82,61.74 238.82,59.07 v1(240.02,57.88)
  BOTTOM w0.076: UC1.AW13 130.27,81.57 130.25,81.51 130.13,81.12 130.13,80.97 130.09,80.87 130.09,80.61 130.13,80.49 130.13,80.31 130.09,80.22 130.09,79.84 130.29,79.65 130.29,79.12 130.39,79.02 130.39,79.02 130.99,78.42 130.99,78.42 132.19,77.22 134.08,77.22 134.51,76.79 141.12,76.79 141.16,76.83
  BOTTOM w0.108: RC344.1 v2(150.99,78.35) 150.43,78.35 149.79,77.71 v1(149.79,77.08) 149.38,76.66 148.25,76.66 148.07,76.83 141.16,76.83
SIO_SLP_A#: length 150.9
  TOP w0.108: v1(236.93,56.83) 237.38,57.28 237.83,57.28 238.18,57.63 U38.B28 ; RC473.1 157.95,82.95 157.95,81.25 158.78,80.41 JAPS1.6 160.54,80.41 v1(160.95,80.81)
  IN1 w0.076: 135.74,74.79 135.52,75.02 134.99,75.02 134.33,75.68 133.62,75.68 132.74,76.56 132.74,78.31 131.82,79.23 131.82,79.6 130.38,81.04 129.58,81.04 127.97,82.64 127.97,85.12 v3(128.33,85.48)
  IN1 w0.089: v1(160.95,80.81) 160.32,80.81 159.37,79.86 159.37,78.85 150.56,70.03 147.52,70.03 147.51,70.04 141.15,70.04 140.89,70.31 140.89,71.41 140.11,72.19 137.34,72.19 136,73.52 136,74.53 135.74,74.79
  IN2 w0.089: v1(236.93,56.83) 235.81,55.72 229.48,55.72 228.06,54.3 219.69,54.3 217.83,56.15 212.4,56.15 212.28,56.27 209.1,56.27 208.59,55.77 207.12,54.29 194.69,54.29 193.85,55.13 190.46,55.13 189.06,56.53 188.08,56.53 185.02,59.6 182.71,59.6 174.74,67.58 174.74,72 172.45,74.28 169.05,74.28 167.23,76.11 167.23,76.61 166.99,76.84 166.49,76.84 162.52,80.81 v1(160.95,80.81)
  BOTTOM w0.076: v3(128.33,85.48) 128.47,85.48 UC1.AN16
  BOTTOM w0.108: v2(238.21,57.24) 237.71,57.24 237.71,57.24 237.37,57.24 237.36,57.24 237.33,57.24 v1(236.93,56.83)
SIO_SLP_LAN#: length 287.5
  TOP w0.108: v1(138.01,70.44) 137.79,70.22 135.24,70.22 134.86,70.6 134.5,70.6 RC487.1 133.92,71.16 RC488.1 ; U22.4 v1(189.99,136.96) ; v1(238.99,66.16) 239.46,65.69 239.46,65.35 239.7,65.11 239.74,65.11 R9674.1
  IN1 w0.089: v1(189.99,136.96) 189.82,136.79 189.82,130.57 187.81,128.56 187.81,109.83 187.36,109.38 187.36,108.75 185.7,107.09 185.7,80.86 181.78,76.93 181.78,66.43 188.01,60.2 188.01,58.21 191.27,54.95 191.27,51.71 191.05,51.49 191.05,49.39 191.77,48.67 194.42,48.67 194.87,48.23 205.48,48.23 206.11,48.86 214.31,48.86 v1(214.59,49.14) 218.09,49.14 218.93,49.98 218.93,56.1 220.93,58.1 225.18,58.1 225.49,57.79 228.74,57.79 228.94,57.59 235.97,57.59 236.54,58.15 236.54,58.66 236.86,58.99 238.12,58.99 238.69,58.41 240.93,58.41 241.58,57.75 245.69,57.75 v1(246.09,58.15)
  IN2 w0.089: v1(214.59,49.14) 207.34,49.14 204.6,51.87 191.91,51.87 191.25,51.22 188.27,51.22 187.26,50.21 184.07,50.21 181.62,52.66 181.62,56.31 177.54,60.39 175.93,60.39 170.9,65.42 168.86,65.42 168.1,66.17 166.54,66.17 165.92,66.79 159.07,66.79 157.33,68.54 157.32,68.54 157.23,68.63 150.75,68.63 149.26,70.12 144.74,70.12 144.34,69.72 138.73,69.72 v1(138.01,70.44) 137.6,70.84 137.6,71.51 131.25,77.86 130.69,77.86 v3(130.37,77.54)
  BOTTOM w0.076: v3(130.37,77.54) 130.37,78.1 130.33,78.14 130.33,78.15 130.12,78.36 130.11,78.36 129.73,78.74 129.35,78.74 128.87,79.23 128.87,80.8 128.99,80.93 128.99,81.19 128.97,81.21 128.97,81.58 129.25,81.86 UC1.AW15
  BOTTOM w0.108: v1(238.99,66.16) 239.46,65.69 239.46,65.35 239.72,65.09 242.02,65.09 243.67,63.44 243.67,63.01 245.88,60.8 245.88,59.73 246.01,59.6 246.01,58.23 v1(246.09,58.15) ; v2(138.66,70.44) v1(138.01,70.44)
SIO_SLP_LAN#_R: length 6
  TOP w0.108: v1(237.17,60.72) 237,60.9 U38.B37 ; R9674.2 240.04,63.51 239.13,62.6 238.75,62.6 238.72,62.63 v1(238.69,62.63)
  IN4 w0.089: v1(238.69,62.63) 238.69,62.23 237.19,60.72 v1(237.17,60.72)
  BOTTOM w0.108: v2(237.17,60.09) v1(237.17,60.72)
SIO_SLP_S0#: length 288.6
  TOP w0.108: RC458.2 v1(190.56,91.94) ; v1(189.73,101.12) UC10.2 ; v1(162.06,85.82) 161.57,85.33 161.1,85.33 160.67,84.91 JAPS1.15 ; v1(241.13,44.36) 241.29,44.21 R9685.2
  IN1 w0.076: v3(131.07,83.53) 131.46,83.14 131.46,81.94 132.23,81.17 133.37,81.17 139.07,75.46 139.72,75.46 140.39,74.79
  IN1 w0.089: v1(190.56,91.94) 191.16,92.53 191.16,99.69 v1(189.73,101.12) ; v1(244.54,43.45) 243.62,44.36 v1(241.13,44.36) ; v1(162.06,85.82) 161.45,85.21 158.45,85.21 157.24,84 157.24,82.01 154.97,79.74 154.97,76.88 153.35,75.25 149.87,75.25 148.82,74.2 141.01,74.2 140.54,74.66 140.52,74.66 140.39,74.79 ; v1(189.39,92.52) 188.89,92.01 187.29,92.01 186.47,91.19 186.47,75.27 184.54,73.34 184.54,64.57 189.37,59.74 194.07,59.74 194.68,59.13 202.57,59.13 205.45,56.25 210.22,56.25 210.7,55.77 210.7,55.46 v1(211.11,55.06)
  IN3 w0.089: v1(189.73,101.12) 190.54,100.3 190.54,97.46 190.1,97.02 185.61,97.02 184.62,98 180.69,98 180.51,98.18 177.33,98.18 v1(176.82,98.69) ; v1(162.06,85.82) 162.06,85.29 163.42,83.94 175.64,83.94 177.91,86.21 177.91,87.29 178.22,87.6 178.71,87.6 v1(179.21,88.1)
  IN4 w0.089: v1(179.21,88.1) 180.02,88.91 180.02,92.95 179.64,93.33 178.24,93.33 177.49,94.08 177.49,98.04 176.85,98.69 v1(176.82,98.69) ; v1(189.73,101.12) 190.12,101.51 190.12,103.24 191.22,104.33 191.22,113.18 190.98,113.42 189.78,113.42 188.12,115.08 188.12,132.29 189.67,133.85 189.67,135.75 190.58,136.66 190.58,140.69 185.62,145.66 v1(184.72,145.66) ; v1(211.11,55.06) 212.44,56.38 217.4,56.38 220,53.79 223.33,53.79 224.26,52.85 229.2,52.85 230.14,51.92 239.52,51.92 239.64,51.8 243.46,51.8 244.68,50.57 244.68,49.77 244.61,49.69 244.61,44.48 244.54,44.41 v1(244.54,43.45)
  BOTTOM w0.076: v3(131.07,83.53) 131.39,83.85 UC1.AT11
  BOTTOM w0.108: v1(189.39,92.52) 189.49,92.62 v2(190.56,92.62) v1(190.56,91.94) ; v1(176.82,98.69) 176.82,100.75 PR5618.2 ; PR5607.2 167.4,78.65 166.79,79.26 166.79,79.85 167.35,80.4 167.35,80.79 167.12,81.01 165.34,81.01 162.85,83.5 162.85,85.02 v1(162.06,85.82) ; R9533.2 v1(184.72,145.66)
SIO_SLP_S0#_TPM: length 3.8
  BOTTOM w0.108: U25.29 187.13,145.78 187.01,145.66 R9533.1 R9534.2 v2(186.17,147.61)
SIO_SLP_S3#: length 303.9
  TOP w0.108: RC624.1 122.92,67.8 v1(122.64,67.8) ; v1(250.26,45.38) 250.1,45.38 249.68,44.95 UC13.1 ; UC11.2 221.08,68.27 220.86,68.5 220.44,68.5 v1(220.03,68.09) ; R9586.2 v1(243.93,43.42) ; v1(248.09,59.45) 248.58,58.97 249.29,58.97 249.49,59.17 249.49,60.21 249.25,60.45 Q4215.1 ; v1(189.67,99.75) 190.07,99.75 190.38,100.06 UC10.1 ; v1(161.5,81.77) 161.94,81.77 162.95,80.77 162.95,78.14 162.14,77.33 161.1,77.33 160.02,78.41 JAPS1.2 ; v1(236.67,62.65) 236.75,62.57 U38.A35 ; PR5701.1 218.02,64.72 v1(218,64.75)
  IN1 w0.076: v3(129.26,84.77) 129.61,84.43 129.61,82.55 132.13,80.03 133.53,80.03 133.98,79.59 133.98,77.63 134.68,76.92 134.68,76.11 135.19,75.6 136.8,75.6 137.43,74.97 139.33,74.97 139.51,74.79
  IN1 w0.089: v1(189.39,94.35) 188.78,94.96 188.78,98.86 v1(189.67,99.75) ; v1(182.69,81.65) 182.23,81.2 182.23,80.68 179.8,78.25 179.8,65.86 185.08,60.59 185.08,50.09 v1(185.42,49.75) ; 139.51,74.79 140.37,73.93 140.37,73.92 140.8,73.49 v1(140.8,73.37) 140.85,73.32 140.85,72.53 142.12,71.26 146.75,71.26 147.79,70.21 150.48,70.21 158.92,78.64 158.92,80.92 159.81,81.82 159.81,82.25 160.12,82.56 160.72,82.56 v1(161.5,81.77)
  IN3 w0.089: v1(250.26,45.38) 247.43,45.38 246.47,44.41 244.92,44.41 v1(243.93,43.42) ; v1(122.64,67.8) 124.87,67.8 125.61,68.54 127.2,68.54 129.61,70.96 133.89,70.96 138.08,66.76 v1(138.39,66.76) ; v1(212.15,46.6) 210.43,46.6 210.06,46.22 209.71,46.22 208.86,47.08 193.97,47.08 193.43,47.62 186.34,47.62 185.97,47.98 185.85,48.1 185.85,49.31 v1(185.42,49.75) ; v1(161.5,81.77) 162.02,81.77 163.63,80.16 167.1,80.16 168.48,81.54 174.84,81.54 176.6,83.3 181.04,83.3 v1(182.69,81.65) ; v1(236.67,62.65) 237.09,62.65 237.3,62.86 237.3,63.62 237.65,63.97 241.26,63.97 243.5,61.74 243.5,61.48 244.94,60.03 247.51,60.03 v1(248.09,59.45)
  IN4 w0.089: v1(220.03,68.09) 220.56,67.55 234.71,67.55 235.79,66.47 235.79,63.53 v1(236.67,62.65) ; v1(140.8,73.37) 141.69,72.49 141.69,69.25 139.2,66.76 v1(138.39,66.76)
  BOTTOM w0.076: UC1.AP15 129.32,84.77 v3(129.26,84.77)
  BOTTOM w0.108: R734.1 185.23,49.94 v1(185.42,49.75) ; v1(212.15,46.6) 211.84,46.91 211.84,52.58 212.7,53.44 212.75,53.44 213.76,54.45 213.76,55.81 215.84,57.89 215.84,61.66 216.92,62.74 216.92,63.02 218,64.09 v1(218,64.75) 218.4,65.15 218.4,66.56 219.92,68.09 v1(220.03,68.09) ; v1(182.69,81.65) 182.81,81.78 183.56,81.78 188.78,87 v2(188.78,92.04) 188.78,94.12 189.01,94.35 v1(189.39,94.35) ; v1(236.67,62.65) 237.71,63.69 238.9,63.69 239.17,63.42 241.17,63.42 242.15,62.44 242.15,61.43 244.08,59.5 244.08,54.47 245.32,53.23 245.6,53.23 246.47,52.35 246.47,49.42 245.43,48.38 245.43,44.92 v1(243.93,43.42)
SIO_SLP_S4#: length 287.6
  TOP w0.108: PR5711.1 213.65,56.76 213.35,56.45 v1(213.35,55.51) ; PR5407.1 85.42,56.83 v1(85.84,56.83) ; v1(161.66,80.33) 161.24,79.91 JAPS1.5 ; U38.B36 237.5,61 v1(237.81,60.69) ; v1(126.2,66.82) 125.77,66.38 UC14.2 ; R418.1 190.28,90.62 190.28,88.94 R422.1 190.16,88.51 v1(190.43,88.23)
  IN1 w0.089: v1(237.81,60.69) 237.52,60.41 237.52,60.41 236.8,59.7 236.56,59.7 236.08,59.21 231.03,59.21 230.91,59.09 230.19,59.09 229.51,59.77 217.61,59.77 v1(213.35,55.51) ; v1(190.43,88.23) 188.65,86.44 188.65,70.41 185.42,67.19 185.42,64.94 189.74,60.62 194.55,60.62 195.16,60.01 206.33,60.01 209.8,63.48 213.31,63.48 215.73,65.9 217.49,65.9 v1(217.99,66.41)
  IN2 w0.089: v3(129.57,78.39) 129.83,78.65 131.48,78.65 132.6,77.53 135.04,77.53 136.4,76.18 143.33,76.18 143.9,75.61 146.63,75.61 149.49,78.47 159.52,78.47 161.38,80.33 v1(161.66,80.33)
  IN3 w0.089: v1(126.2,66.82) 128.1,68.71 135.51,68.71 136.23,67.99 136.23,67.71 v1(136.23,67.71) ; v1(143.19,55.36) 138.04,55.36 137.73,55.66 104.6,55.66 100.7,59.57 89.49,59.57 86.75,56.83 v1(85.84,56.83) ; v1(161.66,80.33) 162,79.98 167.18,79.98 168.56,81.36 176.59,81.36 178.29,83.07 179.77,83.07 181.29,81.54 182.16,81.54 v1(182.69,81.01)
  IN4 w0.076: 134.32,74.79 130.72,78.39 v3(129.57,78.39)
  IN4 w0.089: 134.32,74.79 135.53,73.59 135.53,69.22 136.23,68.51 v1(136.23,67.71) 136.23,67.06 136.43,66.87 136.43,64.41 137.55,63.3 137.55,59.86 141.73,55.67 142.88,55.67 v1(143.19,55.36)
  BOTTOM w0.076: UC1.BA16 128.7,81.03 128.7,79.16 129.48,78.39 v3(129.57,78.39)
  BOTTOM w0.108: v1(182.69,81.01) 183.12,81.45 183.53,81.45 189.42,87.33 189.42,87.34 190.31,88.23 v1(190.43,88.23) ; v2(143.19,56.1) v1(143.19,55.36) ; v1(217.99,66.41) 216.97,65.39 216.97,63.37 216.71,63.11 216.71,62.82 215.63,61.75 215.63,58.36 213.35,56.07 v1(213.35,55.51)
SIO_SLP_S5#: length 136.8
  TOP w0.108: U38.A18 240.02,53.38 240.17,53.53 v1(240.5,53.53) ; JAPS1.4 160.57,79.41 160.88,79.1 v1(161.63,79.1)
  IN2 w0.089: 161.63,79.08 162.48,79.08 168.34,73.22 169.71,73.22 174.56,68.37 174.56,67.5 182.64,59.42 184.3,59.42 184.9,58.83 184.9,58.59 185.53,57.96 186.27,57.96 187.87,56.36 188.99,56.36 190.39,54.95 193.78,54.95 194.62,54.12 207.19,54.12 209.17,56.1 212.21,56.1 212.35,55.95 217.79,55.95 219.61,54.12 228.13,54.12 229.54,55.53 235.91,55.53 236.64,54.79 238.68,54.79 239.94,53.53 v1(240.5,53.53) ; 161.63,79.08 v1(161.63,79.1) ; 161.63,79.08 160.22,77.67 152.98,77.67 152.55,78.11 149.51,78.11 146.83,75.43 143.57,75.43 143.17,75.83 136.38,75.83 134.99,77.23 132.4,77.23 131.36,78.26 130.23,78.26 v3(129.97,78)
  BOTTOM w0.076: UC1.AY16 128.67,81.51 128.36,81.19 128.36,80.93 128.54,80.75 128.54,78.92 129.46,78 v3(129.97,78)
  BOTTOM w0.108: v2(240.64,52.81) 240.64,52.83 240.5,52.97 v1(240.5,53.53)
SIO_SLP_SUS#: length 309.3
  TOP w0.108: R9567.1 190.64,86.73 190.97,87.06 v2(190.97,90.13) 190.97,92.31 190.33,92.96 190.33,93.89 v1(190.74,94.3) 191.15,94.71 191.15,96.05 190.84,96.35 R9581.1 ; v1(130.72,119.49) 129.68,120.53 PR5507.1 ; PR5706.1 183.88,110.68 183.62,110.95 v1(183.62,111.42) ; RC474.1 158.06,83.72 v1(158.41,83.72) ; v1(149.09,69.37) 149.17,69.37 152.01,72.2 152.01,73.64 151.58,74.06 151.2,74.06 v1(150.91,73.78) ; R9584.2 224.72,61.9 v1(224.72,62.73) ; v1(126.2,66.21) 125.73,65.73 UC14.1
  IN1 w0.076: 139.76,74.79 139.42,75.13 137.5,75.13 136.85,75.78 135.27,75.78 134.88,76.16 134.88,77.05 134.14,77.8 134.14,79.66 133.57,80.23 132.16,80.23 129.8,82.59 129.8,84.84 v3(129.25,85.39)
  IN1 w0.089: 139.76,74.79 140.76,73.79 150.89,73.79 v1(150.91,73.78) 151.15,74.01 152.61,74.01 155.33,76.73 155.33,79.59 157.6,81.86 157.6,82.91 v1(158.41,83.72) ; v1(190.74,94.3) 190.31,93.87 190.31,92.57 188.12,90.38 188.12,76.41 184.89,73.18 184.89,64.72 189.52,60.09 194.32,60.09 194.93,59.48 205.26,59.48 206.22,58.51 206.22,58.26 207.19,57.3 207.97,57.3 213.85,63.18 224.27,63.18 v1(224.72,62.73)
  IN2 w0.089: v1(149.09,69.37) 148.81,69.65 145.16,69.65 144.06,68.55 141.08,68.55 140.5,69.13 137.73,69.13 136.76,68.16 v1(136.76,67.37) ; v1(173.06,111.93) 167.21,111.93 164.34,114.8 162.65,114.8 158.39,114.8 155.08,118.12 139.88,118.12 139.64,118.36 138.51,119.49 v1(130.72,119.49)
  IN3 w0.089: v1(158.41,83.72) 159.6,83.72 159.83,83.49 175.7,83.49 177.51,85.3 179.41,85.3 180.53,84.19 182.8,84.19 183.72,83.26 183.72,82.81 v1(183.32,82.41) ; v1(136.76,67.37) 136.76,67.77 135.02,69.51 128.49,69.51 127.14,68.16 126.37,68.16 125.8,67.59 125.8,66.61 v1(126.2,66.21) ; v1(176.46,103.75) 174.84,105.37 174.84,110.49 173.4,111.93 v1(173.06,111.93)
  IN4 w0.089: v1(190.74,94.3) 189.22,95.82 189.22,100.87 189.16,100.93 189.16,105.53 183.63,111.06 183.63,111.41 v1(183.62,111.42)
  BOTTOM w0.076: v3(129.25,85.39) 129.29,85.39 UC1.AN15
  BOTTOM w0.108: v1(183.62,111.42) 183.21,111.42 183.05,111.27 174.66,111.27 174,111.93 v1(173.06,111.93) ; v1(190.74,94.3) 190.18,94.86 190.18,95.07 189.65,95.6 189.14,95.6 186.75,93.22 186.75,85.81 183.35,82.41 v1(183.32,82.41) ; v1(176.46,103.75) 176.46,104.56 PR5621.1
SIO_SLP_SUS#_R: length 4.2
  TOP w0.108: U38.B52 229.08,60.63 228.81,60.9 227.24,60.9 v2(226.83,61.3) 226.38,61.76 R9584.1
SIO_SLP_WLAN#: length 508.4
  TOP w0.108: v1(53.07,125.55) 53.33,125.55 53.62,125.26 53.62,125.25 v2(53.63,125.25) ; R9657.1 262.06,43.81 261.01,42.76 256.92,42.76 v1(256.5,43.17)
  IN1 w0.089: v1(257.62,26.79) 255.72,28.68 246.64,28.68 245.71,27.75 242.18,27.75 241.74,27.3 239.22,27.3 238.02,26.11 228.91,26.11 228.44,25.65 219.82,25.65 213.73,31.74 190.29,31.74 187.74,34.28 187.74,38.75 177.4,49.1 177.4,51.53 176.34,52.59 176.34,57.02 175.96,57.41 175.96,67.73 171.83,71.85 171.83,78.82 172.1,79.09 172.49,79.09 173.35,78.22 174.81,78.22 175.4,78.81 175.4,83.79 175.85,84.23 175.85,97.64 172.53,100.96 172.53,103.24 172.27,103.49 171.51,103.49 169.17,105.83 169.17,117.23 168.91,117.49 168.91,117.49 167.26,119.14 167.26,120.22 167.16,120.32 167.16,120.32 164.02,123.46 163.06,123.46 160.13,126.39 160.13,129.65 158.35,131.43 154.95,131.43 153,133.39 153,135.79 150.24,138.55 145.63,138.55 145.27,138.9 144.54,138.9 144.3,139.14 143.99,139.14 143.14,139.99 140.45,139.99 134.93,145.51 133.62,145.51 133.05,146.08 125.88,146.08 123.44,148.52 115.26,148.52 114.46,147.72 114.46,147.29 113.54,146.37 105.49,146.37 102.13,143.02 98.51,143.02 97.61,142.12 85.39,142.12 84.52,142.99 71.94,142.99 71.31,142.36 71.31,142.36 71.26,142.3 69.33,142.3 65.97,138.95 65.97,129.99 62.98,126.99 60.36,126.99 58.64,125.27 53.35,125.27 v1(53.07,125.55)
  IN2 w0.089: v1(257.24,52.57) 256.85,52.18 255.59,52.18 255.52,52.25 250.73,52.25 250.05,51.58 235.06,51.58 234.4,52.23 234.4,53.76 234.2,53.96 232.22,53.96 231.65,54.53 229.76,54.53 227.91,52.68 226.34,52.68 224.6,50.94 218.63,50.94 217.59,49.91 207.32,49.91 204.75,52.48 193.92,52.48 193.1,53.3 189.78,53.3 188.36,54.72 185,54.72 183.7,56.02 182.66,56.02 177.61,61.08 176,61.08 175.97,61.1 170.27,66.8 166.95,66.8 166.4,67.35 160.02,67.35 158.45,68.92 158.34,69.03 157.59,69.03 157.55,69.07 157.54,69.07 157.45,69.16 151.06,69.16 149.61,70.61 149.53,70.61 149.29,70.84 149.29,70.92 149.19,71.03 v1(148.98,71.03)
  IN4 w0.089: v1(257.24,52.57) 257.24,52.47 256.84,52.07 256.84,47.63 256.07,46.87 256.07,46.24 256.73,45.58 256.73,43.4 v1(256.5,43.17) 256.47,43.13 256.47,40.84 257.36,39.94 257.36,36.69 256.58,35.91 256.58,34.04 257.62,33.01 v1(257.62,26.79)
  BOTTOM w0.076: 130.51,74.84 130.51,75.98 129.92,76.57 129.92,76.96 128,78.88 128,79.98 UC1.BB17
  BOTTOM w0.108: v1(53.07,125.55) 53.07,125.16 53.4,124.83 RC465.1 ; 130.51,74.84 130.51,73.85 132.07,72.29 135.18,72.29 135.36,72.11 137.72,72.11 137.9,71.93 138.02,71.93 138.03,71.93 144.53,71.93 145.2,71.26 146.92,71.26 147.51,70.67 148.62,70.67 v1(148.98,71.03)
SIO_SLP_WLAN#_R: length 2.5
  TOP w0.279: U37.A14 263.03,47.42 v2(262.65,47.03) 262.32,46.7 262.32,46.39 R9657.2
SKTOCC#: length 7.3
  BOTTOM w0.076: UC1.A65 100.98,102.72 100.98,103.54 100.11,104.41 99.83,104.41
  BOTTOM w0.089: T7140.1 95.9,105.54 95.9,105.42 96.9,104.41 99.83,104.41
SLEEVE: length 6.8
  IN3 w1.27: 35.24,123.56 35.24,125.21 35.6,125.57 35.6,130.16
  vias: v1(36.09,131.31) v1(36.46,122.97) v2(37.09,123.25) v4(35.7,131.94) v4(36.46,123.71)
SLEEVE_D: length 21.5
  IN2 w2.032: 240.83,115.41 251.16,115.41 251.59,114.98 254.48,114.98 258.49,118.99 259.58,118.99 JUAJ1.4
  vias: v1(240.73,103.24) v1(240.75,102.63) v1(241.36,103.24) v1(241.36,102.63) v2(242.02,104.31)
SLEEVE_L: length 20.7
  IN3 w1.27: 22.64,140.25 23.23,140.83 32.83,140.83 34.58,139.08 34.58,134.85 37.08,132.35
  vias: v1(21.55,139.99) v1(37.35,131.74) v2(26.33,141.01) v4(20.97,139.51) v4(36.88,132.31)
SLOT2_CONFIG_0: length 245.8
  TOP w0.108: v1(264.98,59.68) 265.77,59.68 267.43,61.34 RP4810.1 ; U37.B12 261.78,49.37 262.58,50.16 v1(263,50.16)
  IN2 w0.089: v1(105.93,126.48) 108.26,128.81 110.43,128.81 110.72,128.52 116.61,128.52 117.76,129.67 122.2,129.67 122.57,129.31 122.57,128.76 123.53,127.8 126.78,127.8 128.74,125.85 132.4,125.85 139.95,118.3 155.15,118.3 158.47,114.98 164.41,114.98 167.07,112.33 173.91,112.33 175.2,111.03 176.1,110.13 183.2,110.13 188.22,105.1 188.22,96.5 188.6,96.13 188.6,86.69 188.53,86.62 188.53,86.19 187.74,85.4 187.74,84.96 187.74,83.92 183.63,79.81 183.63,70.28 184.24,69.67 184.24,65.62 186.75,63.11 186.84,63.11 190.21,59.74 194.18,59.74 196.76,57.15 204.37,57.15 205.64,58.42 205.64,58.99 206.55,59.91 212.79,59.91 213.62,59.07 216.19,59.07 220.78,63.67 222.22,63.67 222.4,63.49 226.51,63.49 227.11,64.09 244.08,64.09 246.64,61.53 252.44,61.53 252.72,61.25 260.73,61.25 261.17,60.8 261.17,59.75 261.64,59.28 264.58,59.28 v1(264.98,59.68)
  IN4 w0.089: v1(263,50.16) 263.21,50.37 263.21,53.44 263.73,53.96 264.41,53.96 264.98,54.54 v1(264.98,59.68)
  BOTTOM w0.108: v1(105.93,126.48) 106.02,126.58 JWWAN1.21 ; v1(264.98,59.68) v2(264.98,60.4)
SLOT2_CONFIG_1: length 261
  TOP w0.108: v1(267.78,60.95) 268.04,61.21 RP4810.3 ; U37.A18 v1(266.29,50.33)
  IN2 w0.089: v1(267.78,60.95) 267.43,60.6 265.83,60.6 265.57,60.86 265.57,61.84 263.01,64.4 246.04,64.4 243.07,67.37 219.41,67.37 218.57,66.54 218.57,66.17 217.73,65.32 217.29,65.32 215.99,64.02 214.71,64.02 214.21,63.51 208.27,63.51 207.12,62.36 204.42,62.36 204.25,62.19 204.25,61.85 202.23,59.83 196.76,59.83 195.51,61.08 195.51,61.43 191.8,65.14 191.36,65.14 185.92,70.59 185.92,74.62 189.27,77.97 189.27,84.55 191.32,86.6 191.32,111.21 184.43,118.1 183.45,118.1 181.64,119.91 166.89,119.91 165.49,121.3 163.14,121.3 161.22,123.22 161.22,124.35 160.31,125.27 160.31,125.27 160.31,129.94 158.94,131.31 158.94,135.12 157.67,136.39 156.78,136.39 156.21,136.95 146.04,136.95 145.86,136.77 141.92,136.77 140.5,138.19 139.23,138.19 133.42,144 108.13,144 v1(107.25,143.12)
  BOTTOM w0.108: JWWAN1.69 108.68,138.58 109.15,139.05 109.15,139.66 108.57,140.25 108.57,142.25 107.71,143.12 v1(107.25,143.12) ; v1(266.29,50.33) 265.82,50.81 265.82,59.5 v2(266.93,60.61) 267.27,60.95 v1(267.78,60.95)
SLOT2_CONFIG_2: length 257.6
  TOP w0.108: v1(266,61) RP4811.5 ; v1(257.8,59.98) 257.8,59.85 258.53,59.12 U37.A44
  IN2 w0.089: v1(106.64,143.12) 107.7,144.18 133.62,144.18 139.38,138.42 140.65,138.42 142.12,136.94 145.65,136.94 145.84,137.13 156.42,137.13 156.91,136.64 157.8,136.64 159.19,135.24 159.19,131.31 160.48,130.02 160.48,125.34 161.4,124.42 161.4,123.29 163.21,121.48 165.57,121.48 166.96,120.09 181.75,120.09 183.56,118.28 184.58,118.28 191.5,111.37 191.5,110.44 191.5,86.53 191.39,86.42 189.44,84.48 189.44,77.89 186.1,74.55 186.1,70.66 191.35,65.41 191.79,65.41 195.77,61.43 195.77,61.08 196.84,60.01 202.16,60.01 204.07,61.93 204.07,62.27 204.35,62.55 207.05,62.55 208.2,63.69 214.13,63.69 214.66,64.22 215.91,64.22 217.2,65.5 217.65,65.5 218.39,66.24 218.39,66.61 219.23,67.45 219.33,67.55 229.37,67.55 230.43,68.61 239.41,68.61 240.48,67.55 243.14,67.55 243.24,67.45 246.06,64.63 263.03,64.63 266,61.67 v1(266,61)
  IN3 w0.089: v1(266,61) 265.65,61.35 259.19,61.35 257.83,59.98 v1(257.8,59.98)
  BOTTOM w0.108: v1(106.64,143.12) 106.56,143.12 105.29,141.85 105.29,140.48 105.69,140.08 JWWAN1.75 ; v1(257.8,59.98) 257.47,60.32 v2(257.47,61.33)
SLOT2_CONFIG_3: length 248.3
  TOP w0.108: RP4810.7 269.14,61.47 269,61.33 268.75,61.33 268.33,60.91 268.33,60.65 v1(267.31,59.64) 265.25,57.58 U37.B34
  IN2 w0.089: v1(103.06,126.51) 103.9,127.34 106.16,127.34 108.75,129.93 112.46,129.93 114.52,131.99 120.39,131.99 122.92,129.46 122.92,128.91 123.68,128.16 126.93,128.16 128.81,126.28 132.47,126.28 140.1,118.65 155.3,118.65 158.61,115.34 164.56,115.34 167.21,112.68 174.13,112.68 175.93,110.88 176.33,110.48 183.34,110.48 188.58,105.25 188.58,96.65 188.95,96.27 188.95,86.11 188.1,85.25 188.1,83.77 183.99,79.66 183.99,70.42 184.6,69.81 184.6,65.76 186.9,63.46 186.99,63.46 190.36,60.09 194.32,60.09 196.9,57.51 202.07,57.51 204.19,59.63 205.77,59.63 206.4,60.26 214.56,60.26 214.62,60.2 216.81,60.2 220.63,64.02 222.45,64.02 222.62,63.85 226.36,63.85 226.96,64.45 244.23,64.45 246.74,61.94 258.36,61.94 258.48,61.81 263.86,61.81 266.04,59.64 v1(267.31,59.64)
  BOTTOM w0.108: v2(266.83,58.87) 267.31,59.35 v1(267.31,59.64) ; v1(103.06,126.51) 102.55,126 102.55,124.07 105.34,121.27 106.23,121.27 106.54,121.58 JWWAN1.1
SM_RCOMP0: length 9.9
  TOP w0.381: v3(127.41,84.17) 127.34,84.17 126.12,82.96 126.12,82.44 125.5,81.82 125.5,81.11 v2(125.12,80.72) 124.57,80.18 124.57,78.83 124.17,78.42 R801.1
  BOTTOM w0.254: v3(127.41,84.17) 127.5,84.26 127.74,84.5 UC1.AR18
SM_RCOMP1: length 8.9
  TOP w0.381: v3(127.41,83.53) 127.35,83.53 126.83,83.01 v2(126.83,82.36) 126.22,81.75 126.22,79.44 125.26,78.47 125.26,77.62 125.46,77.42 R802.1
  BOTTOM w0.254: UC1.AT18 127.79,83.85 127.56,83.68 v3(127.41,83.53)
SM_RCOMP2: length 8.1
  TOP w0.381: v3(127.41,82.87) 127.41,82.7 127.95,82.16 127.95,81.34 v2(127.21,80.61) 127.77,80.05 127.77,78.91 127.06,78.21 R803.1
  BOTTOM w0.254: UC1.AU18 127.74,83.2 127.58,83.04 v3(127.41,82.87)
SML0_SMBCLK: length 65.5
  TOP w0.108: v1(146.11,134.09) 146.55,134.53 U21.28
  IN3 w0.089: v1(146.11,134.09) 145.64,133.62 145.64,130.02 146.71,128.94 147.66,128.94 150.84,125.76 150.84,116.69 151.14,116.4 151.14,100.45 148.4,97.7 148.4,96.51 148.39,96.5 148.39,95.09 146.75,93.45 v1(146.75,93.21)
  IN4 w0.089: v1(146.75,93.21) 146.32,93.63 145.62,93.63 145.08,93.09 141.83,93.09 141.01,93.92 133.27,93.92 v3(132.91,94.28)
  BOTTOM w0.076: v3(132.91,94.28) 132.91,94.27 133.16,94.53 UC1.R9
  BOTTOM w0.108: RC348.1 147.03,92.93 v1(146.75,93.21) 146.26,93.69 RC186.1
SML0_SMBDATA: length 58.7
  TOP w0.108: U21.31 145.35,134.36 145.35,134.35 v1(145.35,134.09)
  IN3 w0.089: v1(145.35,134.09) 145.35,129.9 146.59,128.65 147.54,128.65 150.55,125.64 150.55,116.71 150.55,116.71 150.55,116.57 150.85,116.28 150.85,100.66 148.09,97.91 148.09,95.21 v1(146.11,93.23)
  BOTTOM w0.076: UC1.W2 137.34,92.42 137.62,92.29 138.09,92.29 138.67,92.88 140.71,92.88 141.16,92.43
  BOTTOM w0.108: RC349.1 147.18,92.34 146.54,92.34 146.14,92.75 146.14,93.21 v1(146.11,93.23) 144.79,93.23 RC192.1 143.88,92.14 141.61,92.14 141.34,92.41 141.18,92.41 141.16,92.43
SML1_SMBCLK: length 142.9
  TOP w0.108: v1(233,53.19) 232.5,52.69 U38.B6
  IN3 w0.089: v1(161.85,58.43) 161.85,57.98 162.56,57.27 165.78,57.27 166,57.48 170.95,57.48 172.98,55.45 175.79,55.45 176.76,54.48 176.76,53.42 180.48,49.7 184.36,49.7 185.24,50.57 187.25,50.57 188,51.32 188.79,51.32 189.04,51.57 191.08,51.57 191.53,52.01 199.56,52.01 202.36,49.22 213.15,49.22 214.06,48.31 218.35,48.31 219.85,49.81 223.23,49.81 226.32,52.9 229.42,52.9 230.22,52.11 231.91,52.11 v1(233,53.19)
  IN4 w0.089: v1(161.85,58.43) 161.06,59.22 158.93,59.22 157.95,60.2 157.95,62.74 158.46,63.25 158.46,65.7 158.14,66.01 158.14,75 158.79,75.65 158.79,78.07 159.21,78.49 159.21,80.36 158.46,81.1 158.37,81.1 158.01,81.47 158.01,84.24 157.01,85.23 157.01,86.62 156.4,87.24 155.32,87.24 154.02,88.55 153.19,88.55 152.84,88.9 152.84,90.03 152.13,90.74 152.13,91.94 149.79,94.27 v1(149.79,94.55)
  BOTTOM w0.076: 138.67,93.38 138.12,92.84 137.74,92.84 137.66,92.8 137.41,92.8 137.28,92.84 137.09,92.84 136.9,92.77 136.74,92.77 UC1.W3
  BOTTOM w0.108: v2(150.3,93.54) 150.3,94.04 v1(149.79,94.55) 149.32,94.07 149.03,94.07 148.92,94.19 147.88,94.19 RC36.1 147.09,94.14 141.94,94.14 141.18,93.38 138.67,93.38
SML1_SMBDATA: length 142.3
  TOP w0.108: v1(232.65,50.58) 232.65,50.69 232.25,51.1 U38.A5
  IN3 w0.089: v1(161.24,58.43) 161.55,58.12 161.55,57.86 162.44,56.97 162.7,56.97 162.71,56.96 165.97,56.96 166.2,57.19 170.75,57.19 172.78,55.16 175.67,55.16 176.46,54.36 176.46,53.3 180.36,49.41 184.48,49.41 185.36,50.28 186.4,50.28 187.37,50.28 188.12,51.03 188.91,51.03 189.16,51.28 191.2,51.28 191.65,51.72 199.44,51.72 202.24,48.93 213.03,48.93 213.94,48.02 218.47,48.02 219.97,49.52 223.35,49.52 226.44,52.61 229.3,52.61 230.1,51.82 232.33,51.82 232.65,51.5 v1(232.65,50.58)
  IN4 w0.089: v1(149.16,94.55) 149.16,94.49 151.84,91.81 151.84,90.62 152.55,89.91 152.55,88.78 153.07,88.25 153.9,88.25 155.2,86.94 156.22,86.94 156.72,86.44 156.72,85.11 157.72,84.12 157.72,81.35 158.25,80.81 158.34,80.81 158.92,80.24 158.92,78.61 158.49,78.19 158.49,75.77 157.85,75.13 157.85,65.89 158.16,65.57 158.16,63.37 157.66,62.86 157.66,60.08 158.81,58.93 160.74,58.93 v1(161.24,58.43)
  BOTTOM w0.076: UC1.V3 136.49,92.97 136.96,92.97 137.06,93 137.31,93 137.44,92.97 137.62,92.97 137.71,93 138.03,93 138.72,93.69
  BOTTOM w0.108: 138.72,93.69 140.93,93.69 141.69,94.45 146.95,94.45 RC37.1 147.92,94.5 149.11,94.5 v1(149.16,94.55) 149.49,94.88 v2(149.49,95.19)
SNSR_HUB_PWREN: length 93.9
  TOP w0.076: 141.16,88 140.7,87.54 140.7,86.53 140.22,86.05 140.22,85.24 139.96,84.98 137.25,84.98 135.65,86.57 133.75,86.57 133.45,86.28 133.45,85.18 v3(133.81,84.82)
  TOP w0.108: 141.16,88 142.27,89.11 146.72,89.11 v2(147.17,89.56) 147.61,90.01 151.04,90.01 RC610.1 ; C9494.1 174.51,51.68 v1(174.43,51.6)
  IN1 w0.089: v1(174.43,51.6) 175.19,52.36 175.19,56.3 173.74,57.75 173.74,63.03 173.22,63.56 173.22,67.48 v1(173.8,68.06)
  IN3 w0.076: 134.17,82.18 134.17,84.46 v3(133.81,84.82)
  IN3 w0.089: v1(173.8,68.06) 170.88,70.97 165.9,70.97 164.71,72.16 157.68,72.16 156.89,72.96 152.4,72.96 152.19,72.74 150.77,72.74 150.54,72.97 150.54,72.99 149.75,73.78 144.51,73.78 142.48,75.81 139.54,75.81 134.17,81.18 134.17,82.18
  BOTTOM w0.076: UC1.AP7 133.94,84.82 v3(133.81,84.82)
  BOTTOM w0.108: v1(174.43,51.6) 174.28,51.75 JSH1.5
SNSR_HUB_RST#: length 72.4
  TOP w0.108: v1(146.44,67.17) 146.98,67.17 v2(147.23,67.43) 148.22,68.42 150.02,68.42 151.7,70.09 v1(152.3,70.09) ; v1(174.41,52.21) 174.79,52.21 C9495.1
  IN4 w0.076: 140.63,74.79 140.63,74.82 139.13,76.32 139.13,76.53 133.28,82.37 133.28,85.1 v3(132.9,85.48)
  IN4 w0.089: v1(174.41,52.21) 173.98,52.21 173.82,52.06 165.8,52.06 165.02,51.28 161.02,51.28 159.02,53.27 159.02,56.62 157.08,58.55 156.04,58.55 155.8,58.79 155.79,58.79 154.49,60.08 154.49,66.69 152.3,68.89 v1(152.3,70.09) ; 140.63,74.79 141.23,74.18 141.79,74.18 141.95,74.02 141.95,73 142,72.96 142,69.03 143.85,67.17 v1(146.44,67.17)
  BOTTOM w0.076: UC1.AN8 133.04,85.48 v3(132.9,85.48)
  BOTTOM w0.108: JSH1.4 174.37,52.25 v1(174.41,52.21)
SNUB_3V: length 1.8
  TOP w0.508: PR5305.2 190.8,48.39 v2(189.83,47.41)
SNUB_5V:
  vias: v2(191.6,70.98)
SPKR: length 294.7
  TOP w0.076: v3(134.74,82.87) 134.89,83.02 140.83,83.02 141.12,83.31 141.12,85.22 141.16,85.26
  TOP w0.127: R9560.2 154.87,84.95 154.01,84.09 150.66,84.09 150.45,84.29 150.45,84.6 v2(148.07,86.98) 147.37,87.68 143.58,87.68 143.34,87.43 143.34,87.43 141.16,85.26 ; v1(51.4,125.59) 51.39,125.59 50.48,125.59
  IN3 w0.127: v3(134.74,82.87) 136.64,82.87 137.6,81.9 140.94,81.9 141.29,81.55 141.29,81.41 143.73,78.96 147.24,78.96 149.67,81.4 151.83,81.4 152.65,80.57 152.66,80.57 154.48,80.57 157.06,77.99 157.16,77.99 157.22,77.93 159.01,77.93 159.36,78.29 166.62,78.29 168.89,80.56 173.37,80.56 173.84,80.09 181.27,80.09 181.78,80.59 182.9,80.59 v1(183.32,81.01) ; v1(51.4,125.59) 51.85,125.13 58.89,125.13 60.74,126.99 63.21,126.99 65.85,129.62 65.85,129.66 65.97,129.78 65.97,138.54 69.81,142.38 71.24,142.38 71.91,143.05 76.33,143.05 77.79,144.51 83.18,144.51 83.56,144.9 85.15,144.9 86.99,143.05 92.74,143.05 95.69,146.01 95.69,146.5 96.1,146.9 96.73,146.9 96.9,146.74 97.41,146.74 v1(97.8,147.13)
  IN4 w0.127: v1(97.8,147.13) 97.8,146.47 98.68,145.59 113.63,145.59 117,148.96 123.79,148.96 126.2,146.55 132.78,146.55 133.72,145.61 134.19,145.61 137.09,142.7 137.09,142.51 139.28,140.32 143.34,140.32 144.49,139.18 147.88,139.18 148.17,138.89 153.52,138.89 154.57,137.83 155.83,137.83 158.86,134.8 158.86,131.68 160.75,129.79 160.75,127.71 163.42,125.04 163.42,124.43 163.51,124.35 165.92,124.35 167.52,122.75 167.52,121.9 169.6,119.83 181.09,119.83 182.94,117.97 182.94,111.24 188.66,105.52 188.66,100.92 188.86,100.72 188.86,95.06 188.28,94.48 188.28,91.3 v1(189.67,89.9)
  BOTTOM w0.076: UC1.AW5 134.92,82.87 134.74,82.87 v3(134.74,82.87)
  BOTTOM w0.127: v1(189.67,89.9) 190.85,88.72 190.85,88.05 190.54,87.75 190.35,87.75 189.8,87.19 189.8,87.07 183.74,81.01 v1(183.32,81.01)
SRTCRST#: length 48.4
  TOP w0.076: v3(127.42,85.48) 127.93,85.99 127.93,86.5 v2(128.08,86.65) 128.15,86.73 128.7,86.73 129.11,87.14 129.61,87.14 129.72,87.25 131.12,87.25 131.45,87.58 132.19,87.58 CC24.1
  TOP w0.108: RC56.1 148.72,58.88 v1(147.39,58.88)
  IN3 w0.089: v3(127.42,85.48) 126.93,85 126.93,82.83 127.48,82.28 127.86,82.28 131.98,78.17 131.98,73.64 137.93,67.68 139.11,67.68 140.22,66.57 140.22,65.32 140.23,65.31 140.23,65.28 141.77,63.74 v1(141.77,63.31)
  BOTTOM w0.108: v3(127.42,85.48) 127.55,85.48 UC1.AN18 ; ME1.1 140.98,63.31 v1(141.77,63.31) 142.2,63.75 142.55,63.75 143.29,63 143.29,62.98 v1(147.39,58.88)
STRG_WAKE#_R: length 7.7
  BOTTOM w0.108: R9662.2 161.95,44.13 160.57,45.51 160.15,45.51 v2(159.9,45.76) 159.31,46.35 JSTRG1.38
SUS_STAT#: length 27.2
  BOTTOM w0.076: 141.16,78.64 140.99,78.64 140.7,78.35 138.71,78.35 138.31,77.95 135.03,77.95 134.54,78.44 132.6,78.44 132.14,78.9 132.14,78.9 131.45,79.6 131.45,80.47 UC1.BA11
  BOTTOM w0.108: v2(154.06,78.88) 154.06,79.77 RC343.1 151.05,79.85 148.71,77.51 143.11,77.51 141.98,78.64 141.16,78.64
SUSACK#: length 139.3
  TOP w0.076: 133.03,74.79 133.03,74.83 133.52,75.32 133.52,75.88 RC82.2 133.26,76.6 133.26,77.82 134.17,78.73 134.17,79.87 133.08,80.96 131.57,80.96 130.69,81.84 130.69,84.45 v3(131.07,84.82)
  TOP w0.108: 133.03,74.79 RC98.1 133.56,73.04 135.16,74.64 137.3,74.64 137.48,74.46 137.48,71.66 v1(137.09,71.27) ; v1(233,52.56) U38.B7
  IN2 w0.089: v1(233,52.56) 231.12,50.68 231.12,50.24 230.8,49.92 229.07,49.92 228.67,49.52 219.6,49.52 218.82,48.74 207.48,48.74 204.53,51.7 196.09,51.7 193.98,49.59 187.55,49.59 187.34,49.79 186.64,49.79 186.2,49.35 183.9,49.35 181.44,51.8 181.44,56.24 177.47,60.21 175.85,60.21 170.82,65.24 168.78,65.24 168.57,65.45 168.03,66 166.39,66 165.77,66.61 159,66.61 157.25,68.36 157.24,68.36 157.15,68.45 150.63,68.45 149.13,69.94 144.84,69.94 144.44,69.53 137.22,69.53 136.56,70.19 136.56,70.9 136.93,71.27 v1(137.09,71.27)
  BOTTOM w0.076: v3(131.07,84.82) 131.2,84.82 UC1.AP11
  BOTTOM w0.108: v2(136.33,71.01) 136.82,71.01 v1(137.09,71.27)
SUSCLK: length 8.9
  BOTTOM w0.076: v2(130.39,76.85) 129.65,77.59 129.55,77.59 128.27,78.86 128.27,79.79 128.37,79.89 128.37,80.26 128.1,80.53 UC1.BA17
  BOTTOM w0.108: v2(130.39,76.85) 131.04,76.2 R9436.1 R9435.1 131.9,75.25 132.36,74.8 132.36,74.72 132.69,74.39 RC48.1
SUSCLK_HDD: length 35.6
  BOTTOM w0.108: JSTRG1.3 157.06,63.85 157.17,63.96 157.17,65.92 156.81,66.28 155.92,66.28 155.2,66.99 153.66,66.99 152.64,68.01 151.37,68.01 150.84,68.54 150.84,72.12 v2(150.56,72.4) 150.56,72.63 149.87,73.32 147.86,73.32 146.72,72.17 145.5,72.17 144.92,72.76 138.24,72.76 138.07,72.93 135.7,72.93 135.52,73.11 132.41,73.11 131.89,73.64 R9435.2
SUSCLK_WLAN: length 308.3
  IN3 w0.089: v1(96.35,145.73) 93.23,142.61 86.29,142.61 85.53,143.37 78.29,143.37 76.9,141.97 71.42,141.97 71.41,141.97 70.03,141.97 66.39,138.32 66.39,129.05 61.97,124.64 57.17,124.64 56.76,124.23 50.33,124.23 49.08,122.98 49.08,121.6 47.47,119.98 46.12,119.98 45.54,119.4 43.12,119.4 42.66,118.94 42.66,117.36 40.21,114.92 33.73,114.92 33.48,115.16 32.31,115.16 31.77,115.7 31.77,123.66 v1(30.67,124.77) ; v1(170.29,68.9) 170.29,68.24 169.45,67.4 169.45,67.12 168.09,65.75 160.6,65.75 157.02,69.34 152.98,69.34 152.76,69.56 150.1,69.56 149.29,70.37 148.98,70.37 v1(148.27,71.08)
  IN4 w0.089: v1(182.18,66.66) 180.9,67.95 180.9,70.2 185.31,74.61 185.88,74.61 186.87,75.61 186.87,79.9 186.62,80.16 186.62,103.49 179.04,111.07 177.2,111.07 174.76,113.52 174.76,114.73 170.98,118.5 169.24,118.5 164.59,123.16 163.02,123.16 162.69,123.48 162.23,123.94 162.23,124.53 159.29,127.48 159.29,129.36 157.49,131.16 157.49,131.88 157.49,131.88 157.49,133.19 154.56,136.12 152.53,136.12 150.94,137.7 147.68,137.7 147.4,137.98 145.09,137.98 144.78,137.67 142.54,137.67 141.83,138.39 139.54,138.39 135.89,142.04 135.89,142.23 133.85,144.26 133.35,144.26 132.32,145.29 125.7,145.29 124,147 117.77,147 115.06,144.29 97.79,144.29 v1(96.35,145.73)
  BOTTOM w0.108: v1(170.29,68.9) 174.76,68.9 175.1,69.23 176.28,69.23 178.85,66.66 v1(182.18,66.66) ; v1(148.27,71.08) v2(147.75,71.6) 147.66,71.69 145.35,71.69 144.7,72.34 144.37,72.34 144.36,72.35 138.07,72.35 137.9,72.52 135.53,72.52 135.35,72.7 132.24,72.7 131.04,73.9 R9436.2 ; JWLAN1.50 v1(30.67,124.77)
SW_DPC_AUX: length 3.9
  TOP w0.089: U6.J13 86.92,125.47 86.92,124.45 86.67,124.19
  TOP w0.108: 86.67,124.19 86.03,123.56 85.74,123.56 T6303.1
SW_DPC_AUX#: length 9.8
  TOP w0.108: U6.J14 86.61,124.59 85.98,123.96 84.52,123.96 83.15,122.59 83.15,119.67 84.29,118.53 T6304.1
SYS_CLK: length 3.2
  TOP w0.108: v1(101.99,132.32) 101.59,131.92 101.59,131.38 T6353.1
  BOTTOM w0.108: JWWAN1.46 101.46,132.83 101.7,132.59 101.73,132.59 v1(101.99,132.32)
SYS_PRES#_D: length 8.8
  TOP w0.108: JBAT_PK2.4 v5(210.43,112.4)
  BOTTOM w0.108: JBAT_PK2.4 212.3,112.4 211.8,111.9 JBAT_PK1.8
SYS_PWROK_R: length 16.5
  TOP w0.108: CC278.2 RC594.2 138.42,112.35 137.29,112.35 RC404.2 135.8,111.83 135.8,108.98 135.98,108.8 135.98,108.47 136.15,108.29 v2(136.15,108.19) 136.54,107.81 v1(136.97,107.81)
  BOTTOM w0.076: UC1.B6 135,101.96 135.29,102.26 135.29,102.57 135.26,102.6 135.26,103.41 136.12,104.27
  BOTTOM w0.108: 136.12,104.27 136.12,106.45 136.57,106.91 136.57,107.42 v1(136.97,107.81)
SYS_RESET#: length 69.6
  TOP w0.108: v1(161.98,84.79) 161.52,84.34 161.27,84.34 160.61,83.68 160.03,83.68 159.8,83.91 JAPS1.13 ; v1(162.85,99.58) v2(162.04,99.58)
  IN1 w0.089: v1(162.85,99.58) 162.85,98.12 161.35,96.62 161.35,96.61 161.07,96.33 161.07,93.27 162.46,91.88 162.46,85.27 v1(161.98,84.79)
  IN2 w0.089: v1(162.85,99.58) 161.71,98.44 155.99,98.44 155.92,98.37 152.48,98.37 149.54,101.31 149.54,104.68 146.97,107.25 137.06,107.25 v1(136.99,107.18)
  BOTTOM w0.076: UC1.B5 135.91,102.39 135.91,102.94 136.73,103.77
  BOTTOM w0.108: RC224.2 138.39,111.54 CC276.2 RC353.1 137.28,111.72 136.26,111.72 135.42,110.88 135.42,109.58 C9887.1 136.52,108.47 136.89,108.47 137.38,107.98 137.38,107.57 v1(136.99,107.18) 136.99,106.64 136.73,106.38 136.73,103.77
