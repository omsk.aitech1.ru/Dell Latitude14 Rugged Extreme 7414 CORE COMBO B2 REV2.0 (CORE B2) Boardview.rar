# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N37718472: length 2.1
  TOP w0.108: PC5813.2 PR5825.2 62.95,111.11 62.67,110.83 v2(62.67,110.02)
N37718797: length 11.6
  TOP w0.108: PU5801.5 68.9,113.85 68.7,114.05 68.02,114.05 PR5827.1 67.18,114.9 66.36,114.9 66.25,115.01 63.41,115.01 62.14,113.74 PR5826.1 61.48,113.12 61.48,112.54 61.17,112.23 v2(61.17,111.85) 61.57,111.46 61.78,111.46 PR5825.1
N37719668: length 1.4
  TOP w0.108: PC5814.2 65.92,114.14 66.5,114.14 PR5827.2
N37720303: length 56.3
  TOP w0.108: PR5840.1 68.59,106.24 v2(68.01,105.65)
  TOP w0.254: v1(107.83,125.29) 108.29,125.29 PH5804.2 ; PR5834.2 PR5840.1 69.78,106.24 v1(70.17,106.62)
  IN1 w0.254: v1(107.83,125.29) 107.25,124.7 107.25,119.34 106.02,118.11 106.02,116.66 105.73,116.37 105.73,112.51 104.96,111.75 103.95,111.75 101.66,109.46 97.34,109.46 96.72,110.08 82.43,110.08 81.8,109.45 73,109.45 v1(70.17,106.62)
N37720638: length 4.8
  TOP w0.108: PU5801.14 70.96,110.94 70.17,110.15 v2(69.89,110.15) 69.55,109.81 68.51,109.81 68.39,109.69 PC5828.1 PR5842.2
N37720783: length 7
  TOP w0.108: PU5801.15 71.36,110.99 69.98,109.61 68.66,109.61 68.49,109.43 68.49,108.19 68.31,108.01 v2(68.31,107.4) 68.62,107.1 PR5840.2
N37721989: length 6
  TOP w0.108: PU5801.23 74.71,112.65 75.01,112.36 75.72,112.36 76.24,111.84 PC5815.2 76.8,111.19 77.88,111.19 v2(77.99,111.3) 78.2,111.51 78.84,111.51 PR5828.1
N37722129: length 5.7
  TOP w0.108: PR5831.1 78.73,112.34 77.67,112.34 77.55,112.22 76.86,112.22 PC5812.2 76.41,112.67 75.47,112.67 v2(75.32,112.81) 75.08,113.05 PU5801.24
N37722505: length 2
  TOP w0.108: PR5831.2 79.59,112.99 PC5816.2 80.35,113.58 v2(80.43,113.65)
N37723172: length 16.1
  TOP w0.108: PR5829.1 83.88,111.75 84.07,111.94 PR5832.1 84.45,111.93 PR5830.1 85.41,112.33 v1(84.57,113.17) 84.21,113.53 v2(84.21,113.73) ; PU5801.25 75,113.45 75.17,113.28 76.94,113.28 77.05,113.17 78.06,113.17 v1(78.47,112.76)
  IN1 w0.089: v1(78.47,112.76) 79.45,112.76 79.82,113.14 79.84,113.14 80.27,113.57 82.09,113.57 82.9,112.76 84.14,112.76 84.54,113.17 v1(84.57,113.17)
N37723177: length 2.7
  TOP w0.108: v2(82.05,114.24) 82.64,113.65 PC5817.2 PR5829.2
N37724020: length 2.7
  TOP w0.108: v2(85.74,108.7) 85.74,109.31 PC5818.2 85.22,110.17 85.41,110.35 PR5830.2
N37728002: length 1.9
  TOP w0.108: v2(70.22,107.43) 69.89,107.76 PR5846.1 PC5836.1
N37728005: length 3.7
  TOP w0.108: PU5801.16 71.76,111.03 70.13,109.4 70.06,109.4 PR5846.2 PC5835.1
N37728791: length 3.4
  TOP w0.108: PR5849.1 71.23,104.28 71.36,104.15 72.48,104.15 PC5837.1 73.56,104.59 v2(73.94,104.2)
N37729705: length 1
  TOP w0.108: PC5838.2 PR5851.2
N37729720: length 9.6
  TOP w0.108: PU5801.17 72.16,110.17 71.65,109.66 71.65,108.48 70.8,107.63 70.8,106.92 PR5850.2 70.94,106.2 70.84,106.2 70.22,105.58 v2(70.22,105.22) 70.67,105.22 70.9,105.45 PR5849.2 71.84,104.84 71.84,104.81 PR5851.1
N37735982: length 2
  TOP w0.254: PC5914.1 118.47,124.84 v1(118.73,124.58)
  BOTTOM w0.254: v2(119.49,124.58) v1(118.73,124.58)
N37737217: length 7.5
  TOP w0.229: 111.67,121.12 111.87,121.32 PJP5901.1
  TOP w0.254: 111.67,121.12 108.75,121.12 108.67,121.2 107.14,121.2 PR5903.2 105.94,120 v5(105.52,120)
N37747714: length 3.3
  TOP w0.108: Q3609.3 43.02,96.76 43.19,96.58 R9492.2 44.31,96.53 v2(44.31,95.64)
N37818358: length 6.6
  TOP w0.108: PU5801.31 73.36,116.55 74.43,117.62 74.76,117.62 76.23,119.08 76.28,119.08 76.53,119.33 76.72,119.33 PR5819.2 77.09,119.67 v2(78.14,119.67)
N37888482:
  vias: v2(139.03,122.26)
N37888825: length 1.5
  TOP w0.203: PC5512.1 132.6,126.57 133.03,126.14 PU5501.5
N37888837: length 0.9
  TOP w0.152: PC5506.1 PR5505.2
N37906286: length 2.5
  TOP w0.203: PU5201.21 235.46,34.92 234.96,35.42 v1(234.96,35.44) 234.96,36.34 PR5242.2
  BOTTOM w0.108: v1(234.96,35.44) 234.97,35.45 v2(235.67,35.45)
N37906325: length 6.7
  TOP w0.108: 238.47,35.65 238.92,35.65 239.84,36.56 PR5248.2 240.27,37.45 240.27,38.2 240.16,38.32 240.09,38.32 PR5245.1 ; 238.47,35.65 v1(238.47,35.65) ; 238.47,35.65 237.92,35.65 237.46,35.19 PU5201.16
  BOTTOM w0.108: v2(238.62,36.44) 238.62,35.81 v1(238.47,35.65)
N37906747:
  vias: v2(208.82,40.5)
N37906776:
  vias: v2(230.57,31.66)
N37907023: length 1.4
  TOP w0.508: v2(235.8,39.42) 235.94,39.56 PR5249.2
N37913630: length 24
  TOP w0.508: PQ5213.2 252.59,25.94 252.59,26.86 252.89,27.17 PR5215.2 252.99,27.45 v1(252.54,27.9) ; PQ5203.2 246.89,26.34 246.77,26.45 PR5205.2 246.77,27.41 247.41,28.04 v1(247.58,28.04) ; v1(237.55,27.5) PR5222.2
  IN2 w0.508: v1(237.55,27.5) 237.63,27.42 246.96,27.42 v1(247.58,28.04) 248.33,28.04 249.08,27.29 251.93,27.29 v1(252.54,27.9)
  BOTTOM w0.108: v2(251.89,27.9) v1(252.54,27.9)
N37913681: length 54.5
  TOP w0.254: v1(196.8,22.92) 197.19,23.32 197.19,23.79 PQ5209.3 198.82,26.05 199.02,26.25 PR5206.1 199.02,27.29 199.45,27.72 v2(200.16,27.72) ; PQ5206.1 v1(234.44,24) 234.44,22.6 234.03,22.2 231.47,22.2 231.01,22.66 PQ5207.1
  IN3 w0.254: v1(196.8,22.92) 197.31,22.42 233.77,22.42 234.44,23.09 v1(234.44,24)
N37917235: length 2.7
  TOP w0.254: PU5203.5 215.02,45.4 v2(214.97,45.35) 214.97,44.92 215.07,44.82 PR5260.2
N37917241: length 5.6
  TOP w0.108: v2(214.92,42.18) 215.61,42.86 PU5203.7 217.71,42.86 217.87,43.02 217.87,43.98 217.71,44.13 PU5203.6
N37917251: length 6.1
  TOP w0.108: PR5263.2 226.86,42.53 v2(226.76,42.43) 226.6,42.28 226.17,42.28 PR5256.2 PR5254.1 PR5259.2 223.71,41.59 PU5203.1
N37917261: length 7.4
  TOP w0.108: PR5252.1 227.75,43.83 227.82,43.9 v2(227.82,44.39) 227.72,44.49 226.88,44.49 PR5263.1 226.01,45.37 225.42,45.37 PR5261.2 PC5240.2 223.3,44.13 PU5203.3
N37917267: length 6
  TOP w0.108: v2(225.89,44.79) 226.21,44.47 226.21,43.03 225.87,42.69 PR5253.1 PR5258.1 PC5241.2 223.84,42.86 PU5203.2
N37918611: length 2.9
  TOP w0.108: v2(234.21,40.51) 233.37,40.51 PR5251.2 ; PR5251.2 PR5250.2 ; PR5251.2 233.23,39.94 233.19,39.9 PU5202.2
N37918619: length 4.8
  TOP w0.108: PU5202.4 231.77,37.52 231.07,38.22 230.29,38.22 230.19,38.11 PQ5220.5 230.19,36.67 v2(229.7,36.18)
N37918714: length 4
  TOP w0.254: PR5262.1 229.88,41.22 229.49,41.62 v2(229.49,42.22) ; PR5262.1 229.54,40.79 PQ5220.3 ; PR5262.1 230.19,40.83 PQ5220.2
N37918742: length 3.5
  TOP w0.108: PQ5220.6 230.84,36.33 PR5255.1 230.64,35.37 PR5257.2 230.19,34.91 v2(230.19,34.3)
N37925093: length 10.5
  TOP w0.254: PQ5211.3 242.66,25.42 242.4,25.16 PQ5205.1 240.75,25.16 239.69,24.09 v1(239.28,24.09) 238.89,24.09 238.56,24.42 238.56,24.97 238.37,25.16 PQ5204.1 237.74,26.67 PR5209.1 PR5207.1
  BOTTOM w0.108: v2(239.76,23.33) 239.76,23.61 v1(239.28,24.09)
N37935243: length 4.4
  TOP w0.108: PU5201.11 239.71,33.01 240.22,33.52 v1(241.97,33.52) 242.43,33.52 PR5238.1
N37935252: length 5.1
  TOP w0.108: PR5239.1 242.41,33.95 240.07,33.95 v1(239.65,33.53) 239.53,33.41 PU5201.12
  BOTTOM w0.108: v2(240.12,33.06) v1(239.65,33.53)
N37935306: length 7.9
  TOP w0.108: PU5201.10 238.92,32.61 239.05,32.47 239.76,32.47 240.37,33.08 242.07,33.08 242.33,32.83 244.44,32.83 v2(244.82,33.21) 244.87,33.16 PR5236.1
N37936268: length 7.9
  TOP w0.108: PU5201.7 238.39,31.16 238.95,30.6 PC5222.2 240.88,31.05 242.25,31.05 PR5228.1 242.71,29.6 v1(243.26,29.05)
  BOTTOM w0.108: v2(243.26,28.34) v1(243.26,29.05)
N37936296: length 5.9
  TOP w0.108: PR5229.1 242.28,31.92 240.85,31.92 PC5224.2 240.19,31.26 239.35,31.26 v1(239.29,31.32) 238.8,31.81 PU5201.8
  BOTTOM w0.108: v1(239.29,31.32) 239.79,30.82 v2(239.79,30.49)
N37936306: length 5.9
  TOP w0.108: PR5231.1 242.5,32.58 242.28,32.58 242.03,32.83 240.88,32.83 PR5232.1 240.02,31.97 v1(239.69,31.97) 239.13,31.97 238.89,32.21 PU5201.9
  BOTTOM w0.108: v2(238.67,31.97) v1(239.69,31.97)
N39760572: length 5.5
  BOTTOM w0.279: U25.1 188.24,147.88 187.67,148.45
  BOTTOM w0.457: C9563.1 189.99,149.35 RC623.1 191.07,149.54 RC342.1
  BOTTOM w0.508: C9563.1 188.31,149.35 188.21,149.25 C9562.1 187.67,148.45
N39919248: length 1
  BOTTOM w0.108: C76.2 155.83,122.61 155.89,122.54 R57.1
N39919254: length 3.7
  BOTTOM w0.108: v2(142.68,118.73) 143.09,118.33 144.33,118.33 144.65,118.64 C85.2 144.65,119.86 R45.1
N40246279: length 5.2
  TOP w0.108: v2(184.29,121.37) 184.75,121.83 184.75,123.45 184.91,123.61 RC400.2 185.95,123.61 185.99,123.65 JFWP1.3
N40499876: length 11.7
  TOP w0.108: v1(189.67,99.1) 189.21,99.1 189.08,98.97 UC10.4 ; U6217.5 187.72,91.96 188,91.68 188.73,91.68 RC458.1 188.66,92.27 v2(188.66,93.36) 188.66,94.25 v1(189.39,94.98)
  IN1 w0.089: v1(189.67,99.1) 188.96,98.39 188.96,95.42 v1(189.39,94.98)
N40499957: length 4.4
  TOP w0.108: U6217.10 184.07,91.96 183.96,92.06 183.04,92.06 182.79,91.81 C9841.1 181.85,92.06 181.85,92.11 181.6,92.37 181.24,92.37 v2(180.76,92.85)
N40499959: length 2.3
  TOP w0.381: RC456.1 182.64,93.07
  TOP w0.508: v5(184.01,94.07) 183.83,93.89 183.83,92.75
N40617893: length 28.3
  TOP w0.254: PQ5103.4 68.72,81.7 v1(69.53,80.89) ; PQ5104.3 75.87,68.56 76.08,68.77 v2(77.38,68.77) v1(78.42,68.77)
  TOP w0.381: 68.69,86.65 PR5116.1 67.75,87.53 PC5109.2 ; 68.69,86.65 68.31,86.27 68.31,85.41 68.72,85 PQ5103.4 ; 68.69,86.65 PR5115.2
  IN2 w0.254: v1(78.42,68.77) 77.2,68.77 76.82,69.15 70.06,75.91 70.06,80.36 v1(69.53,80.89)
N40617909: length 5
  TOP w0.108: PQ5101.3 242.71,41.39 242.55,41.23 PL5103.2 241.06,41.23 240.74,40.91 v2(240.74,40.25) 241.08,39.9 241.5,39.9 PR5107.1
N40617911: length 11
  TOP w0.108: PR5108.2 PR5109.2 248.8,35.88 248.18,36.5 247.39,36.5 v2(246.77,37.12) 247.32,37.67 248.46,37.67 248.8,38.01 PQ5102.3 248.8,39.46 248.65,39.61 247.33,39.61 246.5,40.44 PQ5101.1
N40617913: length 11.9
  TOP w0.108: PR5110.2 PR5107.2 242.19,39.24 v2(244.44,39.24) 244.44,40.46 245.08,41.11 246.34,41.11 247.23,40.22 249.54,40.22 249.75,40.44 PQ5102.1
N40617923: length 2.9
  TOP w0.108: v2(247.66,43.63) 247.66,42.91 PR5106.1 246.8,42.53 246.6,42.34 PQ5101.2
N40618012: length 4.5
  TOP w0.108: PQ5104.5 75.37,69.13 75.27,69.03 74.97,69.03 74.87,69.12 PQ5104.6 74.87,69.98 74.76,70.09 74.23,70.09 73.95,69.81 73.95,68.87 v2(73.62,68.54)
N40618018: length 7.1
  TOP w0.254: PQ5106.3 73.48,70.83 73.3,71.01 73.01,71.01 72.83,70.83 PQ5106.2 72.83,67.37 v2(73.56,66.65) 73.92,66.28 PR5117.2
N40618025: length 2
  TOP w0.108: PR5114.1 PR5112.2 70.11,86.32 PQ5105.1
N40618028: length 20.6
  TOP w0.108: PR5114.2 69.99,88.46 71.03,88.46 71.31,88.18 71.31,87.7 71.4,87.6 73.33,87.6 74.15,86.78 74.15,80.33 v2(73.98,80.15) 73.39,79.57 73.39,74.85 72.18,73.63 PQ5106.6
N40618035: length 6.3
  TOP w0.305: v2(73.98,88.02) 73.6,88.4 PQ5105.3
  TOP w0.381: PC5109.1 68.88,88.47 69.24,88.82 71.4,88.82 PQ5105.3
N40619003: length 4
  TOP w0.254: v2(248.42,28.21) PR5208.2
  TOP w0.508: PQ5203.1 248.79,26.09 248.42,26.45 PR5208.2 PR5205.1
N40619021: length 30.5
  TOP w0.381: v1(231.2,26.66) 230.82,27.04 v2(229.63,27.04) 229.42,27.04 228.89,27.57 228.89,29.53 228.27,30.15 228.24,30.15 228.16,30.23 226.67,30.23 225.98,29.54 PQ5201.4
  TOP w0.508: v1(248.85,22.98) 249.11,22.72 PR5203.2 PR5201.2
  IN2 w0.508: v1(248.85,22.98) 248.14,22.98 245.86,25.26 232.5,25.26 231.2,26.56 v1(231.2,26.66)
N40619038: length 22.4
  TOP w0.203: PJP5201.2 213.37,23.74 213.49,23.86 v1(213.49,24.3)
  TOP w0.254: v1(233.11,24.25) 233.11,24.25 233.49,23.86 PQ5206.3
  BOTTOM w0.254: v1(213.49,24.3) 213.49,24.17 214.03,23.64 231.42,23.64 v2(232.01,24.23) 232.03,24.25 v1(233.11,24.25)
N40619039: length 18
  TOP w0.203: 214.49,23.74 214.23,23.74 214.11,23.86 v1(214.11,24.3)
  TOP w0.254: PQ5207.3 v1(230.06,24.25)
  BOTTOM w0.254: v1(214.11,24.3) 214.16,24.25 v2(215.63,24.25) v1(230.06,24.25)
N40619055: length 7.7
  TOP w0.108: PR5208.1 249.29,28.66 249.06,28.89 248.3,28.89 247.99,29.2 247.99,30.34 247.74,30.6 PQ5212.3 247.05,32.53 v2(246.67,32.91)
N40619057: length 3.7
  TOP w0.508: v1(255,26.37) 254.99,26.37 ; 254.99,26.37 255.27,26.09 PQ5213.1 ; 254.99,26.37 254.7,26.66 254.7,27.12 PR5219.2 PR5215.1
  BOTTOM w0.108: v2(255,25.72) v1(255,26.37)
N40619062: length 5.1
  TOP w0.108: PQ5215.3 253.14,28.39 v2(253.34,28.19) 253.88,27.65 255.03,27.65 PR5219.1
N40619082: length 49.2
  TOP w0.508: PR5210.2 PR5213.2 255.56,22.72 v1(255.2,22.37)
  BOTTOM w0.508: v1(209.19,23.03) v2(210.02,23.03) 210.53,23.03 211.19,22.37 v1(255.2,22.37)
N40619084: length 4
  TOP w0.508: PR5203.1 249.9,23.64 249,23.64 248.78,23.86 v1(248.78,24.01) 248.41,23.64 248.13,23.64 247.84,23.36 PQ5203.3
  BOTTOM w0.381: v2(248.78,24.7) v1(248.78,24.01)
N40619087: length 3.5
  TOP w0.381: v1(253.5,23.15) 253.58,23.08 PQ5213.3
  TOP w0.508: PR5213.1 255.71,23.99 254.8,23.08 PQ5213.3
N40619103: length 5.9
  TOP w0.108: PQ5214.2 247.69,33.77 PR5216.1 ; v2(247.99,35.73) 248.37,35.34 248.37,34.58 248.14,34.35 247.74,34.35 247.61,34.23 PR5216.1 ; PR5216.1 248.18,33.12 PQ5214.3
N40619115: length 3.5
  TOP w0.254: v1(252.69,23.89) 252.59,23.99 PR5201.1 251.65,24.75 251.66,24.77 PQ5202.6
  BOTTOM w0.108: v2(251.9,23.89) v1(252.69,23.89)
N40619122: length 5.4
  TOP w0.108: PQ5202.3 250.36,28.73 PR5204.1 250.96,28.61 251.01,28.56 PQ5202.2 251.01,27.12 251.29,26.84 251.29,26.53 v1(251.29,26.53)
  BOTTOM w0.108: v2(251.24,25.69) 251.24,26.48 v1(251.29,26.53)
N40619139: length 3.1
  TOP w0.254: v2(259.22,23.46) 258.68,23.99 PR5210.1 258,24.93 258.01,24.95 PQ5210.6
N40619145: length 4.6
  TOP w0.108: v2(257.76,29.33) 257.36,28.93 PQ5210.2 257.36,27.42 257.24,27.29 256.86,27.29 256.71,27.44 PQ5210.3 255.97,27.98 PR5214.1
N40639016: length 2.2
  TOP w0.254: R388.1 v5(149.03,76.32) 149.35,75.99 150.13,75.99 JDEG1.1
N40639050: length 101.6
  TOP w0.108: v1(225.06,64.25) 225.06,65.12 225.29,65.35 225.29,65.69 224.9,66.08 224.65,66.08 224.47,66.26 R9577.1 R406.1 225.99,66.74 R397.1 ; JDEG1.9 154.14,76.73 v1(153.79,77.08)
  IN2 w0.089: v1(153.79,77.08) 155.22,75.65 165.66,75.65 168.27,73.04 169.64,73.04 174.38,68.29 174.38,67.43 182.59,59.22 184.25,59.22 184.72,58.76 184.72,58.51 185.45,57.78 186.19,57.78 187.79,56.18 188.91,56.18 190.32,54.78 193.71,54.78 194.54,53.94 206.15,53.94 208.76,51.33 215.33,51.33 217.91,53.91 222.24,53.91 222.87,53.28 v1(222.87,53.2)
  BOTTOM w0.108: v1(225.06,64.25) 225.55,63.76 v2(225.55,63.5) 225.41,63.36 224.1,63.36 223.03,62.28 223.03,61.28 222.89,61.15 222.89,58.63 223.48,58.05 223.48,54.48 222.87,53.87 v1(222.87,53.2)
N40639272: length 2.7
  TOP w1.016: v4(77.38,73.29) 77.38,72.05 76.81,71.48 FANF1.1
  vias: v2(74.08,79.87)
N40639416: length 2.5
  TOP w0.108: R382.1 242.94,59.73 v2(243.6,60.39) 244.05,60.39 244.13,60.31 C363.1
N40639448: length 3.4
  TOP w0.108: v2(247.58,58.66) 247.05,59.2 247.05,59.62 247.13,59.7 R403.2 247.57,60.83 Q12.1
N40942623:
  vias: v2(110.68,129.86)
N40942627: length 1.2
  TOP w0.254: v2(107.25,131.76) 107.82,131.76 PR5901.1
N40942629: length 2.6
  TOP w0.508: v2(109.26,133.8) 109.26,132.35 109.6,132.01 PR5901.2
N40943390: length 6.7
  TOP w0.108: v5(106.64,126.56) 106.43,126.34 106.43,125.23 106.38,125.18 106.38,124.98 106.43,124.94 106.43,124.91 106.44,124.9 106.44,124.73 106.79,124.37 PR5915.2
  TOP w0.165: PU5901.1 110.1,125.39 108.92,124.21 107.23,124.21 PR5915.2
N40990975: length 2.6
  TOP w0.108: C9840.1 183.05,86.73 v2(183.12,86.8) 183.28,86.96 U45.12
N41315003: length 4.6
  TOP w0.254: PD5206.3 226.97,30.91 v2(226.96,30.9)
  TOP w0.508: PR5230.2 229.79,29.89 PD5206.3
N41332798: length 2.4
  TOP w0.108: R324.1 C339.1 269.75,54.97 v2(270.11,55.33)
N41518611: length 5.1
  TOP w0.108: Q4209.2 34.94,133.95 v5(34.54,133.55) 33.84,132.86 R142.2 R153.2
N41748705: length 2.9
  TOP w0.108: U43.12 184.09,97.12 183.98,97.02 183.22,97.02 v5(182.97,97.27) 182.23,97.27 C397.1
N41748888: length 4.7
  TOP w0.108: U6217.12 184.07,91.16 183.96,91.05 182.69,91.05 182.56,90.92 C390.1 182.1,90.84 181.72,90.46 180.45,90.46 v2(180.3,90.62)
N41749169: length 2.5
  TOP w0.108: R418.2 188.66,91.05 188.53,91.17 v2(188.05,91.17) 187.92,91.05 187.21,91.05 187.1,91.16 U6217.3
N41749239: length 4.4
  TOP w0.108: U43.3 187.15,97.12 187.23,97.04 187.74,97.04 187.74,97.04 187.99,96.78 188,96.78 188.02,96.76 188.02,96.58 188.33,96.28 R424.2 188.33,95.09 188.12,94.88 v2(187.39,94.88)
N41808708: length 7.2
  TOP w0.108: v2(65.62,118.66) 65.62,119.09 66.1,119.57 PR5824.2 66.64,119.16 66.64,118.21 67.08,117.76 68.13,117.76 69.21,116.68 PU5801.1
N41930622:
  vias: v2(121.7,123.58)
N41930661: length 1.3
  BOTTOM w0.254: v2(123.3,125.85) 124.23,125.85 PC5924.1
N41930679: length 5.9
  TOP w0.229: 125.23,119.24 125.66,119.67 125.66,120.33 125.77,120.43 PJP5903.1
  TOP w0.254: v2(121.7,120.46) 122.65,120.46 PR5907.2 123.87,119.24 125.23,119.24
N41934758: length 1.5
  TOP w0.203: PU5903.1 63,91.5 62.88,91.38
  TOP w0.254: PR5913.2 62.88,91.38
N41935105: length 7
  TOP w0.229: PJP5905.1 67.2,94.12 67.37,93.94
  TOP w0.254: v2(68.08,89.4) 67.59,89.4 PR5911.2 67.37,91.46 67.37,93.94
N41935204:
  vias: v2(58.63,92.37)
N41935208: length 1.2
  TOP w0.254: v2(56.5,91.05) 56.29,91.26 PC5926.2
N41935210: length 1.3
  TOP w0.254: v2(57.36,94.55) 57.36,94.27 57.63,94.01 PR5909.2
N42006311: length 2.8
  BOTTOM w0.108: U51.10 56.85,118.92 v2(56.94,118.84) 56.94,118.59 56.5,118.15 C427.1
N42006406: length 6.2
  BOTTOM w0.108: U51.3 56.05,122.73 55.9,122.88 55.9,123.47 55.43,123.94 RC464.2 RC465.2 53.88,126.18 v2(52.72,126.18)
N42006453: length 4
  BOTTOM w0.108: U51.12 56.05,119.6 55.74,119.29 55.74,119.16 54.9,118.33 C409.1 54.9,117.82 v2(54.04,116.96)
N42016762: length 3
  TOP w0.108: v1(209.56,141.8) 209.55,141.81 Q3601.1
  BOTTOM w0.108: v1(209.56,141.8) 209.61,141.85 R3603.2 v2(209.61,143.8)
N42029378: length 2.6
  TOP w0.254: U6202.14 261.22,37.52 261.35,37.66 v2(261.35,38.14) 261.02,38.47
  TOP w0.381: R3701.2 260.68,38.66 260.87,38.47 261.02,38.47
N42030930: length 3.7
  TOP w0.254: U6203.1 130.7,144.78 130.95,145.02 131.58,145.02 v2(132.29,144.31) 132.52,144.08 C9453.1
N42030932: length 7.2
  TOP w0.254: v2(135.14,143.32) 134.93,143.12 C9453.2 133.79,143.6 131.99,145.4 130.41,145.4 130.05,145.04 U6203.2
N42030938: length 1.8
  TOP w0.305: U6203.3 129.4,145.43 129.47,145.5 C9454.1
N42030962: length 1.5
  TOP w0.254: C9455.2 131.33,138.21 131.29,138.25 U6203.28
N42030964: length 5.1
  TOP w0.254: U6203.24 128.1,137.38 128.33,137.15 131.94,137.15 C9455.1
N42030974: length 4.9
  TOP w0.254: U6203.27 130.05,139 130.57,139.51 v2(132.37,139.51) 133.39,138.49 C9456.1
N42030984: length 13.8
  TOP w0.108: U6203.23 127.45,137.28 127.32,137.15 126.93,137.15 126.8,137.28 U6203.22 126.8,138.88 126.22,139.46 126.22,139.92 126.91,140.61 126.91,141.39 126.66,141.64 v2(120.53,141.64) R9396.1
N42702316: length 3
  BOTTOM w0.203: PC5611.2 168.11,101.99 168.16,101.94 v2(168.77,101.94) 169.08,101.94 169.65,102.51 169.65,102.62 169.76,102.73 PU5602.7
N42702326:
  vias: v2(176.01,99.86)
N42702402: length 3.2
  BOTTOM w0.254: PU5602.14 173.98,102.73 174.08,102.83 v2(174.08,102.83) 174.74,102.83 PR5622.1 PR5618.1
N42703158: length 2.4
  BOTTOM w0.254: PC5601.2 175.07,78.2 174.19,78.2 173.83,77.84 PU5601.7
N42703168: length 1.1
  BOTTOM w0.254: v2(167.23,79.58) 167.52,79.87 PC5609.2
N42703218: length 5.3
  BOTTOM w0.108: 168.26,78.17 167.88,77.79 v2(166.33,77.79)
  BOTTOM w0.203: PU5601.14 169.86,77.84 169.35,77.33 PR5611.1 PR5607.1
N42703282: length 3.9
  BOTTOM w0.108: PU5601.5 173.58,78.84 173.92,79.19 173.92,79.55 v2(174.29,79.91) 174.58,80.2 PR5604.1 PR5603.1
N42704390: length 1.3
  TOP w0.254: PC5709.1 215.23,58.34 214.97,58.08 v2(214.97,57.72)
N42704539: length 3.1
  TOP w0.108: PR5707.1 191.5,111.64 191.5,113.27 v2(191.17,113.6)
N42707454: length 2.9
  TOP w0.254: v2(213.42,49.06) 213.42,49.54 213.93,50.05 214.74,50.05 215.18,50.49 PC5728.1
N42743777: length 3.5
  TOP w0.254: v2(89.77,108.61) 89.77,109.23 90.74,110.2 U6221.9
N42775282:
  vias: v1(192.34,65.52) v2(196.63,63.77)
N42775605: length 5.8
  TOP w0.108: PR5307.2 194.35,67.91 194.35,65.98 v2(193.61,65.24) 193.61,64.38 194.08,63.91 PU5301.1
N42775609: length 3
  TOP w0.108: PR5308.2 192.14,62.22 192.77,62.22 v2(192.97,62.42) 193.58,62.42 193.7,62.31 PU5301.5
N42777212: length 2.5
  TOP w0.254: RC83.1 v2(134.51,38.04)
  TOP w0.432: CC67.2 RC83.1
N42777222: length 2.2
  TOP w0.254: v2(135.22,24.65) 135.22,25.7 RC128.1
  TOP w0.508: CC69.2 RC128.1
N43141708: length 9.4
  TOP w0.508: L2800.10 176.46,124.5 v1(175.65,123.69) ; C9885.1 174.36,123.22 v1(174.83,123.68) 174.83,123.69 174.99,123.85 174.99,124.19 175.19,124.4 L2800.9 ; C2802.1 168.71,123.17 v1(169.23,123.69) 168.84,124.07 L2800.4 ; v1(167.57,123.69) L2800.3
  vias: v2(168.06,124.42)
N43141816:
  vias: v2(166.03,133.47)
N43143021: length 11.3
  TOP w0.254: R9401.1 161.28,131.74 v1(161.2,131.81)
  BOTTOM w0.254: v1(161.2,131.81) 161.22,131.84 161.22,132.2 161.99,132.96 v2(161.99,134.71) 163.56,136.28 164.13,136.28 JLAN1.A1
N43143023: length 8
  TOP w0.254: JLAN1.A3 167.74,138.18 166.61,139.31 165.47,139.31 v1(163.82,137.66) 163.46,137.66 R9443.1
  BOTTOM w0.108: v1(163.82,137.66) 163.31,137.15 v2(163,137.15)
N43143025: length 4.8
  TOP w0.108: v2(183.07,140.5) R2803.2
  TOP w0.254: R2803.2 181.19,139.61 JLAN1.B2
N43152286: length 4.6
  BOTTOM w0.108: Q19.6 190.83,44.93 190.66,45.1 190.28,45.1 190.18,45 Q19.5 190.18,43.93 189.93,43.68 188.96,43.68 R126.2
N43265037: length 4.4
  TOP w0.108: v2(181.14,88.61) 181.7,88.05 181.95,88.05 182.1,87.9 C401.1 182.48,87.24 183.7,87.24 184.23,87.76 U45.10
N43265206: length 4.8
  TOP w0.108: U46.12 206.93,63.39 C398.1 206.77,64.15 206.77,65.42 v2(206.97,65.62)
N43265690: length 52.8
  TOP w0.108: U46.3 v1(206.93,58.41) ; v1(189.67,89.17) 189.01,88.51 R422.2
  IN1 w0.089: v1(206.93,58.41) 205.5,59.84 195.08,59.84 194.47,60.45 189.67,60.45 185.25,64.87 185.25,67.26 188.47,70.49 188.47,87.97 v1(189.67,89.17)
  BOTTOM w0.108: v2(189.67,88.53) v1(189.67,89.17)
N43409554: length 3
  TOP w0.108: Q4.3 45.91,105.78 45.41,106.27 v2(45.08,106.27) 44.35,106.27 R99.2
N43409569: length 6.4
  TOP w0.108: v2(32.45,107.81) 32.64,108 R2602.2 33.91,108.32 36.49,108.32 37.63,107.17 Q216.1
N43410155: length 10.7
  TOP w0.108: Q1.1 42.75,106.61 42.82,106.54 R94.1 43.24,106.03 43.5,105.78 44.77,105.78 45.35,105.19 45.35,103.8 46.16,102.99 46.16,101.59 46.47,101.28 v2(46.47,100.85) 46.47,100.75 45.77,100.05 Q17.6
N43412177: length 3
  TOP w0.254: R9488.1 50.01,88.57 49.61,88.97 U6207.3 48.77,89.91 v2(48.5,90.18)
N43412185: length 5.8
  TOP w0.254: U6207.6 47.06,87.67 47.25,87.87 47.25,88.13 47.06,88.32 U6207.5 45.26,88.32 44.96,88.62 v2(44.96,89.07)
  TOP w0.305: v2(44.96,89.07) 44.96,90.17 R9489.2
N43555147: length 5.9
  TOP w0.108: v2(191.1,86.4) 190.82,86.12 189.52,86.12 188.99,86.65 R9567.2 R9569.2 188.73,87.87 187.29,87.87 187.18,87.76 U45.5
N43938385: length 17.5
  TOP w0.108: v2(25.74,92.34) 25.74,92.08 ; 25.74,92.08 24.87,92.08 v1(24.24,91.45) ; 25.74,92.08 26.07,92.08 26.9,92.91 28.04,92.91 28.51,93.38 28.51,93.92 R9483.1
  IN4 w0.089: v1(24.95,98.54) 24.55,98.94 24.03,98.94 23.68,98.6 23.68,98.28 23.51,98.11 23.51,92.49 24.24,91.76 v1(24.24,91.45)
  BOTTOM w0.108: v1(24.95,98.54) 24.79,98.54 24.38,98.13 24.04,98.13 23.8,97.89 U6204.16
N43939053: length 15.7
  TOP w0.108: 28.43,93 28.13,92.7 27,92.7 26.16,91.86 25.26,91.86 v1(24.85,91.45) ; 28.43,93 28.72,93.29 28.72,94 R9486.1 ; 28.43,93 v2(28.61,92.83)
  IN4 w0.089: v1(24.19,98.54) 23.68,98.03 23.68,92.57 24.19,92.06 24.57,92.06 24.85,91.78 v1(24.85,91.45)
  BOTTOM w0.108: v1(24.19,98.54) 23.93,98.54 23.3,97.91 U6204.15
N44940275: length 2.2
  TOP w0.108: R9681.1 272.91,48.45 272.79,48.57 C9957.2 272.79,50.04 v2(272.73,50.1)
N45563838: length 15
  TOP w0.254: v1(44.79,131.99) v2(45.38,131.41) 45.96,130.82 R152.1
  IN1 w0.254: v1(44.79,131.99) 43.78,130.98 41.31,130.98 40.6,131.69 39.74,131.69 v1(39.25,132.17)
  BOTTOM w0.254: Q217.3 36.59,133.56 37.78,132.37 39.05,132.37 v1(39.25,132.17)
N45978292: length 4.9
  BOTTOM w0.108: C9430.1 49.31,93.69 49.57,93.69 49.79,93.92 50.25,93.92 U9.5 50.25,94.37 49.87,94.37 49.62,94.63 49.62,96.36 v2(49.9,96.64)
N46095567: length 1.6
  TOP w0.508: v2(67.62,141.31) PC5730.1
N46457457: length 4.1
  BOTTOM w0.108: JHS1.8 170.28,31.27 170.19,31.36 170.19,32.27 170.52,32.6 PR5223.1 PR5264.1
N46458274: length 30.4
  TOP w0.254: R403.1 247.99,60.8 248.43,61.24 248.43,62.06 247.66,62.83 246.95,62.83 v1(246.54,63.23)
  TOP w0.305: R9687.2 226.53,65.57 v1(226.45,65.65) ; 248.43,62.06 248.62,62.24 250.3,62.24 251.15,61.4 Q4215.2
  IN1 w0.305: v1(226.45,65.65) 227.65,66.84 242.14,66.84 245.75,63.23 v1(246.54,63.23)
N46579745: length 35.5
  TOP w0.108: U38.A57 228.14,56.38 v1(227.97,56.55) ; v1(247.87,52.19) 247.87,51.24 248.42,50.69 R9690.2 R9689.1
  IN1 w0.089: v1(252.31,56.66) 252.14,56.48 240.87,56.48 240.12,57.23 229.62,57.23 228.94,56.55 v1(227.97,56.55)
  IN2 w0.089: v1(247.87,52.19) 248.27,52.19 249.97,53.9 249.97,54.96 251.67,56.66 v1(252.31,56.66)
N46586336: length 4.8
  TOP w0.108: RC624.2 124.19,67.27 123.95,67.03 UC14.4 123.17,67.39 122.35,67.39 121.67,68.07 U6222.4
N46649947: length 6
  TOP w0.254: v1(50.02,89.35) 50.56,89.35 51.35,88.55 R9488.2 51.35,87.53 v2(51.01,87.19)
  BOTTOM w0.254: U6223.4 50.7,87.35 R9683.1 v1(50.02,89.35)
N46651989: length 10.3
  BOTTOM w0.108: R9691.2 49.57,90.51 47.33,90.51 45.98,91.86 45.98,93.18 v2(45.71,93.46)
  BOTTOM w0.254: U6223.5 51.73,88 51.9,88.18 51.9,88.46 51.71,88.65 U6223.6 50.97,88.65 50.51,89.12 50.51,89.57 R9691.2
N46939475:
  vias: v1(191.53,22.19) v2(189.9,22.21)
N46939509: length 7.7
  BOTTOM w0.254: v2(184.26,23.56) 185.05,24.35 PR7402.2 PC7405.2
  vias: v1(184.91,22.19)
N46939750: length 3.6
  BOTTOM w0.254: 191.63,23.48 PR7402.1 191.81,24.52 192.72,24.52 PR7401.2 PR7403.1
N46967671:
  vias: v1(193.86,22.19) v2(193.23,22.21)
N47034159: length 1.5
  TOP w0.254: PU7401.7 194.95,24.04 195.41,24.5 PC7406.1
N47099764: length 1.5
  TOP w0.254: PR7408.1 183.32,25.69 183.6,25.41 PU7402.2
N47483770: length 4.1
  BOTTOM w0.108: R9698.2 42.94,93.97 Q4216.3
N47483795: length 11.5
  BOTTOM w0.108: R9698.1 43.98,94.15 R9697.1 45.22,94.6 47.43,94.6 47.97,94.07 47.97,93.23 47.69,92.95 47.69,91.81 48.09,91.4 50.43,91.4 50.63,91.2 50.61,91.17 50.61,90.54 50.78,90.37 D21.1

## Copper pours and planes (outline as drawn)
3V_BST2_1 on TOP (solid shape): 197.17,58.66 197.17,58.28 197.04,58.15 195.26,58.15 195.13,58.28 195.13,58.66 195.26,58.79 197.04,58.79
3V_BST2_2 on TOP (solid shape): 196.4,62.01 196.4,61 197.22,60.19 197.22,59.63 197.17,59.58 196.28,59.58 196.2,59.65 196.2,62.01 196.23,62.04 196.38,62.04
3V_HG on TOP (solid shape): 192.82,58.76 192.82,57.16 192.77,57.11 192.26,57.11 192.14,57.24 192.14,58.84 192.17,58.87 192.71,58.87
3V_HG on TOP (solid shape): 196.78,62.01 196.78,61.41 196.89,61.3 197.72,61.3 197.9,61.13 197.9,60.77 197.7,60.57 197.17,60.57 196.61,61.13 196.61,62.01 196.63,62.04 196.76,62.04
3V_LG on TOP (solid shape): 192.8,52.06 192.8,50.67 192.41,50.28 192.24,50.28 192.01,50.51 192.01,50.84 192.14,50.97 192.14,52.08 192.77,52.08
3V_LG on TOP (solid shape): 199.07,61.13 199.07,60.74 198.92,60.59 198.49,60.59 198.31,60.77 198.31,61.13 197.72,61.71 197.72,62.14 197.65,62.22 196.99,62.22 196.96,62.24 196.96,62.37 196.99,62.4 197.8,62.4
3V_SW on TOP (solid shape): 196,62.01 196,59.17 195.87,59.04 195.11,59.04 194.93,58.87 194.93,57.9 197.68,57.9 197.77,57.89 197.86,57.89 198.26,57.49 198.26,51.12 196.78,49.65 193.61,49.65 193.48,49.52 193.48,48.12 193.36,47.99 192.21,47.99 192.09,48.12 192.09,49.24 193.3,50.46 193.3,52.82 193.05,53.07 188.78,53.07 188.53,53.33 188.53,54.85 188.78,55.11 192.85,55.11 193.74,56 193.74,58.64 194.4,59.3 194.4,59.53 195.08,60.21 195.08,60.62 195.79,61.33 195.79,62.01 195.82,62.04 195.97,62.04
5V_BST1_1 on TOP (solid shape): 196.25,68.72 196.25,67.96 196.35,67.86 196.71,67.86 196.71,67.32 196.68,67.3 194.83,67.3 194.73,67.4 194.73,67.83 194.75,67.86 195.39,67.86 195.54,68.01 195.54,68.72 195.69,68.87 196.1,68.87
5V_BST1_2 on TOP (solid shape): 196.91,66.33 196.91,65.88 196.49,65.46 196.4,65.27 196.4,64.2 196.38,64.17 196.23,64.17 196.2,64.2 196.2,64.76 195.84,65.98 195.84,66.49 196.76,66.49
5V_HG on TOP (solid shape): 197.42,65.25 197.42,65.06 197.09,64.73 197.09,64.61 196.73,64.25 196.61,64.25 196.61,65.27 196.87,65.53 197.14,65.53
5V_HG on TOP (solid shape): 184.21,70.28 184.67,70.28 184.71,70.24 184.71,69.86 184.67,69.82 183.1,69.82 182.84,69.57 182.84,68.98 182.65,68.8 182.33,68.8 182.19,68.94 182.19,69.95 182.64,70.4 184.09,70.4
5V_LG on TOP (solid shape): 189.32,69.65 189.32,68.94 189.16,68.78 188.81,68.78 188.63,68.96 188.63,69.34 188.15,69.83 187.16,69.83 187.06,69.93 187.06,70.21 187.13,70.28 188.68,70.28
5V_LG on TOP (solid shape): 198.13,64.55 198.13,64.22 197.72,63.82 197.01,63.82 196.96,63.87 196.96,63.97 197,64.01 197.1,64.01 197.57,64.48 197.57,64.61 197.74,64.77 197.92,64.77
5V_SW on TOP (solid shape): 195.67,67.02 195.67,65.76 196,64.94 196,64.2 195.97,64.17 195.82,64.17 195.79,64.2 195.79,64.81 195.24,65.37 194.78,65.37 194.55,65.6 194.55,67.04 194.68,67.17 195.51,67.17
5V_SW on TOP (solid shape): 190.94,74.16 190.94,73.14 190.82,73.01 189.42,73.01 189.29,72.89 189.29,70.98 188.91,70.6 186.88,70.6 186.75,70.47 186.75,68.06 186.62,67.93 185.99,67.93 185.86,68.06 185.86,74.03 186.12,74.28 190.82,74.28
5V_SW on BOTTOM (solid shape): 191.32,77.69 191.32,69.99 191.04,69.71 186.24,69.71 186.07,69.89 186.07,73.57 187.16,74.66 187.16,77.66 188.02,78.52 190.49,78.52
5V_SW on IN2 (solid shape): 195.62,67.15 195.62,66.69 195.46,66.54 194.5,66.54 194.37,66.66 194.37,67.3 194.5,67.43 195.34,67.43
+0.6V_DDR_VTT on TOP (solid shape): 93.41,59.42 93.41,54.73 93.66,54.47 93.66,51.93 93.41,51.68 92.39,51.68 92.14,51.93 92.14,54.22 91.88,54.47 91.88,57.14 91.12,57.9 91.12,59.42 91.25,59.55 93.28,59.55
+0.6V_DDR_VTT on TOP (solid shape): 149.77,27.67 149.77,26.52 148.89,25.64 148.89,24.76 148.04,23.91 141.04,23.91 140.9,24.04 140.9,24.75 140.96,24.8 143.57,24.8 143.67,24.91 147.84,24.91 147.97,25.03 147.97,25.72 148.65,26.4 148.65,27.45 149.11,27.9 149.54,27.9
+0.6V_DDR_VTT on TOP (solid shape): 149.81,40.61 149.81,40.15 149.66,39.99 149.06,39.99 148.58,39.51 148.19,39.51 148.09,39.41 148.09,38.75 147.99,38.65 145.96,38.65 145.71,38.9 145.71,39.99 145.58,40.12 145.17,40.12 144.49,40.12 144.44,40.17 144.44,40.73 144.46,40.76 149.67,40.76
+0.6V_DDR_VTT on BOTTOM (solid shape): 92.57,59.68 92.57,57.82 92.24,57.49 90.74,57.49 90.54,57.7 90.51,57.7 90.51,59.68 90.71,59.88 92.37,59.88
+0.6V_DDR_VTT on BOTTOM (solid shape): 149.76,40.61 149.76,40.02 149.35,39.61 148.45,39.61 148.31,39.75 147.78,39.75 147.66,39.64 147.66,37.65 147.64,37.63 147.39,37.63 147.37,37.64 147.37,40.34 147.76,40.73 149.64,40.73
+0.6V_DDR_VTT on BOTTOM (solid shape): 149.72,27.95 149.72,27.29 149.24,26.81 149.24,26.35 148.64,25.76 148.64,24.1 148.46,23.92 147.61,23.92 147.38,24.14 147.38,26.39 147.66,26.39 147.66,24.26 147.74,24.19 147.74,24.18 147.75,24.17 148.29,24.17 148.34,24.22 148.34,26.23 148.37,26.24 148.42,26.26 148.47,26.28 148.51,26.32 148.55,26.36 148.58,26.4 148.61,26.45 148.63,26.5 148.64,26.55 148.64,26.61 148.64,26.66 148.63,26.72 148.61,26.77 148.58,26.81 148.55,26.86 148.51,26.9 148.47,26.93 148.42,26.96 148.37,26.97 148.31,26.99 148.26,26.99 148.2,26.99 148.15,26.97 148.1,26.95 148.05,26.93 148.01,26.89 147.97,26.85 147.94,26.81 147.91,26.76 147.89,26.71 147.88,26.66 147.88,26.61 147.74,26.47 147.74,26.47 147.66,26.39 147.38,26.39 147.38,27.22 147.38,27.22 147.38,27.67 147.76,28.06 149.62,28.06
+0.6V_DDR_VTT on IN2 (solid shape): 93.17,59.65 93.17,57.8 92.84,57.47 91.34,57.47 91.11,57.7 91.11,59.65 91.31,59.86 92.96,59.86
+0.6V_DDR_VTT on IN2 (solid shape): outline of 734 points within 139.56,36.82 150.28,48.78
+0.6V_DDR_VTT on IN3 (solid shape): outline of 218 points within 147.39,27.04 151.06,40.86
+0.6V_DDR_VTTP on TOP (solid shape): 91.88,54.09 91.88,51.3 92.14,51.04 92.14,50.53 92.01,50.41 87.77,50.41 87.18,51 87.12,51.07 87.04,51.14 86.93,51.25 86.29,51.25 85.94,51.6 85.66,51.6 85.66,52.13 85.69,52.16 86.7,52.16 86.75,52.21 86.75,52.69 86.73,52.72 86.04,52.72 86.02,52.74 86.02,52.9 86.04,52.92 86.85,52.92 87.05,52.72 87.09,52.68 87.14,52.64 87.97,51.8 90.61,51.8 90.61,54.09 90.74,54.22 91.76,54.22
+0.9V_LAN on TOP (solid shape): 143.32,139.1 143.32,138.72 143.24,138.65 143.01,138.65 142.17,137.81 142.17,135.63 142.17,135.62 142.15,135.49 142.17,135.36 142.17,135.35 142.17,134.61 142.35,134.43 143.44,134.43 143.93,133.95 143.93,133.26 143.6,132.93 143.37,132.93 143.17,133.13 143.17,134.18 143.09,134.25 142.17,134.25 141.57,134.86 141.57,136.06 141.13,136.49 141.13,138.29 142.25,139.41 143.01,139.41
+0.9V_LAN on BOTTOM (solid shape): 144.87,138.6 144.87,135.93 144.28,135.35 144.23,135.35 143.95,135.07 143.95,133.49 143.95,133.48 143.93,133.34 143.95,133.2 143.95,133.19 143.95,131.1 143.95,131.09 143.93,130.95 143.95,130.81 143.95,130.8 143.95,130.72 143.79,130.56 143.69,130.54 143.62,130.51 143.44,130.5 143.31,130.6 143.01,130.9 143.01,131.94 142.33,132.63 142.33,134.89 142.42,134.98 142.8,134.98 143.08,135.26 143.08,137.69 143.12,137.69 143.25,137.74 143.36,137.83 143.4,137.88 143.48,137.93 143.57,137.88 144.28,138.03 143.63,138.34 143.34,138.34 143.15,138.44 142.93,138.43 142.71,138.65 142.71,139 142.91,139.21 144.26,139.21
+0.9V_LAN on IN1 (solid shape): outline of 369 points within 142.48,124.45 148.14,134.1
+1.0V_MPHYGT on TOP (solid shape): 157.08,111.44 157.08,110.78 156.98,110.68 156.12,110.68 155.69,111.11 153.35,111.11 152.21,112.26 150.81,112.26 150.68,112.38 150.68,116.07 150.81,116.19 152.33,116.19
+1.0V_MPHYGT on TOP (solid shape): 183.96,88.66 184.92,88.66 184.95,88.63 184.95,88.51 184.92,88.48 184.16,88.48 184.14,88.46 184.14,88.28 184.16,88.25 184.92,88.25 184.95,88.23 184.95,88.1 184.92,88.08 184.16,88.08 183.58,87.49 182.69,87.49 182.56,87.62 182.56,88 182.57,88.01 182.57,88.16 182.87,88.46 182.87,89.07 183.55,89.07
+1.0V_MPHYGT on BOTTOM (solid shape): 129.49,96.23 129.72,96.13 129.94,96.23 130.22,96.23 130.32,96.12 130.32,95.98 130.3,95.94 130.27,95.89 130.23,95.85 130.23,95.39 129.88,95.04 129.88,94.7 129.78,94.6 129.64,94.6 129.63,94.61 129.41,94.69 129.19,94.6 129.01,94.6 128.63,94.98 128.63,94.98 128.49,95.06 128.33,95.05 128.31,95.05 128.25,95.02 128.19,94.97 127.99,94.97 127.96,95 127.86,95.1 127.86,95.26 127.86,95.3 127.89,95.32 127.99,95.39 128.06,95.5 128.06,95.51 128.34,95.79 128.9,95.79 128.97,95.86 129.3,96.2 129.35,96.23
+1.0V_MPHYGT on IN1 (solid shape): 154.75,113.4 154.75,111.44 154.29,110.99 147.48,110.99 147.03,111.44 147.03,112.92 147.64,113.53 154.62,113.53
+1.0V_MPHYGT on IN2 (solid shape): 183.98,88.56 183.98,87.34 183.65,87.01 181.7,87.01 181.57,87.14 181.57,88.63 181.7,88.76 183.78,88.76
+1.0V_MPHYGT on IN2 (solid shape): 156.02,113.53 156.02,112.51 155.64,112.13 153.1,112.13 152.72,112.51 152.72,113.91 152.97,114.16 155.38,114.16
+1.0V_MPHYGT on IN2 (solid shape): outline of 101 points within 173.9,105.73 178.04,108.05
+1.0V_MPHYGT on IN3 (solid shape): outline of 1256 points within 127.62,94.6 149.64,113.07
+1.0V_PRIM on TOP (solid shape): 188.25,92.7 188.25,92.27 186.29,92.27 186.27,92.29 186.27,92.44 187.11,92.44 187.13,92.47 187.13,92.67 187.11,92.7 186.27,92.7 186.27,92.85 186.29,92.88 188.07,92.88
+1.0V_PRIM on TOP (solid shape): 187.72,90.77 188.1,90.77 188.25,90.62 188.25,88.25 188.07,88.08 186.32,88.08 186.27,88.13 186.27,88.25 187.03,88.25 187.08,88.3 187.08,88.46 187.06,88.48 186.29,88.48 186.27,88.51 186.27,90.41 187.11,90.41 187.13,90.44 187.13,90.64 187.11,90.67 186.27,90.67 186.27,90.79 186.32,90.84 187.64,90.84
+1.0V_PRIM on TOP (solid shape): 150.28,116.22 150.28,114.08 150.38,113.98 150.38,108.75 149.97,108.34 148.42,108.34 148.14,108.62 148.14,112.02 148.42,112.45 148.02,112.76 148,112.78 148.02,112.91 147.99,113.03 147.99,114.31 147.76,114.54 144.31,114.54 144.23,114.57 144.21,114.65 144.21,114.68 144.2,114.72 143.83,115.15 143.45,114.72 143.44,114.68 143.44,114.65 143.42,114.57 143.34,114.54 141.16,114.54 141.07,114.63 141.07,115.18 141.2,115.3 142.17,115.3 142.3,115.43 142.3,117.34 142.43,117.46 149.03,117.46
+1.0V_PRIM on IN1 (solid shape): outline of 3630 points within 124.9,90.67 149.41,110.22
+1.0V_PRIM on IN2 (solid shape): 149.54,117.08 149.54,115.46 149.49,115.41 148.27,115.41 148.26,115.42 147.07,115.42 146.87,115.61 146.87,117.08 147,117.21 149.41,117.21
+1.0V_PRIM on IN2 (solid shape): 187.67,93.23 187.67,91.92 187.62,91.84 187.53,91.83 187.03,91.43 187.6,91.13 187.67,91.14 187.73,91.09 187.73,88.39 187.44,88.1 186.12,88.1 185.89,88.33 185.89,93.16 186.09,93.36 187.54,93.36
+1.0V_PRIM_CORE on TOP (solid shape): 152.31,111.47 152.31,108.75 152.03,108.47 151.27,108.47 150.76,108.98 150.76,111.75 150.89,111.88 151.9,111.88
+1.0V_PRIM_CORE on TOP (solid shape): 126.43,92.95 126.43,92.7 126.3,92.57 124.52,92.57 124.39,92.7 124.39,92.95 124.52,93.08 126.3,93.08
+1.0V_PRIM_CORE on BOTTOM (solid shape): 171.61,92.8 175.6,92.8 175.69,92.71 175.69,90.98 175.6,90.89 171.26,90.89 170.98,91.17 170.19,91.17 170.11,91.18 170.04,91.17 169.61,91.17 169.4,91.38 169.4,92.75 169.61,92.95 171.46,92.95
+1.0V_PRIM_CORE on BOTTOM (solid shape): 127.21,89.88 127.24,89.86 127.26,89.84 127.44,89.75 127.63,89.84 127.65,89.86 127.67,89.88 127.82,89.88 127.93,89.78 127.93,89.65 127.88,89.59 127.81,89.56 127.76,89.54 127.65,89.43 127.67,89.34 127.67,89.27 127.65,89.2 127.54,89.09 127.5,89.07 127.44,89.07 127.36,89.08 127.28,89.13 127.13,89.19 126.97,89.13 126.94,89.11 126.88,89.08 126.81,89.07 126.8,89.07 126.64,89.14 126.58,89.32 126.58,89.36 126.57,89.4 126.56,89.43 126.65,89.51 126.68,89.55 126.91,89.78 126.95,89.81 127,89.86 127.02,89.88
+1.0V_PRIM_CORE on VCC (solid shape): 152.46,109.79 152.46,101.26 151.23,100.03 151.2,99.99 151.19,99.94 151.19,89.83 149.32,87.96 149.3,87.92 149.29,87.87 148.78,87.36 142.99,87.36 142.65,87.71 142.6,87.74 142.56,87.75 142.05,87.75 142,87.74 141.96,87.71 141.61,87.36 124.98,87.36 124.52,87.82 124.52,88.45 124.87,88.8 124.89,88.84 124.9,88.89 124.9,94.04 125.46,94.6 129.98,94.6 130.03,94.61 130.07,94.64 130.58,95.15 130.61,95.19 130.62,95.24 130.62,96.46 131.6,97.43 131.62,97.48 131.63,97.52 131.63,106.16 131.62,106.21 131.6,106.25 131.25,106.59 131.25,106.87 131.6,107.21 131.62,107.25 131.63,107.3 131.63,109.82 132.04,110.22 152.03,110.22
+1.0V_PRIM_CORE on IN2 (solid shape): outline of 3478 points within 124.75,87.24 171.26,98.79
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 902 points within 124.99,89.22 131.25,94.2
+1.0V_PRIM_COREP on BOTTOM (solid shape): 175.07,97.52 175.07,95.11 175.19,94.98 175.45,94.98 175.46,94.97 176.33,94.97 176.49,94.81 176.49,93.64 175.91,93.05 171.92,93.05 171.38,93.59 171.38,94.22 171.13,94.48 170.37,94.48 170.19,94.65 170.19,95.29 170.04,95.44 170.04,96.78 170.9,97.65 174.94,97.65
+1.0V_PRIM_XDP on BOTTOM (solid shape): 79.44,118.15 79.44,115.99 80.12,115.3 80.12,113.25 80.02,113.15 79.56,113.15 79.51,113.2 79.51,115.38 79.16,115.74 79.16,118.15 79.23,118.23 79.36,118.23
+1.0V_RUN on TOP (solid shape): 71.64,130.26 71.64,129.15 70.72,128.23 69.23,128.23 68.79,128.66 68.79,130.67 71.23,130.67
+1.0V_RUN on TOP (solid shape): 93.03,116.35 93.03,114.42 92.68,114.42 92.54,114.44 92.4,114.42 92.05,114.42 91.91,114.44 91.77,114.42 90.46,114.42 90.36,114.31 90.36,113.78 89.7,113.12 89.7,111.95 89.62,111.88 88.96,111.88 88.25,112.59 88.25,113.45 88.71,113.91 88.71,116.02 89.09,116.4 92.97,116.4
+1.0V_RUN on BOTTOM (solid shape): 71.21,130.67 71.21,129.4 70.22,128.41 69.1,128.41 68.13,129.38 68.13,130.44 68.46,130.77 71.11,130.77
+1.0V_RUN on BOTTOM (solid shape): 86.37,137.99 86.37,135.75 86.21,135.59 85.82,135.59 85.41,136 85.18,136 84.9,136.28 84.9,137.18 85.79,138.07 86.3,138.07
+1.0V_RUN on IN2 (solid shape): outline of 802 points within 81.44,114.31 91.88,136.98
+1.0V_RUN on IN3 (solid shape): outline of 1182 points within 69.48,128.11 86.65,139.4
+1.0V_RUN_VMM on TOP (solid shape): 95.69,116.47 95.69,112.01 95.08,111.4 92,111.4 91.89,111.51 91.89,112.86 93.32,114.29 93.32,116.84 93.48,117.01 95.16,117.01
+1.0V_RUN_VMM on BOTTOM (solid shape): 93.38,126.64 93.38,125.78 92.43,124.83 92.41,124.83 92.11,124.38 92.55,124.07 92.58,124.08 92.67,123.99 92.67,122.77 92.39,122.49 91.78,122.49 91.73,122.5 91.65,122.49 91.12,123.03 91.12,123.99 91.1,124.02 91.1,126.96 91.24,127.1 92.92,127.1
+1.0V_RUN_VMM on IN2 (solid shape): outline of 433 points within 91.1,114.39 95.9,126.68
+1.0V_RUN_VMM_LX on TOP (solid shape): 70.62,139.26 70.62,137.28 70.5,137.15 69,137.15 68.64,136.79 68.64,136.18 68.41,136.18 68.38,136.22 68.38,138 68.46,138.09 69.25,138.09 69.56,138.39 69.56,139.1 69.81,139.36 70.52,139.36
+1.0V_RUN_VMM_VIN on TOP (solid shape): 68.64,134.29 68.93,134 68.93,133.33 68.48,131.82 68.48,128.11 67.42,127.05 67.42,126.28 66.99,125.86 66.23,125.86 66.1,125.98 66.1,128.28 66.99,129.17 66.99,133.1 67.27,133.38 67.75,133.38 68.15,133.85 68.41,134.49 68.41,134.8 68.64,134.8
+1.0V_RUNP on TOP (solid shape): 73.95,139.15 73.95,136.31 73.01,135.37 73.01,134.23 71.13,132.35 71.13,131.18 68.95,131.18 68.72,131.41 68.72,131.94 69.35,133.08 69.63,133.36 70.19,133.36 70.41,133.58 70.41,133.91 71.07,134.57 71.07,136.81 71.44,137.17 71.44,139.28 71.59,139.43 73.67,139.43
+1.0V_RUNP on BOTTOM (solid shape): 71.13,133.62 71.13,131.53 70.78,131.18 67.8,131.18 67.39,131.59 67.39,133.89 67.57,134.07 70.67,134.07
+1.0V_SRAM on TOP (solid shape): 126.43,94.6 126.43,94.22 127.06,93.59 127.06,93.46 126.93,93.33 124.52,93.33 124.39,93.46 124.39,93.97 124.52,94.1 125.03,94.1 125.66,94.73 126.3,94.73
+1.0V_VCCST on TOP (solid shape): 184.95,90.82 184.95,90.69 184.92,90.67 184.16,90.67 184.14,90.64 184.14,90.46 184.16,90.44 184.92,90.44 184.95,90.41 184.95,90.29 184.92,90.26 184.16,90.26 184.01,90.11 184.01,89.83 183.78,89.6 182.66,89.6 182.59,89.68 182.59,90.23 183.2,90.84 184.92,90.84
+1.0V_VMM_VDD on TOP (solid shape): 87.28,130.52 87.39,130.39 87.54,130.33 87.55,130.33 87.65,130.23 87.69,130.16 87.74,130.11 87.74,129.91 87.63,129.68 87.74,129.46 87.74,129.26 87.63,129.03 87.74,128.81 87.74,128.61 87.67,128.52 87.63,128.42 87.63,128.4 87.44,128.21 87.23,128.21 87.14,128.31 87.03,128.37 87.01,128.38 86.9,128.49 86.9,130.37 87.06,130.52
+1.0V_VMM_VDD on TOP (solid shape): 89.46,130.4 89.46,129.62 89.53,129.54 89.57,129.48 89.61,129.43 89.64,129.36 89.61,129.29 89.57,129.24 89.53,129.17 89.47,129.11 89.45,129.11 89.18,128.91 89.15,128.57 89.34,128.38 89.34,128.29 89.3,128.25 89.06,128.25 88.92,128.39 88.91,128.41 88.88,128.53 88.81,128.64 88.78,128.71 88.92,129.03 88.78,129.36 88.92,129.68 88.78,130.01 88.81,130.08 88.88,130.18 88.91,130.29 89.07,130.35 89.19,130.48 89.37,130.48
+1.0V_VMM_VDD on TOP (solid shape): 89.63,132.78 89.86,132.65 90.09,132.78 90.28,132.78 90.31,132.73 90.36,132.7 90.38,132.68 90.38,132.54 90.36,132.52 90.3,132.47 90.25,132.4 90.25,132.39 90.15,132.29 90.13,132.29 89.95,132.19 89.86,132.01 89.85,132 89.75,131.89 89.74,131.89 89.67,131.84 89.61,131.76 89.6,131.74 89.47,131.74 89.46,131.76 89.3,131.9 89.1,131.89 89.09,131.89 88.68,131.89 88.56,131.91 88.44,131.89 88.1,131.89 88.07,131.92 88.07,132.02 88.12,132.07 88.38,132.07 88.55,132 88.73,132.06 88.78,132.11 88.82,132.18 88.92,132.28 88.94,132.28 89.12,132.37 89.21,132.56 89.21,132.57 89.31,132.67 89.32,132.68 89.39,132.72 89.44,132.78
+1.0V_VMM_VDD on BOTTOM (solid shape): 91.65,133.54 91.65,132.45 91.58,132.37 89.67,132.37 89.59,132.41 89.51,132.42 89.49,132.42 89.37,132.55 89.37,132.75 89.55,132.93 89.57,132.93 89.57,132.96 89.6,132.98 89.6,133.64 89.67,133.72 91.48,133.72
+1.0V_VMM_VDD on BOTTOM (solid shape): outline of 235 points within 86.65,124.4 92.11,130.34
+1.0V_VMM_VDD on IN2 (solid shape): outline of 537 points within 87.07,125.9 91.86,133.21
+1.0V_VMM_VDD on IN4 (solid shape): outline of 875 points within 85.63,125.53 90.89,133.06
+1.0V_VMM_VDDLP on BOTTOM (solid shape): 87.69,138.9 87.69,132.54 87.53,132.37 86.75,132.37 86.6,132.52 86.6,132.7 86.5,132.86 86.47,132.93 86.5,133.01 86.6,133.34 86.35,133.58 86.31,133.59 86.31,135.24 86.55,135.48 86.55,138.6 87.01,139.05 87.54,139.05
+1.0V_VMM_VDDTX on TOP (solid shape): 86.22,128.94 86.22,128.41 86.35,128.28 86.35,128.27 86.41,128.19 86.5,128.13 86.51,128.12 86.6,128.02 86.61,128.01 86.65,127.89 86.73,127.8 86.73,127.6 86.68,127.55 85.86,127.55 85.57,127.84 85.56,127.88 85.51,127.93 85.51,128.13 85.62,128.24 85.62,128.88 85.82,129.08 85.86,129.11 85.9,129.16 86.01,129.16
+1.0V_VMM_VDDTX on BOTTOM (solid shape): 86.37,128.13 86.37,127.17 86.31,127.1 85.65,127.1 85.63,127.09 85.52,127.07 85.42,127.01 84.97,127.01 84.77,127.22 84.77,127.7 84.8,127.72 85.38,127.72 85.46,127.8 85.46,128.18 85.51,128.23 86.27,128.23
+1.0V_VMM_VDDTX on BOTTOM (solid shape): 89.86,126.19 89.86,126.16 89.87,126 89.97,125.86 90.13,125.69 90.43,125.69 90.77,125.36 90.77,124.12 90.71,124.07 89.22,124.07 88.89,124.4 88.89,125.36 88.69,125.55 88.69,126.16 88.86,126.33 89.72,126.33
+1.0V_VMM_VDDTX on IN1 (solid shape): outline of 934 points within 84.21,125.85 90.87,133.69
+1.0VS_VCCIO on TOP (solid shape): outline of 89 points within 109.66,85.92 123,90.92
+1.0VS_VCCIO on BOTTOM (solid shape): 171.5,90.37 171.5,87.9 171.36,87.76 171.36,85.79 171.16,85.59 169.48,85.59 169.35,85.71 169.35,90.79 169.56,91 170.88,91
+1.0VS_VCCIO on BOTTOM (solid shape): 122.11,87.87 122.11,87.75 121.65,87.29 121.65,87.11 121.65,87.1 121.61,86.94 121.65,86.79 121.65,86.78 121.65,86.44 121.32,86.11 121.32,86.1 121.24,86.05 121.18,85.98 120.81,85.98 120.76,86.04 120.69,86.08 120.68,86.09 120.46,86.31 120.46,87.63 120.83,88 121.98,88
+1.0VS_VCCIO on BOTTOM (solid shape): 114.84,86.96 114.84,86.66 114.76,86.45 114.84,86.24 114.84,86.04 114.69,85.89 114.51,85.89 114.38,86.02 114.37,86.04 114.34,86.07 114.3,86.07 114.29,86.07 114.13,86.1 113.97,86.05 113.96,86.04 113.93,86.04 113.9,85.97 113.86,85.93 113.82,85.89 113.6,85.89 113.52,85.97 113.52,86.22 114.39,87.08 114.72,87.08
+1.0VS_VCCIO on IN2 (solid shape): 80.2,94.73 80.2,93.71 79.94,93.46 78.8,93.46 78.67,93.59 78.67,94.73 78.93,94.98 79.94,94.98
+1.0VS_VCCIO on IN2 (solid shape): outline of 95 points within 87.74,103.18 91.25,106.3
+1.0VS_VCCIO on IN2 (solid shape): outline of 12887 points within 86.68,76.92 171.13,91.43
+1.0VS_VCCIO on IN4 (solid shape): 87.18,86.48 87.18,85.59 87.06,85.46 86.17,85.46 86.04,85.59 86.04,86.48 86.17,86.6 87.06,86.6
+1.2V_MEM on TOP (solid shape): 112.44,27.84 112.44,26.54 112.08,26.18 111.8,26.18 111.48,26.49 111.48,27.84 111.52,27.88 112.41,27.88
+1.2V_MEM on TOP (solid shape): 120.28,68.16 120.28,67.09 120.41,66.97 121.35,66.97 121.63,66.69 122.31,66.69 122.49,66.51 122.87,66.51 122.97,66.41 122.97,66.08 122.9,66 121.58,66 121.3,65.72 118.98,65.72 118.68,66.03 118.68,66.54 120.46,66.54 120.46,66.36 120.51,66.31 121.14,66.31 121.19,66.36 121.19,66.54 121.14,66.59 120.51,66.59 120.46,66.54 118.68,66.54 118.68,68.11 118.88,68.31 120.13,68.31
+1.2V_MEM on TOP (solid shape): outline of 15602 points within 80.81,23.91 143.61,83.94
+1.2V_MEN_P on TOP (solid shape): 90.33,49.9 90.33,47.46 90.21,47.33 88.73,47.33 88.45,47.61 88.45,49.72 88.78,50.05 90.18,50.05
+1.2V_MEN_P on TOP (solid shape): 89.65,55.11 89.65,54.75 89.27,54.37 88.86,54.37 88.61,54.12 88.43,54.12 88.17,54.37 87.44,54.37 87.03,53.96 86.02,53.96 86.02,54.06 86.09,54.14 86.4,54.14 87.51,55.26 89.5,55.26
+1.2V_MEN_P on TOP (solid shape): 93.79,76.7 93.79,70.22 95.31,68.7 95.31,64.25 95.06,64 88.71,64 87.88,64.82 87.88,69.65 86.87,70.66 80.77,70.66 80.33,71.11 80.33,76.32 81.09,77.08 93.41,77.08
+1.2VP_+VLDOIN on TOP (solid shape): 85.46,52.13 85.46,51.52 85.61,51.37 85.84,51.37 86.24,50.97 87.01,50.97 88.07,49.9 88.07,47.49 87.95,47.36 87.18,47.36 87.06,47.49 87.06,49.07 86.93,49.2 85.85,49.2 85.63,49.42 85.63,50.58 85.25,51.42 85.25,52.13 85.28,52.16 85.43,52.16
+1.2VP_B+ on TOP (solid shape): 82.74,64.76 82.74,60.82 82.87,60.69 84.01,60.69 84.14,60.57 84.14,58.54 84.01,58.41 78.55,58.41 78.29,58.66 78.29,59.81 78.37,59.88 79.97,59.88 80.15,60.06 80.15,63.44 80.58,63.87 81.6,63.87 81.72,64 81.72,64.76 81.85,64.89 82.61,64.89
+1.2VP_BOOT on TOP (solid shape): 85.05,52.13 85.05,51.42 85.46,50.53 85.46,49.29 85.33,49.16 84.82,49.16 84.69,49.29 84.69,50.13 84.85,50.28 84.85,52.13 84.87,52.16 85.02,52.16
+1.2VP_BOOT_R on TOP (solid shape): 83.93,49.92 83.93,49.29 83.81,49.16 82.28,49.16 82.15,49.29 82.15,49.92 82.28,50.05 83.81,50.05
+1.2VP_DH on TOP (solid shape): 82.31,65.55 82.31,65.26 82.08,65.03 81.48,65.03 81.37,64.91 81.37,64.48 81.32,64.43 80.78,64.43 80.73,64.48 80.73,65.2 81.33,65.79 82.06,65.79
+1.2VP_DH on IN3 (solid shape): 85.15,51.17 85.15,49.9 85.02,49.77 84.26,49.77 84.14,49.9 84.14,51.17 84.26,51.3 85.02,51.3
+1.2VP_DL on TOP (solid shape): 87.09,64.83 87.35,64.83 88.21,63.98 88.21,63.81 87.92,63.52 87.77,63.52 87.14,64.15 86.88,64.15 86.41,64.62 86.41,64.9 86.59,65.08 86.85,65.08
+1.2VP_DL on TOP (solid shape): 83.88,52.49 83.88,51.68 83.81,51.6 83.35,51.6 82.99,51.25 81.98,51.25 81.85,51.12 81.85,50.61 81.11,49.87 80.86,49.87 80.78,49.95 80.78,51.14 81.47,51.83 82.41,51.83 82.74,52.16 83.25,52.16 83.32,52.24 83.32,52.49 83.35,52.52 83.86,52.52
+1.2VP_FB on TOP (solid shape): 89.7,56.1 89.7,55.79 89.55,55.64 87.46,55.64 86.14,54.32 85.71,54.32 85.66,54.37 85.66,54.85 85.76,54.95 86.37,54.95 87.03,55.61 87.03,55.74 87.67,56.38 89.42,56.38
+1.2VP_SNUB on TOP (solid shape): 79.94,73.88 79.94,71.11 79.82,70.98 78.8,70.98 78.67,71.11 78.67,72.63 78.52,72.78 78.52,73.72 78.88,74.08 79.74,74.08
+1.2VP_SW on TOP (solid shape): 84.25,52.13 84.25,51.4 84.05,51.19 84.05,50.31 84,50.25 82.19,50.25 82.12,50.33 82.12,51.02 82.19,51.09 83.09,51.09 83.45,51.45 84,51.45 84.05,51.5 84.05,52.13 84.07,52.16 84.22,52.16
+1.2VP_SW on TOP (solid shape): 87.44,69.2 87.44,65.9 87.18,65.65 86.5,65.65 85.41,64.55 85.41,61.08 85.28,60.95 83.5,60.95 83.37,61.07 83.37,61.33 83.37,61.33 83.37,64.75 82.03,66.09 80.43,66.09 80.26,66.26 80.26,68.76 79.82,69.2 78.8,69.2 78.67,69.33 78.67,69.86 78.75,69.94 86.7,69.94
+1.2VP_SW on IN3 (solid shape): 83.63,51.17 83.63,50.15 83.5,50.03 82.61,50.03 82.33,50.31 82.33,51.07 82.56,51.3 83.5,51.3
+1.2VP_VDD on TOP (solid shape): 83.17,54.88 83.17,54.17 83.22,54.12 83.86,54.12 83.88,54.09 83.88,53.96 83.86,53.94 82.84,53.94 82.66,54.12 81.06,54.12 80.71,54.47 79.36,54.47 79.23,54.6 79.23,55 79.36,55.13 82.92,55.13
