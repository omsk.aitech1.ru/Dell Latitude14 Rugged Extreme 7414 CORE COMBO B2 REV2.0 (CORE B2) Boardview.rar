# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3.3V_WWAN_EN: length 270.6
  TOP w0.108: v2(60.08,123.69) v1(59.45,123.69) ; v1(260.67,56.88) 261.12,57.34 261.12,57.62 260.78,57.96 U37.B42
  IN2 w0.089: v1(260.67,56.88) 259.78,56 259.78,49.46 259.41,49.09 257.15,49.09 256.86,49.38 256.86,50.13 256.39,50.6 253.89,50.6 253.68,50.39 252.9,50.39 251.95,49.44 232.38,49.44 232.15,49.21 229.37,49.21 227.93,47.77 207.2,47.77 203.98,50.98 196.64,50.98 194.12,48.47 190.93,48.47 190.17,47.71 184.43,47.71 180.73,51.41 180.73,55.74 178.95,57.52 177.43,57.52 174.99,59.96 172.51,59.96 170.59,61.88 170.06,61.88 169.33,62.62 169.33,62.7 166.96,65.06 158.25,65.06 156.41,66.91 148.74,66.91 146.58,64.75 144.95,64.75 143.12,62.91 135.4,62.91 133.61,64.7 118.01,64.7 117.39,64.08 107.57,64.08 86.09,85.56 86.09,86.18 82.1,90.17 74.9,90.17 73.24,91.83 73.24,96.03 70.8,98.47 70.8,105.83 71.05,106.09 71.05,108.86 68.75,111.17 67.75,111.17 65.32,113.6 63.77,113.6 63.4,113.97 63.4,115.13 62.49,116.03 62.49,116.91 59.45,119.96 v1(59.45,123.69)
  BOTTOM w0.108: v1(59.45,123.69) 58.94,124.19 57.39,124.19 RC191.2 56.85,123.66 U51.5
3V_5V_EN: length 12.6
  TOP w0.108: v1(194.24,64.5) 194.75,65.01 194.99,65.01 195.1,64.9 PU5301.20 ; PR5313.2 192.26,61.76 192.47,61.96 193.58,61.96 v1(194.04,61.51) PC5319.1 194.5,60.72 195.1,61.32 PU5301.6
  BOTTOM w0.108: v1(194.24,64.5) 194.04,64.3 v1(194.04,61.51) v2(196.56,61.51)
3V_5V_PGOOD: length 7.2
  TOP w0.108: PU5301.7 195.5,61.34 PR5306.1 193.61,59.45 192.7,59.45 PR5304.1 191.83,60.31 190.43,60.31 v2(190.03,60.72)
3V_BST2_2: length 1.2
  TOP w0.254: PR5303.1 196.85,59.78 v2(197.93,59.78)
3V_FB2_1: length 36.4
  TOP w0.203: PJP5305.1 200.26,49.47 v1(199.69,50.05)
  TOP w0.254: v1(189.22,62.37) 189.52,62.68 PC5317.2 PR5310.2
  BOTTOM w0.254: v1(189.22,62.37) 190.38,63.54 190.38,65.42 192.67,67.7 196.28,67.7 199.53,64.45 199.86,64.45 201.28,63.03 201.28,61.89 v2(202.46,60.71) 203.49,59.68 203.49,53.84 v1(199.69,50.05)
3V_FB2_2: length 5.8
  TOP w0.254: PU5301.4 193.76,62.71 192.29,63.54 PR5312.2 PR5310.1 PC5317.1
  TOP w0.305: PC5317.1 v2(188.99,63.54)
3V_HG: length 6.9
  IN4 w0.762: v4(192.47,58.61) 192.88,59.03 194.59,59.03 196.15,60.59 197.19,60.59 v4(197.55,60.95)
  BOTTOM w0.508: v2(197.55,60.06) v4(197.55,60.95)
3V_LG: length 20.5
  BOTTOM w0.762: v4(198.69,60.95) 198.69,60.24 199.27,59.65 v2(200.37,59.65) 201.83,59.65 202.47,59.01 202.47,55.71 199.51,52.74 195.55,52.74 195.21,52.74 193.13,50.66 v4(192.37,50.66)
5V_BST1_1:
  vias: v2(195.95,68.57)
5V_FB1_1: length 23.5
  TOP w0.254: PR5309.1 PC5316.1 193.91,69.34 v1(193.58,69.67)
  BOTTOM w0.203: 178.63,73.5 178.8,73.33 PJP5303.2
  BOTTOM w0.254: v1(193.58,69.67) 192.71,68.8 v2(190.59,68.8) 190,68.21 179.66,68.21 177.79,70.08 177.79,73.17 178.12,73.5 178.63,73.5
5V_FB1_2: length 8.5
  TOP w0.108: PC5316.2 192.85,68.87 191.25,68.87 v2(191.12,69)
  TOP w0.203: PC5316.2 PR5309.2 PR5311.2 193.05,64.55 194.1,63.51 PU5301.2
5V_HG: length 16.1
  IN4 w0.762: v4(197.01,65.2) 195.07,65.2 194.5,65.77 193.3,65.77 192.78,66.29 189.92,66.29 187.09,69.12 v4(182.52,69.12)
  vias: v2(182.81,70.14)
5V_LG: length 11.9
  IN4 w0.762: v4(188.99,69.1) 189.56,68.53 195.17,68.53 198.18,65.52 198.18,64.8 197.82,64.44 v4(197.82,64.42)
  vias: v2(188.56,69.97)
5V_SW: length 8.5
  IN2 w0.762: v4(187.51,70.93) 188.99,70.93 192.24,67.68 194.02,67.68 194.47,67.22
  vias: v1(194.78,66.89) v1(195.39,66.89) v2(188.45,77.43) v2(190.21,77.48) v4(186.62,73.6) v4(186.62,72.71) v4(186.62,71.82) v4(186.62,70.93) v4(187.51,73.6) v4(187.51,72.71) v4(187.51,71.82)
5V_VO1: length 32.7
  TOP w0.203: PU5301.14 198.12,63.51 198.84,64.22 198.84,65.16 198.25,65.76 197.39,67.24 197.39,67.67 197.31,68.09 v1(196.96,68.44)
  BOTTOM w0.203: 178.6,73.85 178.8,74.05 PJP5304.2
  BOTTOM w0.254: 178.6,73.85 177.97,73.85 177.64,73.52 177.43,73.31 177.43,69.83 179.4,67.86 190.89,67.86 191.48,68.44 v2(193.1,68.44) v1(196.96,68.44)
+0.6V_DDR_VTT: length 53.9
  IN2 w1.524: 140.3,47.92 138.42,49.8 135.67,49.8 132.34,53.12 101.86,53.12 95.95,59.04 92.77,59.04
  IN3 w0.762: 149.59,32.17 149.59,31.36 148.93,30.7
  vias: v1(148.59,40.44) v1(148.57,39.83) v1(148.93,27.24) v1(149.39,27.7) v2(148.55,25.16) v4(91.6,59.04) v4(91.6,58.12) v4(149.41,40.4)
+0.6V_DDR_VTTP: length 1.8
  TOP w0.508: v2(91.45,54.75) 91.48,54.72 PJP5403.2
+0.9V_LAN: length 14
  TOP w0.203: U21.46 v1(143.52,130.74) ; v1(143.52,131.94) 143.51,131.94 U21.43 ; v1(147.79,127.42) 147.79,128.07 C117.1 147.72,128.5 147.35,128.87 U21.11 ; U21.40 143.31,133.14 v1(143.56,133.39) ; v1(146.11,130.29) 146.15,130.25 U21.8
  TOP w0.216: U21.46 140.84,130.74 139.89,129.79 139.89,129.78 ; v1(143.52,130.74) 143.12,130.34 U21.47
  TOP w0.254: v1(147.64,133.34) 147.84,133.54 U21.22 ; v1(147.64,131.31) 147.76,131.31 147.92,131.14 U21.16
  TOP w0.508: v1(142.76,124.98) 142.58,124.98 142.38,124.78 L27.2
  BOTTOM w0.508: C183.1 147.95,133.66 v1(147.64,133.34)
  vias: v1(143.06,138.91) v2(143.04,132.42)
+1.0V_AMPHYPLL: length 44.5
  TOP w0.457: v3(130.07,96.9) 130.36,97.2 131.5,97.2 C9631.1
  TOP w0.508: RC419.2 156.53,108.23 155.65,107.35 C9632.1 154.65,108.29 154.82,108.47 154.82,109.67 v1(154.89,109.73) ; v3(140.68,103.37) 140.02,102.71 v2(140.02,101.52) 138.69,100.19 138.16,100.19 136.81,98.85 136.81,98.35 136.52,98.06 135.85,98.06 134.97,97.18 132.36,97.18 131.95,97.59 C9631.1
  IN1 w0.508: v3(140.68,103.37) 140.68,102.31 143.68,99.3 147.06,99.3 150.56,102.8 150.56,105.4 v1(154.89,109.73)
  BOTTOM w0.254: UC1.L15 129.72,96.56 v3(130.07,96.9) 129.72,97.25 UC1.K15
+1.0V_APLL: length 75.6
  TOP w0.254: v1(139.7,113.88) 139.7,112.98 C9656.1 141.13,113.27 141.13,113.81 RC444.2 ; v3(130.06,93.49) 130.17,93.37 C9959.1
  TOP w0.508: v1(145.86,91.68) 145.88,91.66 v2(145.88,90.92)
  IN1 w0.254: v1(139.7,113.88) 139.85,114.03 142.63,114.03 143.63,113.04 144.13,113.04 145.98,114.9 154.42,114.9 158.08,111.24 158.08,103.8 159.86,102.01 159.86,99.97 159.57,99.68 157.9,99.68 157.14,98.92 157.14,97.5 155.13,95.49 148.83,95.49 147.85,94.51 146.71,94.51 145.63,93.43 145.63,92.42 145.86,92.19 v1(145.86,91.68)
  IN4 w0.254: v3(130.06,93.49) 130.84,92.71 140.66,92.71 141.57,91.81 143.7,91.81 144.31,91.2 145.5,91.2 145.86,91.56 v1(145.86,91.68)
  BOTTOM w0.254: UC1.V15 130.06,93.42 v3(130.06,93.49)
+1.0V_APLLEBB: length 2.1
  TOP w0.254: RC446.2 127.7,96.25 v3(127.44,96) 127.32,95.87 C9636.1
  BOTTOM w0.254: UC1.N18 127.77,95.68 v3(127.44,96)
+1.0V_CLK1: length 15.1
  TOP w0.508: v2(132.65,114.16) v1(133.28,114.16)
  IN1 w0.254: v3(132.47,105.47) 132.81,105.81 132.81,106.43 132.68,106.57 132.68,111.11 132.85,111.29 132.85,113.73 v1(133.28,114.16)
  BOTTOM w0.203: v3(132.47,105.47) 131.35,104.36 130.99,104.36 130.56,103.93 130.56,103.64 130.04,103.12 UC1.A14
  BOTTOM w0.254: RC450.2 133.08,113.96 v1(133.28,114.16)
+1.0V_CLK2: length 31.8
  TOP w0.254: RC435.2 145.29,112.65 145.53,112.41 ; v1(145.26,111.28) 145.26,112.14 145.53,112.41 ; C9647.1 145.53,112.41
  IN2 w0.254: v1(145.26,111.28) 145.26,110.8 143.8,109.34 136.33,109.34 135.75,108.75 133.92,108.75 133.67,108.5 132.81,108.5 129.68,105.37 129.68,102.55 127.87,100.75 127.87,99.85 127.84,99.82 127.84,98.24 127.41,97.8 v3(127.39,97.8)
  BOTTOM w0.254: UC1.K19 127.39,97.55 v3(127.39,97.8)
  BOTTOM w0.381: v1(145.26,111.28) 145.26,111.74 v2(145.1,111.9)
+1.0V_CLK3: length 33
  TOP w0.254: RC451.2 143.28,113.64 143.28,111.58 143.07,111.37 ; v2(142.81,108.78) 142.81,109.08 143.29,109.56 143.29,111.15 143.07,111.37 ; 143.07,111.37 v1(142.51,111.37)
  IN2 w0.254: v3(126.14,96.88) 126.14,97.35 126.05,97.44 126.05,100.57 128.79,103.31 128.79,105.56 132.57,109.34 133.39,109.34 133.56,109.51 135.09,109.51 135.67,110.1 141.72,110.1 142.51,110.89 v1(142.51,111.37)
  BOTTOM w0.254: UC1.L21 125.82,96.56 v3(126.14,96.88)
+1.0V_CLK4: length 32.2
  TOP w0.254: RC436.2 142.17,113.65 142.2,113.63 142.2,112.99 142.31,112.88 C9648.1 141.4,112.41 141.15,112.15 141.15,111.51 140.98,111.34 v1(140.15,111.34)
  IN2 w0.254: v1(140.15,111.34) 139.29,110.48 135.45,110.48 135.02,110.05 133.54,110.05 133.23,109.74 132.43,109.74 128.43,105.74 128.43,103.7 126.92,102.18 126.87,102.18 125.14,100.46 125.14,96.17 v3(126.15,95.16)
  BOTTOM w0.254: v2(140.15,110.69) v1(140.15,111.34) ; UC1.N20 126.45,95.6 126.16,95.3 126.16,95.17 v3(126.15,95.16)
+1.0V_CLK5: length 50.1
  TOP w0.254: RC437.2 144.46,113.4 144.35,113.29 C9649.1 144.35,112.4 144.35,112.4 143.95,112 v1(143.95,111.37) ; v2(110.73,96.46) 110.91,96.64 RC52.2 110.3,97.4 v3(110.17,97.27)
  IN2 w0.254: v1(143.95,111.37) 142.3,109.72 136.05,109.72 135.47,109.13 133.74,109.13 133.49,108.88 132.65,108.88 129.22,105.45 129.22,103.24 126.95,100.97 126.95,97.37 v3(127.46,96.86)
  IN4 w0.152: v3(127.46,96.86) 126.82,96.23 113.32,96.23 112.94,96.61 112.94,96.79 112.45,97.27 v3(110.17,97.27)
  BOTTOM w0.254: v3(127.46,96.86) 127.46,96.77 UC1.L19
+1.0V_CLK6: length 9.3
  BOTTOM w0.203: UC1.A10 132.52,103.36 133.72,104.56 v2(133.72,105.76) 133.72,108.84 133.63,108.93 133.63,109.69 133.49,109.83 C9650.1 RC438.2
+1.0V_DTS: length 2.3
  TOP w0.254: v3(138.02,94.59) 138.02,94.87 v2(138.31,95.16) 138.8,95.16 RC440.2
  BOTTOM w0.203: UC1.T1 137.96,94.56 138,94.59 v3(138.02,94.59)
+1.0V_MPHYAON: length 36.8
  TOP w0.254: v3(140.02,99.45) 139.84,99.63 138.72,99.63 v2(138.57,99.48) 138.4,99.31 137.95,99.31 137.28,98.65 137.28,98.12 136.75,97.59 136.04,97.59 135.16,96.7 130.56,96.7 130.31,96.46 129.65,96.46 129.25,96.86 v3(128.74,96.86) ; RC439.2 145.92,113.42 145.83,113.42 v1(145.82,113.41)
  IN3 w0.254: v1(143.44,108.83) 143.44,108.87 143.9,109.34 144.45,109.34 145.99,110.87 145.99,113.01 145.83,113.17 145.83,113.4 v1(145.82,113.41)
  BOTTOM w0.178: C9628.1 143.04,109.37 143.04,109.23 v1(143.44,108.83) 143.22,108.83 142.76,108.37 142.33,108.37 140.22,106.26 140.22,100.17 140.02,99.96 v3(140.02,99.45) 139.89,99.33 139.89,98.82 139.48,98.41 139.02,98.41 138.4,97.8 138.4,97.53 138.09,97.21 UC1.L1
  BOTTOM w0.254: v3(128.74,96.86) 128.74,96.96 UC1.K17
+1.0V_MPHYGT: length 49.9
  TOP w0.254: v3(130.1,96.01) 130.1,95.67 C9633.1 129.47,95.43 129.47,95.8 RC446.1
  TOP w0.508: v3(128.08,95.19) 128.04,95.19 RC447.1
  IN2 w1.524: 155.26,113.15 156.78,111.62 161.46,111.62 164.23,108.85 165.83,108.85 166.23,108.45 171.87,108.45 173.24,107.07 174,107.07 ; 177.86,106.18 179.38,104.66 183.26,104.66 184.77,103.15 184.77,92.45 185,92.22 185,88.96 183.91,87.87 v4(183.49,87.87)
  BOTTOM w0.508: v2(184.34,87.87) v4(183.49,87.87)
  vias: v1(147.64,112.89) v1(147.66,111.9) v1(148.04,112.38) v1(154.57,112.79) v1(182.75,87.9) v4(153.94,113.25)
+1.0V_PLL: length 4.6
  TOP w0.203: RC454.2 128.88,97.78 v2(129.78,97.78)
  TOP w0.254: v3(126.81,96.86) 127.24,97.3 127.26,97.3 127.27,97.31 128.38,97.31 RC454.2
  BOTTOM w0.254: UC1.K21 125.89,97.35 126.39,97.35 UC1.K20 126.81,96.93 v3(126.81,96.86)
+1.0V_PRIM: length 130.9
  TOP w0.203: v3(126.15,90.97) 126.2,90.92 RC418.1
  TOP w0.254: v3(140.65,94.73) RC440.1 ; v3(126.79,90.97) 127.13,90.64 C9625.1
  TOP w0.508: v1(132.29,113.33) 133.98,113.33 134.99,114.34 137.7,114.34 138.09,114.72 141.29,114.72
  IN2 w0.508: v1(85.2,109.13) 85.84,109.77 85.84,110.2 88.68,113.04 97.6,113.04 98.92,114.37 98.92,115.31 99.67,116.07 100.47,116.07 101.43,117.03 101.43,117.72 103.71,120 113.55,120 115.81,122.26 119.49,122.26 120,121.76 120,120.39 121.88,118.5 126.71,118.5 129.78,115.43 131.29,115.43 132.29,114.42 v1(132.29,113.33)
  IN2 w1.524: 186.42,93.13 186.42,103.83 183.84,106.41 182.72,106.41 180.19,108.94 174.9,108.94 173.75,110.1 166.91,110.1 163.71,113.3 157.77,113.3 155.33,115.74 150.63,115.74 150.18,116.19 149.19,116.19
  BOTTOM w0.203: v3(128.09,91.85) 128.09,91.73 UC1.AB17 ; UC1.Y18 127.44,91.92 v3(127.44,91.85)
  BOTTOM w0.254: v3(126.79,90.97) 127.12,91.3 UC1.AB19 ; UC1.P18 128.12,94.41 v3(128.12,94.34) ; v3(126.15,90.97) 126.15,91.09 UC1.AB20
  BOTTOM w0.508: v1(85.2,109.13) 85.2,109.54 85.06,109.68 PJP5813.1 ; RC438.1 RC450.1 132.95,112.38 132.29,113.04 v1(132.29,113.33)
  vias: v1(147.38,116.47) v1(147.38,115.86) v1(148.02,116.47) v1(148.02,115.86) v1(148.61,109.31) v1(148.52,108.57) v1(149.08,108.83) v1(187.41,92.6) v1(187.41,90.51) v1(187.41,89.83) v1(187.41,89.19) v1(187.41,88.56) v2(188.1,89.29)
+1.0V_PRIM_4: length 2.6
  TOP w0.203: v3(126.1,87.64) 125.92,87.82 v2(125.92,88.41) 125.92,88.79 126.2,89.07 RC418.2
  BOTTOM w0.203: UC1.AK20 126.1,87.59 v3(126.1,87.64)
+1.0V_PRIM_CORE:
  vias: v2(170.29,92.34) v3(125.49,92.67) v3(126.16,92.67) v3(126.81,89.29) v3(127.44,89.29) v3(139.3,97.42) v3(140.3,91.3) v3(140.68,91.81) v4(151.68,109.72) v4(151.96,108.9) v4(169.86,91.56) v4(170.75,91.56)
+1.0V_PRIM_COREP: length 15.7
  BOTTOM w0.254: PU5602.1 172.26,100.58 172.73,100.11 174.79,100.11 175.45,99.46 175.45,98.18 174.78,97.51 PC5617.1 ; PC5614.1 169.44,94.77 168.87,95.34 168.87,95.54 168.87,95.55 168.87,96.46 169.73,97.32 169.73,100.37 170.16,100.8 PU5602.5
  vias: v2(176.26,94.63)
+1.0V_PRIM_XDP: length 102.3
  TOP w0.254: RC386.1 135.22,112.23 136.36,113.37 v1(136.36,113.55)
  IN2 w0.254: v1(136.36,113.55) 136.36,113.62 135.34,114.64 133.08,114.64 132.8,114.36 132.8,112.21 132.39,111.8 131.44,111.8 130.8,111.16 130.39,111.16 130.11,111.45 130.11,113.21 125.96,117.36 121.37,117.36 119.9,118.83 104.16,118.83 102.58,117.25 102.58,116.4 102.07,115.89 102.07,114.44 101.53,113.91 101.53,113.22 100.57,112.26 100.01,112.26 98.77,111.02 98.77,110.84
  IN2 w0.508: 78.5,111.93 79.11,112.54 79.11,114.21 79.41,114.51 79.41,117.14 79.07,117.47 79.07,119.33 79.8,120.06 79.8,123.5 v1(78.66,124.64) ; 78.5,111.93 78.88,111.54 78.93,111.54 79.37,111.1 79.37,110.67 80.32,109.72 81.49,109.72 83.32,107.89 85.84,107.89 88.46,110.5 89.11,110.5 90.12,111.51 98.1,111.51 98.77,110.84 v1(98.77,110.83) ; 78.5,111.93 v1(78.47,111.93)
  BOTTOM w0.254: RC362.1 v1(98.77,110.83)
  BOTTOM w0.279: JXDP1.43 79.3,124.04 78.7,124.64 v1(78.66,124.64)
  BOTTOM w0.508: CC11.1 79.81,112.57 79.16,111.93 ; 79.16,111.93 80.34,110.74 82.01,110.74 v2(82.54,111.27) PJP5813.2 ; 79.16,111.93 v1(78.47,111.93)
+1.0V_RUN: length 1.6
  IN3 w1.016: 72.71,130.32 73.85,131.46
  vias: v4(70.06,128.77) v4(70.7,129.43) v4(85.43,136.59) v4(86.04,135.92) v4(89.72,115.28) v4(90.61,115.53) v5(91.45,115.69)
+1.0V_RUN_VMM:
  vias: v1(94.7,116.37) v1(94.7,115.76) v1(95.34,116.37) v1(95.36,115.76) v4(91.76,123.51) v4(92.97,126.31) v5(95.09,112.17)
+1.0V_RUN_VMM_EN: length 8
  TOP w0.108: PU5904.7 68.01,137.19 PC5726.1 PR5717.1 PR5719.2 67.17,140.65 66.28,141.54 v2(66.28,142.58) 66.7,142.99 PR6092.2
+1.0V_RUN_VMM_FB: length 4.4
  TOP w0.305: v2(65.21,135.88) PR5720.1 PC5733.1 ; PR5716.1 PC5733.1 ; PC5733.1 66.84,134.91 67.15,134.6 PU5904.1
+1.0V_RUN_VMM_LX: length 1.8
  TOP w0.508: 70.3,138.29 v2(70.3,140.08)
+1.0V_RUN_VMM_VIN:
  vias: v2(67.66,127.85)
+1.0V_RUNP: length 2.5
  TOP w0.305: v1(67.6,133.8) 66.48,133.8 PC5733.2 PR5720.2
  vias: v1(69.91,132.3) v1(70.52,132.32) v1(70.95,133.36) v1(70.95,132.75) v2(73.1,136.06)
+1.0V_SRAM: length 7.8
  IN4 w0.508: v3(125.28,90.29) 125.03,90.29 124.68,90.63 124.68,92.68 125.52,93.51 v3(126.15,93.51) v3(126.78,93.51)
  BOTTOM w0.254: v3(125.28,90.29) 125.33,90.23 125.33,90.21 UC1.AF21 UC1.AF20 ; v3(126.78,93.51) 127.12,93.85 UC1.T19 ; v3(126.15,93.51) 126.15,93.6 UC1.T20
+1.0V_VCCST: length 222.1
  TOP w0.254: PR5803.1 67.32,122.62 v1(67.12,122.82) ; v3(121.85,105.27) 122.35,105.77 122.83,105.77 125.1,103.49 v1(127.56,103.49) 127.56,100.72 127.86,100.42 127.86,100.05 127.84,100.03 127.84,97.94 RC454.1 ; v1(69.68,124.4) 69.68,124.24 PR5802.2 PR5804.2 PR5805.1
  TOP w0.381: v1(183.2,94.35) 183.2,94.65 182.99,94.86 RC457.1
  TOP w0.508: v1(69.68,124.4) 69.66,124.4 69.58,124.47 69.58,125.26 PC5802.2 68.57,125.29 v5(68.55,125.3)
  IN2 w0.381: 129.7,110.07 129.75,110.07 129.78,110.05 131.23,110.05 131.89,110.71 132.83,110.71 133.86,111.74 134.54,111.74 135.16,112.35 137.83,112.35 137.9,112.43 145.66,112.43 146.34,111.75 146.34,110.73 146.62,110.45 149.04,110.45 153.44,106.05 160.7,106.05 161.83,104.92 163.77,104.92 164.06,105.2 166.37,105.2 167.01,105.84 168.65,105.84 170.18,104.31 173.17,104.31 173.89,103.58 175.03,103.58 175.74,104.29 176.78,104.29 178.51,102.57 180.02,102.57 181.24,101.35 181.24,99.73 182.31,98.67 182.31,95.24 v1(183.2,94.35) ; 129.7,110.07 128.71,111.06 128.71,113.08 125.58,116.22 120.97,116.22 119.43,117.76 104.61,117.76 103.69,116.84 103.69,115.99 103.16,115.46 103.16,113.38 101.43,111.65 100.03,111.65 99.46,111.09 99.46,110.73 99.01,110.27 98.46,110.27 v1(97.88,110.86) ; 129.7,110.07 129.75,110.02 128.1,108.37 124.45,108.37 123.38,107.3 123.38,106.8 v3(121.85,105.27)
  IN2 w0.508: v1(97.88,110.86) 95.64,110.86 v1(95.61,110.83) 90.43,110.83 89.39,109.79 88.65,109.79 86.1,107.25 86.1,105.11 85.32,104.32 v1(85.32,104) 84.73,104 83.93,104.79 83.93,105.45 80.71,108.68 80.05,108.68 77.25,111.47 77.25,117.01 75.75,118.5 75.75,121.91 74.1,123.56 70.19,123.56 69.87,123.88 69.87,124.17 69.68,124.36 v1(69.68,124.4) 68.11,122.82 v1(67.12,122.82)
  IN3 w0.254: v1(74.6,128.4) 73.98,127.78 72.68,127.78 69.68,124.78 v1(69.68,124.4)
  BOTTOM w0.152: v1(74.6,128.4) 73.77,129.24 73.77,130.53 75.18,131.94 75.29,131.94 RC382.2
  BOTTOM w0.203: v1(127.56,103.49) UC1.A18
  BOTTOM w0.254: v1(85.32,104) 85.32,103.76 86.12,102.96 RC455.1 86.7,101.64 87.72,101.64 RC80.1 RC113.1 ; RC249.1 v1(97.88,110.86) ; v3(121.85,105.27) 120.87,106.26 120.87,108.14 122.18,109.46 122.18,110.3 122.37,110.48 C9608.1 C9611.1 ; v1(95.61,110.83) 95.61,110.83 95.61,110.83 95.61,111.66 R9546.2 96.35,112.46 95.44,113.37 RC244.1
  BOTTOM w0.381: v1(183.39,90.6) 182.78,91.21 182.78,93.94 v1(183.2,94.35)
+1.0V_VCCSTG: length 148.8
  TOP w0.254: RC415.2 124.85,97.6 v3(124.65,97.4)
  TOP w0.381: v1(181.16,94.86) RC457.2 RC456.2
  IN2 w0.254: v3(124.65,97.4) 124.22,97.82 124.22,107.05 124.96,107.79 125.59,107.79 v1(125.84,107.53) ; v1(124.72,109.31) 124.72,111.82 119.29,117.26 106.23,117.26 106.01,117.03 106.01,117.02 105.71,116.73 104.66,116.73 104.35,116.42 104.35,111.24 v1(104.07,110.96) 103.97,110.86 v1(101.23,110.86) v1(100.01,110.86) 100.01,110.02 99.58,109.59 95.44,109.59 94.93,110.1 90.56,110.1 89.88,109.41 89.88,108.29 90.23,107.94 v1(90.23,107.23)
  IN2 w0.381: v1(181.16,94.86) 181.74,95.43 181.74,98.48 180.71,99.51 180.71,101.16 180.35,101.52 177.1,101.52 176.76,101.17 175.59,101.17 172.96,103.8 169.97,103.8 168.44,105.33 167.22,105.33 166.58,104.69 164.27,104.69 163.98,104.41 161.61,104.41 160.48,105.54 153.23,105.54 148.83,109.94 146.31,109.94 145.83,110.43 145.83,111.48 145.39,111.92 139.17,111.92 139.07,111.82 136.15,111.82 134.83,110.5 133.36,110.5 133.06,110.2 132.12,110.2 129.45,107.53 v1(125.84,107.53)
  BOTTOM w0.254: v1(100.01,110.86) 99.91,110.86 99.78,110.73 RC361.1 ; v1(90.23,107.23) 89.66,106.66 88.42,106.66 88.15,106.39 RC405.1 ; C9609.1 123.77,111.07 RC416.1 124.72,109.94 v1(124.72,109.31) 125.1,109.31 v2(125.6,108.8) 125.6,107.77 v1(125.84,107.53) ; RC357.2 101.08,111.01 v1(101.23,110.86) 101.54,110.55 RC363.1 RC364.1
  BOTTOM w0.305: v1(104.07,110.96) 103.52,110.96 103.19,111.29 RC366.1 ; v1(104.07,110.96) 103.8,110.68 RC365.1 ; v1(104.07,110.96) 104,111.03 RC367.1
+1.0V_VCCSTG_R1: length 2.7
  TOP w0.203: v3(127.39,98.41) 127.19,98.41 v2(126.64,98.96) 126.16,98.96 RC415.1
  BOTTOM w0.254: v3(127.39,98.41) 127.23,98.41 UC1.G20
+1.0V_VCCSTG_R2: length 8.3
  BOTTOM w0.203: UC1.A22 125.08,104.11 124.14,105.06 124.14,108.14 123.86,108.42 v2(123.86,109.18) 123.73,109.31 123.73,110.07 RC416.2
+1.0V_VMM_VDD: length 4.3
  TOP w0.089: 88.53,131.95 88.73,131.95
  TOP w0.254: U6.H8 v8(87.58,128.71) U6.H9 ; U6.H7 v8(87.58,129.36) ; U6.C8 90.51,129.03 v8(90.18,128.71) U6.C9 ; U6.H6 v8(87.58,130.01) ; U6.D3 v8(90.18,132.61) ; U6.G3 v8(88.23,131.96) ; U6.E3 v8(89.53,132.61)
  vias: v2(88.23,129.35) v8(88.23,126.11) v8(88.89,130.01) v8(88.89,129.36)
+1.0V_VMM_VDDLP: length 10.5
  TOP w0.254: v8(88.89,130.66) 88.89,130.67 89.2,130.98 U6.E5 ; v8(86.93,132.61) U6.J3
  BOTTOM w0.254: v8(88.89,130.66) 88.89,131.97 88.33,132.53 87.41,132.53
  BOTTOM w0.508: L7108.2 90.2,139.43 87.93,139.43 v2(87.35,138.85) L7107.2
+1.0V_VMM_VDDTX: length 2.7
  TOP w0.254: U6.C7 v8(90.18,130.01) U6.C6 ; v8(86.28,133.26) 86.61,132.93 U6.J2 ; U6.F3 v8(88.88,132.61)
  BOTTOM w0.254: v2(89.47,132.02) 89.47,132.02 v8(88.88,132.61)
  vias: v8(85.63,128.06) v8(86.28,128.06) v8(88.89,126.11) v8(89.53,126.11)
+1.0VO_DSW: length 6.6
  TOP w0.203: v3(138.25,85.33) 137.21,85.33 136.61,85.93 136.61,87.22 v2(136.82,87.43) C9627.1
  BOTTOM w0.254: v3(138.25,85.33) 138.25,86.09 138,86.35 137.77,86.35 UC1.AL1
+1.0VS_VCCIO: length 268.8
  TOP w0.254: v1(100.26,113.4) 100.26,111.77 100.52,111.52 100.52,110.56 RC134.1
  TOP w0.305: v1(250.76,62.88) 250.2,63.44 Q4215.3 ; R374.2 R9687.1 225.66,65.51 v1(225.8,65.65)
  TOP w0.381: RC420.1 121.68,72.64 v1(122.64,71.67)
  IN1 w0.305: v1(225.8,65.65) 225.8,66.12 226.98,67.3 242.3,67.3 245.53,64.07 249.42,64.07 250.61,62.88 v1(250.76,62.88)
  IN1 w0.508: v1(100.26,113.4) 99.63,114.03 98.61,114.03 97.9,113.32 96.18,113.32 95.46,114.03 95.46,114.62 96.12,115.28 v1(96.12,115.84)
  IN2 w0.203: 133.24,89.38 134.55,89.38
  IN2 w0.254: 102.17,82.41 103.44,82.41 ; 100.65,87.41 102.17,87.41
  IN2 w0.381: 134.58,88.37 132.45,88.37
  IN2 w0.508: v1(175.7,68.57) 175.6,68.67 175.6,89.35 175.03,89.92 173.07,89.92 172.38,89.22 170.83,89.22 ; 77.46,97.79 74.99,100.26 74.99,104 74.86,104.13 v1(74.84,104.13) ; v1(91.17,109.13) 91.18,109.13 91.18,109.14 90.99,108.95 90.99,105.78
  IN2 w0.635: v4(92.98,134.48) 93.78,134.48 95.01,133.26 95.01,127.24 96.34,125.91 96.34,117.86 96.12,117.64 v1(96.12,115.84)
  IN2 w0.762: 88.67,104.57 85.08,100.98 83.07,100.98 81.24,99.15 78.82,99.15 77.46,97.79 77.46,95.18 78.12,94.53 79.11,94.53 v1(79.18,94.6) ; 88.2,86.86 88.43,87.08 88.43,90.29 87.51,91.2 80.73,91.2 79.56,92.37 79.56,93.84
  IN2 w1.016: 135.12,86.98 133.27,86.98 ; 99.44,81.01 103.12,81.01
  IN3 w0.254: v1(122.64,71.67) 122.71,71.67 123.91,70.47 126.59,70.47 131.47,75.35 131.47,77.54 129.86,79.15 128.97,79.15 127.89,80.23 125.99,80.23 124.22,81.99 124.22,85.37 123.02,86.57 121.44,86.57 v3(121.01,86.14)
  IN3 w0.508: v1(100.26,113.4) 98.87,112 92.39,112 91.17,110.78 v1(91.17,109.13)
  IN4 w0.305: v1(225.8,65.65) 225.42,66.03 224.65,66.03 223.34,64.72 219.68,64.72 219.14,65.27 214.74,65.27 213.69,64.21 208,64.21 207.03,63.23 195.9,63.23 195.72,63.06 194.8,63.06 193.46,64.4 v1(189.01,64.4)
  IN4 w0.762: 86.29,86.09 84.18,86.09 79.18,91.09 v1(79.18,94.6)
  BOTTOM w0.432: v1(74.84,104.13) 74.86,104.13 74.1,104.89 73.34,104.89 v2(71.82,106.41) 71.11,107.12 RC381.2
  BOTTOM w0.508: v4(92.98,134.48) 92.98,135.49 91.88,136.59 91.88,139.78 L7108.1 ; v1(175.7,68.57) 175.98,68.57 180.69,63.86 188.47,63.86 v1(189.01,64.4)
  vias: v1(86.93,86.4) v1(86.93,85.79) v1(169.84,89.98) v3(113.7,86.08) v3(114.61,86.08) v3(120.97,87.75) v3(121.85,87.75) v4(170.11,90.67) v4(170.78,90.11)
+1.2V_MEM: length 133.1
  TOP w0.305: v1(104.86,39.75) 104.96,39.65 RD3.1
  TOP w0.381: U5.5 82.12,33.15 82.28,33.31 82.69,33.31 83.18,32.82 CD23.1
  TOP w0.508: CD98.1 143.19,32.35 ; 84.42,32.8 84.4,32.82 CD23.1 ; CD97.1 v1(137.98,39.74) ; v1(84.14,39.75) 84.01,39.62 CD95.1
  IN2 w0.508: v1(112.02,26.57) 110.56,26.57 v1(110.52,26.62) ; v1(122.64,66.24) 122.45,66.05 112.08,66.05 111.67,66.46 v1(110.01,66.46)
  IN4 w0.254: v3(125.28,79.24) 125.09,79.24 123.75,80.57 v3(123.75,83.53)
  BOTTOM w0.108: v1(121.01,27.65) 121.52,27.15 JDIMM2.154
  BOTTOM w0.152: v3(115.05,78.71) 115.06,78.73 UC1.BB41
  BOTTOM w0.178: UC1.BB32 120.03,80.47 v3(120.03,79.24) ; v3(111.44,79.47) 111.41,79.54 111.41,79.89 111.41,80 UC1.BB47 ; v3(108.95,79.47) 108.95,80.35 UC1.BB51 ; v3(125.28,79.24) 125.04,79.48 125.04,80.27 125,80.31 UC1.BB23
  BOTTOM w0.254: UC1.AU35 v3(117.35,83.5) ; v1(107.31,48.38) 107.44,48.5 108.16,48.5 108.76,47.9 JDIMM1.111 ; v3(121.01,83.53) 121.01,83.53 121.29,83.35 121.47,83.23 UC1.AU28 ; v3(113.69,83.55) 114.05,83.2 UC1.AU42 ; UC1.AU23 124.21,83.22 v3(123.75,83.53)
  BOTTOM w0.305: JDIMM2.178 127.53,25.19 127.53,26.87 127.1,27.29 v1(127.01,27.29) ; JDIMM1.160 v1(123.01,39.98) ; JDIMM2.75 99.77,31.93 100.21,31.48 v1(100.39,31.48) ; v1(143.32,47.96) 143.26,47.9 JDIMM1.241 ; JDIMM1.112 v1(109.01,39.74) ; JDIMM2.160 123.01,26.41 122.97,26.45 v1(122.97,26.48) ; JDIMM2.141 116.27,32.27 v1(116.52,32.02) ; JDIMM2.124 v1(112.02,26.57) ; JDIMM2.54 v1(94.52,26.44) ; v1(114.07,30.63) 114.56,30.63 115,31.07 115,32.12 114.77,32.35 JDIMM2.135 ; JDIMM1.163 123.76,44.98 v1(124.84,43.9) ; JDIMM2.112 v1(109.02,26.66) ; JDIMM2.117 v1(110.27,32.12) ; JDIMM1.142 v1(116.51,39.99) ; JDIMM1.12 84.01,39.62 84.14,39.74 v1(84.14,39.75) ; JDIMM1.118 v1(110.51,39.78) ; v1(104.86,39.75) 105.01,39.6 JDIMM1.96 ; JDIMM2.96 105.02,26.96 v1(105.22,27.17) ; v1(122.77,45.3) 122.77,46.64 122.76,46.64 JDIMM1.159 ; JDIMM1.75 99.76,45.71 99.73,45.68 99.73,45.04 100.08,44.69 v1(100.24,44.69) ; JDIMM1.148 v1(120.01,39.93) ; JDIMM2.199 v1(132.77,32.12) ; JDIMM2.153 v1(121.27,32.07) ; v1(119.97,32.09) 119.77,32.3 JDIMM2.147 ; JDIMM1.33 89.26,45.41 v1(89.18,45.33) ; JDIMM1.141 116.26,45.58 v1(116.01,45.33) ; JDIMM2.159 v1(122.77,32.12) ; v1(115.24,39.74) 115.01,39.51 JDIMM1.136 ; v1(108.07,31.49) 108.77,32.18 JDIMM2.111 ; JDIMM1.129 113.26,47.82 112.96,48.12 112.07,48.12 111.76,47.82 JDIMM1.123 v1(111.76,45.39) ; JDIMM2.130 v1(113.52,26.58) ; JDIMM1.178 127.51,39.56 127.52,39.56 127.52,40.83 v1(126.99,41.36) ; JDIMM2.118 v1(110.52,26.62) ; v1(111.54,32.12) 111.77,32.34 JDIMM2.123 ; v1(132.78,45.33) 132.76,45.34 JDIMM1.199 ; JDIMM2.136 v1(115.02,26.53) ; v1(84.14,26.53) 84.02,26.41 JDIMM2.12 ; JDIMM2.241 143.27,32.32 v1(143.06,32.12) ; JDIMM1.147 119.76,45.36 v1(119.8,45.33) ; v1(137.98,39.74) 138.01,39.71 JDIMM1.220 ; JDIMM2.220 v1(138.02,26.53) ; JDIMM2.129 113.27,32.25 113.26,32.24 113.26,31.65 111.69,30.09 v1(111.54,30.09) ; JDIMM2.33 89.26,31.84 88.96,31.53 v1(88.71,31.53) ; JDIMM1.154 v1(121.51,39.95) ; v1(121.49,45.24) 121.26,45.46 JDIMM1.153 ; JDIMM1.135 114.76,45.33 v1(114.74,45.33) ; JDIMM1.54 94.51,39.52 94.52,39.53 94.52,40.02 94.17,40.37 v1(94.01,40.37) ; v1(124.71,30.72) 123.77,31.67 JDIMM2.163 ; JDIMM1.124 v1(112.01,39.8) ; JDIMM1.130 v1(113.51,39.83) ; JDIMM2.148 v1(120.02,26.72) ; JDIMM1.117 110.26,45.42 v1(110.04,45.2) ; JDIMM2.142 v1(116.52,26.78)
  vias: v2(100.24,43.75) v2(106.97,41.92) v2(130.19,48.27) v2(132.52,48.27) v2(134.45,48.25)
+1.2V_MEM_CPUCLK: length 33.6
  TOP w0.305: v1(122.64,68.61) 122.54,68.61 122.13,69.02 122.13,70.41 121.65,70.89 121.58,70.89
  TOP w0.406: 121.58,70.89 C9607.1
  TOP w0.508: RC417.2 120.58,72.38 120.33,72.12 120.33,71.24 121.18,71.24 C9607.1
  IN2 w0.254: v1(122.64,68.61) 123.3,68.61 126.2,71.51 v1(126.2,72)
  IN3 w0.254: v1(126.2,72) 125.92,72 125.54,72.38 125.54,77.46 124.78,78.22 124.78,79.05 122.94,80.89 119.34,80.89 116.88,83.34 116.88,84.98 116.62,85.24 116.24,85.24 115.52,85.96 v3(115.52,86.08)
  BOTTOM w0.254: UC1.AM40 115.12,86.45 115.23,86.35 v3(115.52,86.08) ; v2(126.2,71.26) v1(126.2,72)
+1.2V_MEN_P: length 42.1
  IN2 w0.508: v1(86.75,71.13) 88.99,68.9 88.99,54.88 v1(88.52,54.41)
  IN2 w1.016: v4(86.75,72.07) 87.72,72.07 90.03,69.77 90.03,50.12 v4(89.78,49.87)
  vias: v2(89.62,75.78) v2(89.75,73.72) v2(91.4,75.83) v2(93.23,75.88)
+1.2VP_+VLDOIN:
  vias: v2(86.83,50.79)
+1.2VP_B+: length 6.2
  TOP w0.381: v1(83.75,56.71) PR5406.1
  TOP w0.508: PL5401.2 78.93,57.93 v2(78.57,57.57)
  BOTTOM w0.508: v1(83.75,60.19) v1(83.75,56.71)
+1.2VP_B+_R: length 5
  TOP w0.203: PU5401.9 84.56,55.01 84.31,55.26 83.63,55.26 PR5406.2 82.28,56.6 80.86,56.6 v2(80.73,56.48)
+1.2VP_BOOT:
  vias: v2(85.1,50.71)
+1.2VP_BOOT_R: length 1.3
  TOP w0.508: PR5401.1 83.53,49.3 v2(83.53,48.2)
+1.2VP_CS: length 16.7
  TOP w0.203: 82.64,53.05 82.81,53.23 PU5401.13
  TOP w0.254: v1(80.31,48.54) 80.07,48.78 80.07,52.44 80.48,52.85 82.43,52.85 82.64,53.05 ; v1(79.77,47.28) 79.55,47.5 79.47,47.5 v2(79.21,47.77) 78.9,48.07 78.9,53.25 PR5402.2
  BOTTOM w0.254: v1(80.31,48.54) 79.77,47.99 v1(79.77,47.28)
+1.2VP_DH: length 22.3
  IN3 w0.762: v4(81.93,65.41) 81.09,64.57 81.09,55.74 79.84,54.5 79.84,50.31 80.92,49.23 83.72,49.23 84.39,49.9
  BOTTOM w0.508: v2(81.18,64.66) v4(81.93,65.41)
  vias: v1(84.44,51.04) v1(84.44,50.43)
+1.2VP_DL: length 16.9
  IN2 w0.762: v4(87.84,63.89) 84.54,60.59 84.54,55.46 83.7,54.62 82.03,54.62 81.42,54.01 v4(81.42,50.61)
  vias: v2(80.91,50.03)
+1.2VP_FB: length 0.8
  TOP w0.508: v2(89.7,56.86) 89.7,56.43 89.47,56.2
+1.2VP_S3: length 3.9
  TOP w0.203: v2(87.49,57.21) 86.96,56.68 86.96,56.05 86.63,55.72 PR5409.2 85.98,55.23 85.56,55.23 85.36,55.04 PU5401.7
+1.2VP_SNUB:
  vias: v2(78.7,72.61)
+1.2VP_SW: length 16.6
  IN3 w0.762: 82.71,50.69 82.71,51.7 82.22,52.2 82.22,53.32 82.61,53.71 82.61,64.25 v4(83.75,65.39)
  BOTTOM w0.508: v2(83.02,64.66) v4(83.75,65.39)
  vias: v1(83.42,51.09) v1(83.42,50.48)
+1.2VP_VDD: length 1.1
  TOP w0.508: PR5402.1 79.56,55.31 v2(79.13,55.74)
+1.5V_EN: length 5.6
  TOP w0.108: PU5701.7 216.11,61.32 216.34,61.56 216.34,62.5 PR5703.1 PR5701.2 PC5704.1 219.39,62.8 v2(219.39,62.35)
+1.5V_FB: length 4.5
  TOP w0.108: PU5701.1 214.05,62.97 PR5704.1 PR5705.1 215.76,63.16 v2(216.15,63.55) 216.27,63.67 PC5708.1
+1.5V_LX: length 0.8
  TOP w0.508: 217.28,61.66 217.56,61.94 v2(217.56,62.35)
+1.5V_RUN: length 294.7
  IN1 w0.254: v1(60.06,114.59) 60.56,115.09 62.83,115.09 63.64,115.89 63.64,117.44 64.49,118.29 66.47,118.29 67.73,119.55 75.38,119.55 77.85,117.07 84.26,117.07 84.96,116.37 85.96,116.37 87.11,115.23 87.29,115.23 v1(87.39,115.13)
  IN1 w0.381: 187.39,49.9 187.39,50.64 187.95,51.19 188.86,51.19 190,52.34 190,53.41 187.95,55.46 186.4,55.46
  IN1 w0.508: 186.7,49.7 186.7,50.79 187.79,51.88 188.26,51.88 188.85,52.47 188.85,53.69 187.96,54.57 186.65,54.57 186.37,54.85 ; v1(182.51,80.1) 180.23,77.82 180.23,66.1 186.23,60.1 186.23,56.01
  IN2 w0.254: v1(87.39,115.13) 87.39,114.62 88.45,113.55 96.94,113.55 97.48,114.09 97.48,115.1 v1(97.6,115.22) 97.6,115.91 96.95,116.56 96.95,117.43 97.94,118.43 100.49,118.43 101.51,119.45 101.51,121.2 102.11,121.8 102.86,121.8 102.98,121.68 103.9,121.68 104.02,121.8 104.79,121.8 105.29,121.3 113.9,121.3 115.38,122.77 120.33,122.77 122.59,120.51 125.74,120.51 130.08,116.17 136.54,116.17 137.48,115.23 141.72,115.23 142.68,116.19 145.86,116.19 146.89,115.16 148.16,115.16 151.75,111.57 155.05,111.57 156.02,110.61 160.92,110.61 163.69,107.83 164.46,107.83 165.34,106.95 169.07,106.95 170.63,105.39 177.22,105.39 178.96,103.65 182.84,103.65 183.75,102.73 183.75,99.1 183.17,98.51 183.17,97.17 183.68,96.66 183.68,94.15 183.68,94.02 181.29,91.63 181.29,86.22 180.48,85.41 180.48,84.88 182,83.36 182,80.62 v1(182.51,80.1)
  IN2 w0.508: v1(52.08,114.42) 52.08,114.61 52.64,115.17 57.93,115.17 58.5,114.59 v1(60.06,114.59)
  IN3 w0.889: 187.95,49.47 189.72,49.47 190.31,48.88 194.7,48.88 195.53,48.06 212.77,48.06 213.73,47.11 215.61,47.11
  BOTTOM w0.254: 186.04,56.25 185.63,56.66 JEPC1.25 ; 186.13,56.52 JEPC1.26
  BOTTOM w0.305: JEPC1.27 186.63,56.51 186.62,56.5
  BOTTOM w0.381: R9444.2 97.6,115.74 v1(97.6,115.22) ; v4(215.53,55.42) 214.77,54.66 214.77,54.03 213.42,52.69 213.42,48.78 215.23,46.98
  BOTTOM w0.508: v1(185.74,55.39) 185.88,55.25 186.45,55.25 C635.1 186.62,56 ; L37.2 41.82,120.61 46.37,120.61 46.75,120.99 v2(48.42,120.99) 49.44,120.99 51.61,118.83 51.61,116.11 52.08,115.63 v1(52.08,114.42) ; 215.99,47 216.06,47.08 216.06,54.89 v4(215.53,55.42)
  vias: v1(186.43,48.94) v1(186.88,49.39) v1(215.44,46.62) v1(216.05,46.62)
+1.5V_RUN_AUDIO: length 6.1
  TOP w0.216: U17.40 40.72,119.31 39.94,118.53 39.94,118.38 39.97,118.35 v1(39.94,118.35)
  BOTTOM w0.508: L37.1 C150.1 39.3,119.22 39.63,119.22 39.97,118.89 39.97,118.38 v1(39.94,118.35)
+1.5V_VIN:
  vias: v2(212.91,60.31)
+1.5VSP: length 13.6
  TOP w0.254: PC5707.1 219.39,57.52 219.62,57.75 219.62,59.45 219.9,59.73 219.9,64.38 219.01,65.27 216.88,65.27 216.77,65.37 PC5708.2 215.78,64.89 215.78,64.83 215.77,64.82 215.77,64.43 215.36,64.02 PR5705.2
  vias: v2(218.98,55.49)
+1.8V_ATS: length 4.5
  BOTTOM w0.178: RC452.1 140.7,92.42 v2(140.32,92.42) 139.1,92.42 138.64,91.96 138.07,91.96 138.02,91.91 UC1.AA1
+1.8V_EN: length 5.7
  TOP w0.108: v2(183.98,110.2) 184.36,109.82 PR5706.2 PR5708.1 PC5716.1 187.46,110.55 188.35,110.55 188.66,110.25 PU5702.7
+1.8V_FB: length 4.5
  TOP w0.203: PC5717.1 v2(184.95,106.85)
  TOP w0.254: PC5717.1 PR5710.1 PR5709.1 186.88,107.63 187.92,107.63 188.16,107.87 PU5702.1
+1.8V_LX: length 2.8
  TOP w0.254: PL5702.1 186.6,111.24 v2(186.24,111.6)
+1.8V_PGPPF: length 15.7
  TOP w0.203: v2(140.75,90.69) 140.22,90.69 139.79,91.12 139.79,91.45 139.38,91.86 v3(139.25,91.86)
  TOP w0.254: v3(139.25,91.86) 139.3,91.91 RC430.2
  IN1 w0.203: v3(128.74,89.29) 129.16,88.88 129.84,88.88 130.36,89.4 135.53,89.4 137.48,91.34 137.48,91.39 138.06,91.97 139.14,91.97 v3(139.25,91.86)
  BOTTOM w0.254: v3(128.74,89.29) 128.74,89.4 UC1.AF16
+1.8V_PRIM: length 72.8
  TOP w0.432: RC432.1 137.78,93.56 RC388.1
  TOP w0.508: v1(142.8,91.05) 142.8,91.59 v2(142.38,92.01) 140.83,93.56 RC431.1 139.99,93.56 RC430.1 138.92,93.56 RC432.1 ; v1(184.06,112.79) 184.49,112.79 185.01,113.31 PJP5704.1
  IN1 w0.508: v1(142.8,91.05) 142.8,92.64 143.6,93.43 143.6,95.59 143.29,95.9 143.29,97.07 143.9,97.68 147.92,97.68 151.32,101.08 154.39,101.08 155.13,101.82 155.13,107.35 156.83,109.06 v1(157.41,109.06)
  IN2 w0.508: v1(184.06,112.79) 182.74,111.47 176.45,111.47 175.75,112.17 174.46,113.46 v1(171.69,113.46) ; v1(157.41,109.06) 158.73,109.06 161.1,106.68 163.8,106.68 164.68,105.8 v1(165.57,105.8)
  IN3 w0.508: v1(171.69,113.46) 170.11,111.89 170.11,110.35 v1(165.57,105.8)
  BOTTOM w0.254: v1(142.8,91.05) C9641.1 RC452.2
+1.8V_VIN:
  vias: v2(190,105.45)
+1.8VALWP: length 11.1
  TOP w0.254: PJP5704.2 186.01,112.94 185.33,112.26 183.77,112.26 183.13,111.62 183.13,110.26 184.07,109.33 184.27,109.33 PC5717.2 PR5710.2
  TOP w0.508: PJP5704.2 v2(186.01,115.91)
+1VALWP: length 22.2
  TOP w0.152: 138.11,116.78 138.11,116.35 138,116.25 137.78,116.25 136.43,114.9 131.15,114.9 130.03,116.02 130.03,119.62 129.7,119.95 129.32,119.95 129.08,120.2 129.08,122.98 130.21,124.12 130.21,125.11 130.14,125.18 130.14,126.18 PR5504.2 130.44,126.81 130.36,126.89 PC5506.2
  vias: v2(133.72,116.98) v4(133.54,117.92) v4(135.73,117.3) v4(136.6,117.3)
+1VALWP_VIN: length 1.8
  BOTTOM w0.508: PL5501.2 132.01,126 v2(131.83,125.81)
  vias: v1(134.92,127.23) v1(135.53,127.24) v1(136.14,127.24)
+1VS_VCCIOP: length 26.6
  IN1 w0.254: v1(169.35,82.3) 169.62,82.3 169.86,82.54 169.86,85.08 170.11,85.33 174.05,85.33 174.18,85.46 174.18,88.76 174.43,89.02 v1(174.99,89.02)
  BOTTOM w0.254: v1(169.35,82.3) 169.31,82.3 168.97,81.95 168.97,80.36 169.21,80.13 170.75,80.13 171.02,79.86 PU5601.1 ; 175.17,89.55 176.06,89.55 176.46,89.14 176.46,83.96 176.11,83.6 176.11,82.53 176.11,82.53 175.37,81.79 PR5604.2
  vias: v2(174.33,89.35)
+2.5V_EN: length 7
  TOP w0.108: v2(213.09,57.44) 214.26,57.44 214.87,56.83 PR5711.2 PR5713.1 PC5722.1 215.09,54.75 215.81,54.75 216.32,54.24 216.32,53.43 216.22,53.33 216.22,53.32 PU5703.7
+2.5V_FB: length 5.7
  TOP w0.254: PU5703.1 213.56,53.82 212.71,54.67 PR5714.1 PC5729.1 PR5715.1 212.71,57.01 212.28,57.44 v2(211.24,57.44)
+2.5V_LX: length 1.6
  TOP w0.508: v2(217.12,54.65) 217.12,53.01
+2.5V_MEM: length 74
  TOP w0.508: CD135.1 v1(147.38,34.66)
  IN3 w0.762: 214.11,42.08 214.54,41.64 214.54,38.95 214.13,38.55 210.37,38.55 ; 211.34,42.15 210.3,42.15 209.59,41.44 209.59,40.17
  IN3 w1.524: 155.89,44.18 159.14,40.93 173.9,40.93 175.18,39.65 187.16,39.65 187.71,39.1 208.52,39.1 209.59,40.17
  BOTTOM w0.305: JDIMM2.259 147.77,34.35 147.46,34.66 v1(147.38,34.66) 147.27,34.54 JDIMM2.257 ; JDIMM1.257 147.26,47.9 147.48,48.12 v4(147.64,48.12) 147.76,47.99 JDIMM1.259
  vias: v1(148.35,47.66) v1(148.35,47.05) v1(212.98,42.94) v1(213.6,42.94) v1(214.23,42.94) v2(214.87,47.74)
+2.5V_VIN: length 2
  TOP w0.203: v2(211.03,53.79) 212.15,53.79 PC5719.1
+2.5VS: length 19.5
  TOP w0.254: PR5715.2 PC5729.2 211.16,55.61 v1(211.11,55.66) ; v1(217.92,54.32) 218.04,54.45 219.64,54.45 219.8,54.29 219.8,51.75 219.59,51.55 219.59,49.98 219.39,49.77 PC5724.1
  IN1 w0.254: v1(217.92,54.32) 217.92,55.59 217.13,56.38 215.1,56.38 214.59,55.87 214.59,54.45 214.44,54.29 213.15,54.29 211.77,55.66 v1(211.11,55.66)
  vias: v2(218.48,47.59)
+3.0V_RTC: length 54.3
  TOP w0.508: RC434.2 147,58.15 146.62,58.54 146.62,58.92 146.05,59.49 146.05,60.04 145.58,60.51 145.58,61.21 145.98,61.61 v1(145.98,62.55) ; v3(129.84,79.6) 129,78.76 129,78.15 129.67,77.49 129.67,77.39 130.55,76.5 C9644.1 C9645.1
  IN2 w0.508: v1(141.95,66.1) 140.14,66.1 138.9,64.86 137.78,64.86 136.71,65.93 134.96,65.93 134.1,66.79 134.1,73.52 131.48,76.14 130.54,76.14 129.86,76.82 129.86,77.25 129,78.11 129,78.76 v3(129.84,79.6)
  IN3 w0.254: v3(129.84,79.6) 129.01,79.6 126.05,82.56 126.05,86.48 126.27,86.7 v3(126.5,86.7)
  IN3 w0.508: v1(141.95,66.1) 142.3,66.1 143.83,64.58 145.4,64.58 146.06,63.92 146.06,63.41 145.98,63.34 v1(145.98,62.55)
  BOTTOM w0.178: UC1.BB14 129.85,80.39 129.85,79.6 v3(129.84,79.6)
  BOTTOM w0.254: v3(126.5,86.7) 126.61,86.7 UC1.AK19
  BOTTOM w0.508: v2(142.66,66.1) v1(141.95,66.1)
+3.3V_1.8V_PGPPA: length 15.9
  TOP w0.254: RC428.2 137.68,91.61 137.45,91.83 v2(137.45,92.22) 137.45,92.34 137.81,92.7 RC432.2 138.42,92.11 138.75,91.78 v3(138.75,91.3)
  IN1 w0.203: v3(138.75,91.3) 138.75,91.2 135.92,88.38 132.62,88.38 131.65,87.41 130.83,87.41 130.57,87.15 129.65,87.15 v3(129.28,86.77)
  BOTTOM w0.254: UC1.AK15 v3(129.28,86.77)
+3.3V_1.8V_PGPPG: length 26
  TOP w0.254: RC429.2 151.45,90.49 149.57,90.49 149.01,91.05 147.03,91.05 146.31,90.34 144.84,90.34 144.31,90.87 v2(143.88,90.87) 143.52,90.51 142.63,90.51 141.34,91.8 141.34,92.14 140.78,92.7 RC431.2 140.14,91.99 v3(140.01,91.86)
  IN4 w0.203: v3(130.24,91) 131.27,92.02 135.95,92.02 136.2,92.28 139.6,92.28 v3(140.01,91.86)
  BOTTOM w0.254: UC1.AD15 129.72,90.59 130.12,91 v3(130.24,91)
+3.3V_ALW: length 882.3
  TOP w0.203: v1(243.32,38.74) 243.32,38.22 PR5244.1 243.93,37.88 R386.1 244.79,36.56 244.87,36.49 R392.1
  TOP w0.254: R9405.1 252.79,44.92 252.56,44.69 v1(252.16,44.69) ; UC9.5 155.03,90.57 154.85,90.39 154.42,90.39 154.14,90.1 154.14,89.43 154.87,88.7 v1(155.64,88.7) CC94.1 157.99,88.38 159.4,88.38 159.78,88.76 v1(159.78,89.02) ; RC443.1 C9653.1 156.21,100.64 156.02,100.83 154.04,100.83 v1(152.94,101.92) ; PR5218.2 v1(256.5,36.56) ; v1(228.15,68.49) R455.2 ; R455.2 228.66,67.09 228.66,65.77 229.04,65.39 R348.1 R350.1 ; R455.2 R454.2 R380.1 ; R9588.1 251.9,47.44 v1(252.03,47.56) ; v1(235.65,68.19) R343.1 R395.2 R398.2 R396.2 ; PR5254.2 225.51,40.42 226.86,40.42 227.09,40.65 v1(227.09,40.91) ; R344.1 244.16,48.27 v1(244.16,47.87) ; PR5105.1 248.98,42.53 248.47,43.04 R36.2 249.68,45.85 UC13.5 249.68,46.26 249.26,46.67 C9982.1 248.93,47.42 248.84,47.42 248.15,48.12 v1(247.84,48.12) ; R388.2 147.2,75.43 147.61,75.02 148.63,75.02 150.2,73.45 150.2,70.83 149.89,70.52 145.45,70.52 143.93,72.04 143.09,72.04 142.63,71.59 140.24,71.59 v1(139.63,70.98) 138.57,69.91 135.11,69.91 134.73,70.3 RC487.2 ; v4(52.3,93.59) 52.3,92.19 51.34,91.22 46.87,91.22 R9489.1 ; PR5262.2 231.66,41.14 231.76,41.24 PR5250.1 ; PR5262.2 230.2,41.68 230.2,42.42 v1(229.5,43.12) 228.97,43.12 228.71,43.37 228.71,45.53 228.48,45.76 R361.2 R359.2 ; PR5262.2 231.13,40.7 231.28,40.55 231.28,39.05 232.04,38.29 233.34,38.29 233.84,37.78 PU5202.5 233.84,36.92 233.28,36.36 PC5238.2 232.47,35.98 v1(232.28,35.98) 231.66,35.98 PR5255.2 ; R9399.1 83,39.29 83,39.94 82.59,40.35 v1(82.54,40.35) ; 220.75,61.86 220.41,61.52 220.41,59.91 220.91,59.4 220.91,58.26 221.14,58.03 221.83,58.03 R393.1 ; RP2.2 221.93,61.38 222.36,61.38 222.82,60.92 222.82,60.57 223.56,59.83 224.45,59.83 R345.1 R339.1 ; R9485.1 R391.1 v1(257.49,44.69) 257.49,44.31 257.8,44.01 R340.1 ; R9591.1 267.27,45.02 v1(267.27,44.69) ; R9407.1 R302.1 R286.1 ; R9407.1 250.81,56.2 250.51,56.5 250.12,56.5 249.95,56.68 R322.1 ; R9407.1 250.84,55.84 v1(251.42,55.84) 251.55,55.97 251.55,56.86 R292.1 ; R364.2 v1(246.19,47.87) ; PR5211.2 252.14,30.21 252.39,30.47 252.39,31.05 252.53,31.19 254.06,31.19 254.42,30.83 v1(255.74,30.83) ; R9463.1 R9466.1 R9688.1 251.85,48.36 v1(252.03,48.18) ; PR5304.2 191.4,59.13 v1(191.36,59.09) ; R9493.1 44.87,99.12 44.87,98.24 v1(44.66,98.03) ; R9668.2 v1(47.66,95.06)
  TOP w0.279: RP4811.6 266,63.5 ; RP4810.4 268.04,63.46
  TOP w0.305: JKB1.4 145.76,50.88 C376.1 144.91,49.84 144.37,49.3 143.73,49.3 138.64,54.39 135.17,54.39 130.95,58.61 126.25,58.61 123.52,61.34 123.52,63.15 123.99,63.62 123.99,64.03 C9985.1 ; JLID1.2 115.8,64.86 C1189.1
  TOP w0.356: R397.2 226.25,69.2 ; 226.25,69.2 225.99,69.46 223.8,69.46 UC11.5 222.65,69.54 220.18,69.54 219.82,69.17 U6218.5 219.23,68.84 219.06,68.67 219.06,67.6 218.5,67.04 217.24,67.04 216.83,66.63 216.83,66.19 217.21,65.8 219.49,65.8 220.38,64.91 ; 226.25,69.2 226.55,69.51 227.92,69.51 228.15,69.28 v1(228.15,68.49)
  TOP w0.381: v1(141.95,66.74) 141.64,66.74 137.47,62.57 129.9,62.57 128.44,64.04 128.44,65.2 127.81,65.82 R479.1 126.81,65.82 126.17,65.19 124.98,65.19 124.44,65.73 UC14.5 123.52,65.16 123.57,65.12 C9985.1 123.3,64.19 123.3,64.01 122.81,63.51 119.04,63.51 118.25,64.3 118.25,65.01 117.27,65.99 116.32,65.99 116.08,65.75 C1189.1
  TOP w0.406: v1(57.23,114.46) 57.23,114.2 UC12.5
  TOP w0.432: 256.6,63.59 256.13,64.06 255.52,64.06 255.08,63.62 ; 256.6,63.59 257.2,64.19 260.35,64.19 261.17,63.36 R9398.1 R9592.1 262.06,63.23 262.49,63.67 265.09,63.67 ; 256.6,63.59 R9408.1 ; C1002.1 259.64,4.75 259.65,4.76 R478.2 R432.2 261.17,3.93 261.52,3.58 262.56,3.58 v1(263.08,4.1) R9497.2 ; R428.1 v1(261.61,15.33) ; 255.08,63.62 254.34,64.35 250.99,64.35 250.75,64.59 249.69,64.59 249.52,64.41 249.52,64.28 249.26,64.02 ; 255.08,63.62 255.08,62.85 254.82,62.6 R288.1 ; R298.1 R9418.1 R9485.1 ; v1(168.51,34.15) 168.51,34.3 166.81,36.01 166.81,36.95 166.15,37.61 R9695.1
  TOP w0.483: RP4810.2 267.43,63.5 ; 269.14,63.51 RP4810.8
  TOP w0.508: v1(189.67,98.31) 190.09,98.31 UC10.5 ; 269.4,63.67 269.89,63.18 R282.1 269.89,58.48 270.65,57.72 270.65,55.84 271.33,55.16 271.33,53.58 270.93,53.18 270.93,52.67 ; v1(183.7,138.67) 183.89,138.48 C452.1 184.91,138.48 185.48,137.91 U22.2 ; R9500.1 181.42,84.62 v1(180.96,85.08) ; C376.1 v1(145.71,50.03) ; v1(183.7,51.17) 183.7,48.07 180.4,44.76 178.87,44.76 v1(178.45,44.34) ; 249.16,63.92 v1(249.16,63.28) ; 249.16,63.92 248.75,64.33 246.34,64.33 245.86,64.81 R402.2 244.91,65.23 244.34,65.79 PJP7.1 ; 249.16,63.92 249.26,64.02 ; C3083.1 180.96,130.15 v1(180.96,130.65)
  IN1 w0.254: v1(191.36,59.09) 191.36,58.17 192.87,56.66 v1(192.87,52.45) ; v1(235.65,68.19) 235.14,68.7 228.36,68.7 v1(228.15,68.49)
  IN1 w0.508: 170.63,122.51 171.67,122.51 172.37,121.81 175.04,121.81 176.66,123.43 178.75,123.43 179.11,123.08 181.4,123.08 181.76,123.43 181.76,124.26 180.84,125.18 180.84,130.53 v1(180.96,130.65) ; v1(168.51,34.15) 168.51,34 169.1,33.41 172.68,33.41 v1(172.96,33.69) ; v1(139.63,70.98) 139.44,70.98 139.04,70.58 139.04,70.05 141.46,67.63 141.46,67.22 v1(141.95,66.74) ; 170.24,121.91 170.3,121.97 ; v1(183.7,138.67) 183.7,141.03 185.96,143.29 185.96,148.4 186.47,148.91 v1(186.47,148.93)
  IN1 w1.27: 175.32,102.99 175.32,105.14 170.67,109.79 170.67,117.86 170.24,118.29 170.24,121.91
  IN2 w0.254: v1(183.7,51.17) 184.36,50.51 187.14,50.51 188.41,51.78 190.7,51.78 191.37,52.45 v1(192.87,52.45) ; v1(169.61,122.29) 168.72,123.18 166.91,123.18 165.87,124.22 163.29,124.22 163.07,124.44 163.07,125.12 162.47,125.72 162.47,128.77 161.48,129.76 161.48,130.43 161.48,130.43 161.48,130.54 160.59,131.43 160.59,131.94 160.97,132.32 161.35,132.32 161.61,132.58 161.61,135.12 161.1,135.62 159.95,135.62 158.3,137.28 157.29,137.28 156.65,137.91 154.16,137.91 153.65,138.42 151.4,138.42 150.89,137.91 144.46,137.91 144.11,137.56 143.69,137.56 142.65,137.56 142.05,138.16 142.05,139.31 141.29,140.07 139.13,140.07 134.17,145.02 119.06,145.02 v1(118.55,145.53) ; v1(152.94,101.92) 154.15,103.12 162.59,103.12 163.18,103.72 164.27,103.72 v1(164.32,103.67) ; v1(243.32,38.74) 243.32,38.11 241.67,36.46 232.78,36.46 232.29,35.98 v1(232.28,35.98) ; v1(235.65,68.19) 235.65,68.14 236.08,67.7 238.67,67.7 v1(239.18,68.21)
  IN2 w0.508: v1(160.89,66.15) 158.86,66.15 157.05,67.96 148.3,67.96 146.85,66.51 144.59,66.51 144.36,66.74 v1(141.95,66.74) ; v1(187.59,96.53) 188.17,95.95 188.17,86.87 187.53,86.22 182.1,86.22 v1(180.96,85.08) ; v1(171.74,36.28) v1(171.01,36.28) 171.01,36.24 170.04,35.27 169.02,35.27 168.51,34.76 v1(168.51,34.15) ; v1(186.47,148.93) 187.03,149.49 190.03,149.49 190.43,149.9 v1(190.43,151.04) ; 170.62,122.16 171.38,122.16 172.27,123.05 175.96,123.05 176.59,123.69 178.75,123.69 179.36,123.08 181.65,123.08 183.32,124.75 183.32,126.69 184.44,127.81 184.44,135.78 183.09,137.12 183.09,138.06 v1(183.7,138.67) ; v1(267.27,44.69) 267.27,44.72 266.67,45.31 258.11,45.31 v1(257.49,44.69) 256.58,45.61 253.3,45.61 252.76,45.07 252.76,45.06 252.4,44.7 252.4,44.7 252.39,44.69 v1(252.16,44.69) 251.9,44.69 251.39,45.2 251.39,46.93 v1(252.03,47.56)
  IN2 w0.635: 168.51,34.76 167.99,35.28 161.82,35.28 v1(161.24,34.7) 150.8,34.7 149.64,35.85 145.98,35.85 v1(144.89,36.95)
  IN3 w0.254: v1(180.96,85.08) 181.29,85.41 181.29,89.77 180.43,90.64 174.83,90.64 173.61,89.41 168.1,89.41 167.96,89.55 160.06,89.55 159.78,89.27 v1(159.78,89.02)
  IN3 w0.508: v1(270.53,52.44) 270.53,51.89 269.17,50.53 269.17,46.6 v1(267.27,44.69) ; v1(161.24,34.7) 158.98,34.7 148.19,45.49 148.17,45.5 147.03,45.5 145.26,47.27 145.26,49.59 v1(145.71,50.03)
  IN3 w1.524: 181.9,103.82 184.54,103.82
  IN4 w0.254: v1(144.89,36.95) 143.17,36.95 142.54,37.57 116.21,37.57 115.61,36.97 115.61,30.34 114.67,29.4 113.73,29.4 112.76,30.37 112.76,34.32 110.7,36.39 107.17,36.39 106.35,35.56 100.98,35.56 98.86,37.68 84.69,37.68 83.1,39.28 83.1,39.83 82.59,40.35 v1(82.54,40.35)
  IN4 w0.508: v1(53.27,128.13) 53.71,127.7 53.71,123.89 v1(54.54,123.05) ; v1(38.16,100.57) 39.07,100.57 40.02,99.63 v1(40.02,98.44) 40.02,97.7 40.56,97.16 43.79,97.16 v1(44.66,98.03) 45.68,97.02 45.71,97.02 v1(47.66,95.06) 48.37,94.35 51.54,94.35 v4(52.3,93.59) ; v1(263.08,4.1) 263.08,7.2 259.45,10.83 259.45,14.11 260.67,15.33 v1(261.61,15.33) 261.61,17.59 255.74,23.45 v1(255.74,30.83)
  BOTTOM w0.254: v1(118.55,145.53) 118.81,145.78 C9441.1 119.19,146.1 119.19,144.9 119.87,144.21 120.25,144.21 121.09,143.37 121.09,142.99 121.2,142.88 JGFX1.43 ; PR5102.2 167.75,34.66 168.01,34.66 v1(168.51,34.15) 168.77,33.9 168.77,31.86 PR5118.2 ; RC409.2 155.57,88.76 v1(155.64,88.7) ; v1(38.16,100.57) 38.03,100.71 JEDP1.40 ; PR5617.1 PR5616.1 165.67,107.3 v1(165.54,107.43) ; v1(40.02,98.44) R9416.2 ; v1(152.94,101.92) 152.89,101.97 152.89,103.26 153.34,103.71 C9457.1 154.23,103.71 154.39,103.87 R272.1
  BOTTOM w0.305: v1(176.46,101.72) 176.48,101.73 JIOR1.12 ; JIOR1.13 177.03,101.23 176.69,101.56
  BOTTOM w0.381: PR5622.2 176.34,102.55 v1(176.46,102.43) ; v1(173.26,71.44) 174.46,71.44 175.45,72.43 175.45,74.71 177.25,76.52 PR5606.1 PR5601.1 ; v1(166.81,77.25) 166.89,77.33 PR5611.2
  BOTTOM w0.457: v1(190.43,151.04) 190.43,150.66 RC623.2 ; v1(172.96,33.69) 172.96,33.49 172.07,32.6 PR5223.2
  BOTTOM w0.508: JSEC1.14 171.19,36.83 171.01,36.65 v1(171.01,36.28) ; v4(52.3,93.59) 52.3,94.51 52.89,95.1 U9.1 ; JSEC1.15 171.69,41.19 171.03,41.85 C9919.1 170.23,42.09 R2736.1 R196.1 170.14,43.5 170.37,43.73 v1(170.37,43.96) ; JSEC1.16 172.19,36.73 v1(171.74,36.28) ; v1(180.96,130.65) 180.94,130.67 180.22,130.67 179.68,130.13 179.68,128.53 179.15,128 JCSW2.2 ; v1(257.49,44.69) 257.49,42.84 256.73,42.07 256.73,40.85 257.62,39.96 257.62,37.68 v1(256.5,36.56) 256.37,36.44 256.37,31.46 v1(255.74,30.83) ; v1(249.16,63.28) 249.16,60.9 250.1,59.96 250.1,58.76 250.66,58.2 250.66,56.6 v1(251.42,55.84) 251.42,54.93 252.07,54.27 252.07,48.97 252.03,48.92 v1(252.03,48.18) v1(252.03,47.56)
  vias: v1(168.46,100.75) v1(168.89,100.31) v1(169.05,100.98) v1(170.11,122.67) v1(189.72,102.5) v1(189.72,101.74) v1(244.16,47.26) v2(189.19,100.53) v4(55.31,123.08) v4(57.82,123.54) v4(58.69,123.54) v4(187.68,98.53) v4(209.23,55.33) v4(209.23,54.47) v4(209.23,53.61) v4(209.23,52.74) v4(209.23,51.85) v4(210.12,55.33) v4(210.12,54.47) v4(210.12,53.61) v4(210.12,52.74) v4(210.12,51.85)
+3.3V_ALW2: length 136.2
  TOP w0.254: v1(204.05,29.48) 202.88,30.65 200.87,30.65 200.57,30.35 200.57,28.93 200.01,28.36 199.51,28.36 197.17,26.02 197.17,25.18 196.56,24.58 PR7405.2 ; R367.2 222.9,55.11 222.75,55.11 222.64,55 221.4,55 v1(220.91,55.49) ; v1(214.89,42.91) 215.07,43.09 PR5260.1
  TOP w0.381: PR5253.2 v1(225.79,44.12)
  TOP w0.508: v1(221.12,46.47) 221.12,47.61 221.62,48.11 221.62,49.2 220.94,49.87 220.94,52.26 220.42,52.78 220.42,54.74 220.91,55.23 v1(220.91,55.49)
  IN2 w0.508: v1(211.03,32.92) 178.11,32.92 176.31,34.71 171.05,34.71 170.8,34.46 v1(170.8,34.13)
  IN3 w0.254: v1(204.05,29.48) 204.05,30.44 206.53,32.92 v1(211.03,32.92)
  IN3 w0.508: v1(225.79,44.12) 223.85,42.18 215.63,42.18 v1(214.89,42.91)
  IN4 w0.508: v1(220.91,60.31) 219.61,59.01 213.42,59.01 212.53,59.9 201.74,59.9 v1(200.77,60.87)
  BOTTOM w0.508: v1(170.8,34.13) 170.31,34.62 C9921.1 R9575.1 ; v1(220.91,55.49) v1(220.91,60.31) ; v1(214.89,42.91) 214.89,39.66 212.86,37.63 211.67,37.63 210.25,36.21 210.25,33.71 v1(211.03,32.92) ; v1(225.79,44.12) 224.84,45.07 222.51,45.07 v1(221.12,46.47)
  vias: v2(200.47,61.66)
+3.3V_ALW2_R: length 8.2
  TOP w0.432: R9695.2 R9694.2 164.45,35.95 v1(164.27,36.13)
  BOTTOM w0.508: R9575.2 168.13,35.6 164.81,35.6 v1(164.27,36.13) 165.19,37.05 JSEC1.2
+3.3V_ALW_5048: length 64.9
  TOP w0.279: U37.A43 259.03,59.25 258.48,59.81 258.48,60.86 C332.1 ; U37.B30 264.52,55.58 v1(264.37,55.43) ; 267.07,49.57 266.8,49.83 U37.A17 ; C330.1 252.83,53.82 253.87,54.86 254.88,54.86 U37.A54 ; U37.B5 258.28,49.44 v1(258.23,49.49)
  TOP w0.508: v1(267.18,55.65) 267.43,55.65 C329.1 ; C330.1 253.15,53.39 v1(253.5,53.39) ; C332.1 259.14,61.27 v1(259.14,60.72) ; C331.1 v1(256.47,46.7)
  IN2 w0.508: v1(264.37,55.43) 264.59,55.65 v1(267.18,55.65) ; v1(268.41,48.76) 267.85,49.31 265.8,49.31 265.11,48.63 258.19,48.63 256.47,46.92 v1(256.47,46.7)
  IN3 w0.508: v1(254.11,44.23) 256.47,46.6 v1(256.47,46.7)
  IN4 w0.508: v1(253.5,53.39) 252.42,52.31 252.42,48.65 253.01,48.07 253.01,44.52 253.43,44.1 253.97,44.1 v1(254.11,44.23) ; v1(259.14,60.72) 259.98,61.56 262.06,61.56 262.49,61.12 262.49,56.79 263.14,56.15 263.86,56.15 264.37,55.64 v1(264.37,55.43)
  BOTTOM w0.508: v1(256.47,46.7) 256.47,47.11 258.23,48.86 v1(258.23,49.49) ; v1(268.41,48.76) 268.41,50.1 v2(269.58,51.27) 268.95,51.91 268.95,54.52 267.82,55.65 v1(267.18,55.65)
