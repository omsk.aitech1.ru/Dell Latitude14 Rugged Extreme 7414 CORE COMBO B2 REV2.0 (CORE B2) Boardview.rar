# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AUX_EN_WOWL: length 264.4
  TOP w0.108: v1(52.74,114.39) 52.74,114.87 v2(52.59,115.02) ; U37.B67 256.1,50.08 v1(256.22,50.2)
  IN2 w0.089: v1(52.74,114.39) 53.02,114.67 56.36,114.67 59.18,111.85 62.84,111.85 63.49,111.21 64.45,111.21 70.11,105.55 70.11,95.73 72.63,93.22 72.63,91.68 74.68,89.64 81.84,89.64 85.48,85.99 85.48,85.41 107.35,63.55 117.61,63.55 118.23,64.17 133.39,64.17 135.18,62.37 143.85,62.37 144.58,61.64 145.68,61.64 145.86,61.82 146.08,61.82 147.21,62.95 150.24,62.95 152.19,64.89 153.32,64.89 154.69,63.53 158.65,63.53 159.65,64.52 165.47,64.52 169.66,60.33 170.03,60.33 173.17,57.19 174.24,57.19 176.06,55.37 176.06,54.65 183.54,47.17 190.39,47.17 190.84,47.62 194.05,47.62 196.88,50.45 203.12,50.45 206.33,47.23 227.61,47.23 233.52,41.32 239.79,41.32 244.17,45.71 247.13,45.71 249.52,48.1 250.79,48.1 251.7,49.02 255.03,49.02 v1(256.22,50.2)
  BOTTOM w0.108: v1(52.74,114.39) 52.74,115.71 52.06,116.39 52.06,122.42 RC584.2 RC464.1
BAT1_LED#: length 95.2
  TOP w0.254: v1(228.66,50.79) 228.92,50.79 229.41,51.28 229.41,51.69 229.69,51.98 U38.B1 ; Q23.1 v1(261.44,11.93)
  IN1 w0.254: v1(228.66,50.79) 228.92,50.79 229.53,51.4 239.37,51.4 239.58,51.19 239.58,49.95 240.97,48.55 245.02,48.55 246.13,49.67 249.59,49.67 249.95,49.31 252.21,49.31 253.2,50.31 253.64,50.31 254.03,50.7 261.96,50.7 262.32,50.34 262.32,49.56 262.8,49.07 265.09,49.07 265.67,49.65 270.7,49.65 271.46,50.41 v1(271.59,50.41)
  IN3 w0.254: v1(271.59,50.41) 271.84,50.41 272.1,50.15 272.1,47.61 271.46,46.98 271.46,42.47 270.06,41.07 270.06,20.54 v1(261.44,11.93)
  BOTTOM w0.254: v1(261.44,11.93) 261.44,11.93 261.44,12.29 v2(260.98,12.75)
BAT1_LED#_Q: length 3.4
  TOP w0.254: Q23.6 261.44,11.2 261.61,11.37 R431.1 262.95,10.58 v2(262.75,10.38)
BAT2_LED#: length 112.1
  TOP w0.254: v1(227.9,57.39) 227.91,57.38 U38.A55 ; Q23.4 v1(260.14,11.34)
  IN1 w0.254: v1(228.03,63.31) 228.61,63.89 230.95,63.89 231.56,64.5 233.23,64.5 233.46,64.28 236.03,64.28 236.21,64.45 243.39,64.45 245.56,62.28 252.78,62.28 253.02,62.52 257.5,62.52 257.9,62.92 262.1,62.92 262.67,63.49 v1(270.57,63.49)
  IN3 w0.254: v1(260.14,11.34) 260.14,12.39 260.72,12.97 261.77,12.97 269.71,20.91 269.71,41.29 270.95,42.53 270.95,50.92 271.41,51.37 271.41,55.91 269.94,57.37 269.94,62.86 v1(270.57,63.49)
  BOTTOM w0.254: v2(259.31,11.34) v1(260.14,11.34) ; v1(228.03,63.31) 229.01,62.33 229.01,59.03 228.62,58.64 228.62,58.11 v1(227.9,57.39)
BAT2_LED#_Q: length 3.2
  TOP w0.254: R427.1 258.76,13.53 v2(258.74,13.55) 258.93,13.75 259.96,13.75 260.14,13.57 Q23.3
BAT_ALERT_D: length 9.1
  TOP w0.108: JBAT_PK2.3 v5(210.43,114.4)
  BOTTOM w0.108: JBAT_PK1.9 213.13,113.4 JBAT_PK2.3
BAT_CON_IO:
  vias: v1(211.42,104.55) v1(211.42,103.93) v1(211.42,103.27) v1(211.42,102.63) v1(211.42,102) v1(212.05,104.55) v1(212.05,103.93) v1(212.05,103.27) v1(212.05,102.63) v1(212.05,102) v1(212.66,103.42) v5(210.45,103.5)
BATDRV#: length 4.2
  TOP w0.508: PQ5219.4 162.62,25.03 162.98,25.39 v4(163.59,25.39)
  BOTTOM w0.508: PR5247.2 164.76,24.63 164.58,24.45 v2(163.97,24.45) 163.59,24.83 v4(163.59,25.39)
BATDRV#_R: length 93.5
  TOP w0.216: v1(236.57,35.55) 236.66,35.46 PU5201.18
  IN3 w0.508: v1(236.48,24.15) 236.47,24.15 235.9,24.71 234.35,24.71 233.85,25.21 232.9,25.21 230.85,23.15 210.78,23.15 207.99,25.95 199.3,25.95 197.88,24.52 195.49,24.52 194.47,25.54 184.87,25.54 182.21,22.87 v1(181.93,22.87)
  IN4 w0.508: v1(236.57,35.55) 236.57,31.78 238.16,30.19 238.16,26.08 236.48,24.41 v1(236.48,24.15)
  BOTTOM w0.457: 172.73,24.63 172.79,24.63 174.52,26.36 174.52,26.36 174.63,26.49 176.04,27.89 176.08,27.93 179.51,27.93 182.54,24.91 182.54,23.23 182.18,22.87 v1(181.93,22.87)
  BOTTOM w0.508: PR5247.1 v2(168.29,24.63) 172.73,24.63
BATT_GREEN_LED#: length 7.2
  TOP w0.254: R427.2 v2(258.76,10.76) 258.81,10.71 259.4,10.71 259.65,10.45 259.65,9.99 260,9.64 261.63,9.64 261.91,9.92 v1(262.14,9.92)
  BOTTOM w0.254: v1(262.14,9.92) 261.94,9.92 261.68,9.66 JLED1.8
BATT_ORANGE_LED#: length 5.9
  TOP w0.254: R431.2 262.65,11.93 v1(262.34,11.93)
  BOTTOM w0.254: JLED1.9 261.18,10.76 v1(262.34,11.93) 262.75,12.33 v2(262.75,12.76)
BATTERY_GND: length 72.3
  TOP w0.508: 212.94,116.4 JBAT_PK2.2 215.31,116.4 ; 212.94,118.4 JBAT_PK2.1 ; JBAT_PK2.1 215.31,118.4 ; JBAT_PK2.1 214.13,119.58 ; 211.78,99.28 JBAT_PK2.11 214.13,100.7 ; 211.78,121.53 JBAT_PK2.10 214.13,120.1
  IN1 w0.508: 211.86,99.28 JBAT_PK2.11 214.13,100.61 ; JBAT_PK2.1 215.22,118.4 ; JBAT_PK2.1 214.13,119.49 ; JBAT_PK2.1 213.03,118.4 ; 211.86,121.53 JBAT_PK2.10 214.13,120.19 ; 213.03,116.4 JBAT_PK2.2 215.22,116.4
  IN2 w0.508: 211.86,99.28 JBAT_PK2.11 214.13,100.61 ; 213.03,118.4 JBAT_PK2.1 ; JBAT_PK2.1 214.13,119.49 ; JBAT_PK2.1 215.22,118.4 ; 211.86,121.53 JBAT_PK2.10 214.13,120.19 ; 213.03,116.4 JBAT_PK2.2 215.22,116.4
  IN3 w0.508: 214.13,100.61 JBAT_PK2.11 211.86,99.28 ; 211.86,121.53 JBAT_PK2.10 214.13,120.19 ; 213.03,116.4 JBAT_PK2.2 215.22,116.4 ; JBAT_PK2.1 215.22,118.4 ; JBAT_PK2.1 214.13,119.49 ; JBAT_PK2.1 213.03,118.4
  IN4 w0.508: JBAT_PK2.1 215.14,118.4 ; JBAT_PK2.1 213.11,118.4 ; JBAT_PK2.1 214.13,119.42 ; 214.13,100.53 JBAT_PK2.11 211.94,99.28 ; 215.14,116.4 JBAT_PK2.2 213.11,116.4 ; 214.13,120.27 JBAT_PK2.10 211.94,121.53
  BOTTOM w0.508: 213.03,118.4 JBAT_PK2.1 ; JBAT_PK2.1 215.22,118.4 ; JBAT_PK2.1 214.13,119.49 ; 211.94,121.53 JBAT_PK2.10 214.13,120.27 ; 215.22,116.4 JBAT_PK2.2 213.03,116.4
  vias: v1(204.81,127.19) v1(204.84,126.05) v1(204.86,124.58) v1(204.86,122.95) v1(204.86,121.1) v1(204.99,99.93) v1(204.97,98.11) v1(204.92,96.36) v1(204.99,94.17) v1(205.88,121.97) v1(205.88,121.15) v1(205.88,120.26) v1(206.01,127.12) v1(205.98,126.03) v1(205.93,124.58) v1(205.93,123) v1(206.08,100.21) v1(206.08,99.48) v1(206.08,98.75) v1(206.26,97.27) v1(206.26,95.24) v1(206.31,93.51) v1(206.62,121.97) v1(206.62,121.15) v1(206.62,120.26) v1(206.85,100.21) v1(206.85,99.48) v1(206.85,98.75) v1(207.38,121.97) v1(207.38,121.15) v1(207.38,120.26) v1(207.58,100.21) v1(207.58,99.48) v1(207.58,98.75) v1(208.12,121.97) v1(208.12,121.15) v1(208.12,120.26) v1(208.34,100.21) v1(208.34,99.48) v1(208.34,98.75) v1(208.88,121.97) v1(208.88,121.15) v1(208.88,120.26) v1(209.06,100.21) v1(209.06,99.48) v1(209.06,98.75) v1(209.59,121.97) v1(209.59,121.15) v1(209.59,120.26) v1(209.82,100.21) v1(209.82,99.48) v1(209.82,98.75) v1(210.35,121.97) v1(210.35,121.15) v1(210.35,120.26) v1(210.58,100.21) v1(210.58,99.48) v1(210.58,98.75) v1(211.16,121.1) v1(212.38,119.72) v1(212.38,118.56) v1(212.35,117.59) v1(212.71,115.38) v1(212.96,109.44) v1(213.04,111.37) v1(213.5,119.88) v1(215.35,113.4) v1(215.38,109.44) v1(215.41,105.35) v1(215.43,119.38) v1(215.46,117.72) v1(215.46,115.64) v1(215.43,111.37) v1(215.43,107.43) v1(215.51,103.32) v5(210.12,118.86) v8(205.91,119.62) v8(205.91,118.81) v8(205.91,118) v8(205.91,117.19) v8(205.91,116.37) v8(205.91,115.56) v8(205.91,114.75) v8(205.91,113.94) v8(205.91,113.05) v8(205.91,112.23) v8(205.91,111.42) v8(205.91,110.61) v8(205.91,109.79) v8(205.91,108.98) v8(205.91,108.17) v8(205.91,107.36) v8(205.91,106.59) v8(205.91,105.78) v8(205.91,104.97) v8(205.91,104.16) v8(205.91,103.34) v8(205.91,102.53) v8(205.91,101.72) v8(205.91,100.9) v8(206.72,119.62) v8(206.72,118.81) v8(206.72,118) v8(206.72,117.19) v8(206.72,116.37) v8(206.72,115.56) v8(206.72,114.75) v8(206.72,113.94) v8(206.72,113.05) v8(206.72,112.23) v8(206.72,111.42) v8(206.72,110.61) v8(206.72,109.79) v8(206.72,108.98) v8(206.72,108.17) v8(206.72,107.36) v8(206.72,106.59) v8(206.72,105.78) v8(206.72,104.97) v8(206.72,104.16) v8(206.72,103.34) v8(206.72,102.53) v8(206.72,101.72) v8(206.72,100.9) v8(207.53,119.62) v8(207.53,118.81) v8(207.53,118) v8(207.53,117.19) v8(207.53,116.37) v8(207.53,115.56) v8(207.53,114.75) v8(207.53,113.94) v8(207.53,113.05) v8(207.53,112.23) v8(207.53,111.42) v8(207.53,110.61) v8(207.53,109.79) v8(207.53,108.98) v8(207.53,108.17) v8(207.53,107.36) v8(207.53,106.59) v8(207.53,105.78) v8(207.53,104.97) v8(207.53,104.16) v8(207.53,103.34) v8(207.53,102.53) v8(207.53,101.72) v8(207.53,100.9) v8(208.34,119.62) v8(208.34,118.81) v8(208.34,118) v8(208.34,117.19) v8(208.34,116.37) v8(208.34,115.56) v8(208.34,114.75) v8(208.34,113.94) v8(208.34,113.05) v8(208.34,112.23) v8(208.34,111.42) v8(208.34,110.61) v8(208.34,109.79) v8(208.34,108.98) v8(208.34,108.17) v8(208.34,107.36) v8(208.34,106.59) v8(208.34,105.78) v8(208.34,104.97) v8(208.34,104.16) v8(208.34,103.34) v8(208.34,102.53) v8(208.34,101.72) v8(208.34,100.9) v8(209.16,119.62) v8(209.16,118.81) v8(209.16,118) v8(209.16,117.19) v8(209.16,116.37) v8(209.16,115.56) v8(209.16,114.75) v8(209.16,113.94) v8(209.16,113.05) v8(209.16,112.23) v8(209.16,111.42) v8(209.16,110.61) v8(209.16,109.79) v8(209.16,108.98) v8(209.16,108.17) v8(209.16,107.36) v8(209.16,106.59) v8(209.16,105.78) v8(209.16,104.97) v8(209.16,104.16) v8(209.16,103.34) v8(209.16,102.53) v8(209.16,101.72) v8(209.16,100.9)
BC_CLK_ECE1117: length 163.8
  TOP w0.108: v1(147.84,51.32) 148.32,51.8 148.32,52.92 147.86,53.38 JKB1.9 ; U38.A20 v1(240.27,54.38)
  IN1 w0.089: v1(151.98,32.54) 150.12,34.4 150.12,45.68 149.36,46.44 149.36,47.82 147.84,49.34 v1(147.84,51.32)
  IN4 w0.089: v1(245.17,24.12) 245.04,23.99 243.27,23.99 241.6,22.33 223.7,22.33 220.18,25.85 203.02,25.85 200.56,28.31 197.23,28.31 194.79,30.75 178.7,30.75 178.16,31.3 173.63,31.3 173.09,30.75 172.6,30.75 170.07,28.22 167.65,28.22 165.59,30.27 156.73,30.27 153.76,33.24 152.68,33.24 v1(151.98,32.54)
  BOTTOM w0.108: v1(245.17,24.12) 245,24.29 245,27.98 v2(245.25,28.22) 245.25,28.36 245,28.6 245,35.72 244.65,36.07 244.65,37.91 244.65,39.35 242.48,41.52 242.48,47.4 244.69,49.62 244.69,50.97 243.49,52.17 240.21,52.17 239.3,53.08 239.3,54.19 239.49,54.38 v1(240.27,54.38)
BC_CLK_ECE5048: length 54.5
  TOP w0.108: v1(266.38,56.5) 266.21,56.33 U37.A30 ; U38.A43 232.75,62.6 v1(232.81,62.66)
  IN1 w0.089: v1(266.38,56.5) 265.52,55.64 264.98,55.64 264.88,55.74 264.88,56.3 265.67,57.09 270.45,57.09 271.53,58.17 271.53,59.54 270.55,60.52 265.13,60.52 264.12,61.53 258.96,61.53 258.69,61.25 253.55,61.25 252.66,60.36 252.31,60.36 252.03,60.64 249.76,60.64 249.66,60.74 242.88,60.74 241.85,61.78 233.69,61.78 v1(232.81,62.66)
  BOTTOM w0.108: v1(232.81,62.66) 232.81,62.15 v2(232.62,61.96)
BC_DAT_ECE1117: length 163.8
  TOP w0.108: v1(147.84,51.93) 147.84,52.25 147.72,52.38 JKB1.7 ; v1(244.28,50.41) 244.38,50.31 R344.2 ; U38.B21 238.15,54.13 v1(237.91,54.37)
  IN1 w0.089: v1(152.59,32.54) 150.43,34.69 150.43,45.78 149.66,46.56 149.66,48.02 148.59,49.09 148.59,51.51 148.17,51.93 v1(147.84,51.93)
  IN4 w0.089: v1(152.59,32.54) 153,32.95 153.64,32.95 156.61,29.98 165.47,29.98 167.52,27.93 170.19,27.93 172.72,30.46 173.21,30.46 173.75,31.01 178.02,31.01 178.56,30.46 194.67,30.46 197.11,28.02 200.44,28.02 202.9,25.56 220.06,25.56 223.58,22.04 241.72,22.04 243.39,23.7 244.96,23.7 v1(245.17,23.48)
  BOTTOM w0.108: v1(245.17,23.48) 244.69,23.96 244.69,25.93 v2(244.51,26.11) 244.69,26.29 244.69,35.52 244.34,35.88 244.34,39.22 242.17,41.39 242.17,47.53 244.28,49.65 v1(244.28,50.41) 244.28,50.94 243.36,51.86 240.08,51.86 238.99,52.95 238.99,54.18 238.8,54.37 v1(237.91,54.37)
BC_DAT_ECE5048: length 61.8
  TOP w0.108: R343.2 235.27,66.36 v1(235.27,66.03) ; U38.B45 233,61.06 233.23,60.82 233.23,60.45 v1(233.47,60.21) ; v1(263.74,55.41) 264.41,56.08 U37.B31
  IN1 w0.089: v1(233.47,60.21) 233.47,61.31 233.76,61.6 241.77,61.6 242.81,60.57 249.57,60.57 249.67,60.47 251.95,60.47 252.23,60.19 252.77,60.19 253.66,61.08 258.76,61.08 259.03,61.35 264.05,61.35 265.06,60.34 270.48,60.34 271.35,59.46 271.35,58.24 270.38,57.27 265.59,57.27 v1(263.74,55.41)
  IN4 w0.089: v1(233.47,60.21) 233.94,60.68 233.94,63.79 234,63.87 234.88,64.76 234.88,65.65 v1(235.27,66.03)
  BOTTOM w0.108: v2(263.07,55.41) v1(263.74,55.41)
BC_INT#_ECE1117: length 157.5
  TOP w0.108: JTP1.4 140.6,60.67 139.94,60.01 139.94,57.34 144.03,53.25 144.89,53.25 v1(145.68,52.46) 145.68,52.21 146.01,51.88 JKB1.6 ; v1(240.9,54.34) 240.53,53.97 239.94,53.97 239.85,53.88 U38.A19
  IN2 w0.089: v1(145.68,52.46) 145.68,51.12 149.64,47.16 149.64,43.94 155.8,37.78 171.89,37.78 174.54,35.14 176.49,35.14 178.28,33.34 219.03,33.34 221.4,30.98 227.82,30.98 229.36,29.43 240.3,29.43 241.05,30.18 245.04,30.18 v1(245.47,29.76)
  BOTTOM w0.108: v1(245.47,29.76) 245.65,29.93 245.65,32.86 245.48,33.03 245.48,38.02 245.09,38.41 245.09,39.99 243.1,41.98 243.1,44.64 243.72,45.26 243.72,45.28 v2(244.31,45.87) 244.63,46.19 244.63,48.93 245.13,49.44 245.13,51.12 243.52,52.73 242.31,52.73 241.69,53.36 241.69,54.22 241.53,54.38 240.94,54.38 v1(240.9,54.34)
BC_INT#_ECE5048: length 43.2
  TOP w0.108: U38.A42 233.25,62.83 v1(232.81,63.27) ; v1(267.14,56.5) 266.47,55.83 U37.A29
  IN3 w0.089: v1(267.14,56.5) 265.19,58.45 250.85,58.45 249.03,60.27 244.96,60.27 243.67,61.56 243.67,63.21 242.5,64.38 236.38,64.38 234.99,62.99 233.09,62.99 v1(232.81,63.27)
  BOTTOM w0.108: v2(267.45,57.11) 267.14,56.81 v1(267.14,56.5)
BCM5882_ALERT#: length 107
  TOP w0.108: U37.B62 v1(256.22,52.58)
  IN3 w0.089: v1(255.46,43.04) 255.43,43.01 253.22,43.01 252.54,43.7 247.58,43.7 247.05,43.17 245.98,43.17 244.89,42.08 240.29,42.08 239.25,41.03 234.53,41.03 231.21,44.35 227.19,44.35 226.49,45.05 222.94,45.05 221.79,43.91 216.03,43.91 215.9,44.04 212.41,44.04 211.8,43.42 204.17,43.42 202.51,41.77 180,41.77 178.77,43 170.66,43 v1(169.71,43.96)
  IN4 w0.089: v1(256.22,52.58) 255.47,51.83 255.47,49.53 255.39,49.46 255.39,46.03 256.09,45.33 256.09,44.05 255.46,43.42 v1(255.46,43.04)
  BOTTOM w0.108: v1(169.71,43.96) 169.71,43.63 169.7,43.63 169.7,41.88 170.69,40.89 JSEC1.13 ; v2(256.22,51.92) v1(256.22,52.58)
BEEP: length 294.3
  TOP w0.127: v1(52.03,125.59) 52.03,125.97 v2(51.55,126.45) 51.27,126.73 50.48,126.73 ; U38.B19 237.67,53.13 237.27,53.53 v1(237.27,53.71)
  IN3 w0.127: v1(52.03,125.59) 52.45,126.01 55.78,126.01 56.27,125.51 58.73,125.51 60.58,127.37 63.05,127.37 65.47,129.78 65.47,138.77 69.45,142.76 71.08,142.76 71.75,143.43 75.78,143.43 77.37,145.02 82.87,145.02 83.25,145.4 85.41,145.4 87.37,143.43 92.55,143.43 95.31,146.2 95.31,146.65 95.94,147.28 96.99,147.28 v1(97.12,147.16)
  IN4 w0.127: v1(237.04,58.56) 236.26,57.77 232.6,57.77 231.96,57.14 228.79,57.14 228.62,56.97 225.77,56.97 224.33,58.41 224.08,58.41 221.22,61.27 218.44,61.27 216.75,62.95 208.82,62.95 207.07,61.2 201.48,61.2 200.58,62.1 194.87,62.1 193.58,63.39 187.45,63.39 182.93,67.91 182.15,67.91 181.7,68.36 181.7,69.87 182.13,70.3 187.65,70.3 188.21,70.86 188.21,90.17 187.87,90.51 187.87,95.05 188.48,95.66 188.48,100.56 188.21,100.83 188.21,105.16 183.27,110.1 181.9,110.1 180.12,111.88 177.53,111.88 175.56,113.85 175.56,118.19 174.31,119.44 169.44,119.44 164.92,123.97 163.35,123.97 163.04,124.28 163.04,124.87 160.37,127.53 160.37,129.63 158.48,131.52 158.48,134.64 155.67,137.45 154.42,137.45 153.36,138.51 148.01,138.51 147.73,138.78 144.34,138.78 143.26,139.87 139.2,139.87 136.69,142.37 136.69,142.56 134.06,145.2 133.55,145.2 132.66,146.1 126.04,146.1 123.59,148.54 117.12,148.54 113.73,145.15 98.36,145.15 97.12,146.39 v1(97.12,147.16)
  BOTTOM w0.127: v1(237.04,58.56) 236.51,58.03 236.51,54.47 v1(237.27,53.71)
BIA_PWM: length 21.9
  TOP w0.108: v2(48.78,113.3) v1(48.78,112.66)
  IN1 w0.089: v1(50,97.98) 50,99.03 49.22,99.81 49.22,112.22 v1(48.78,112.66)
  BOTTOM w0.108: R9696.1 45.86,112.1 46.42,112.66 v1(48.78,112.66) ; R95.2 C9986.1 ; C9986.1 50.4,97.58 v1(50,97.98) ; C9986.1 LE1.2
BIA_PWM_EC: length 299.9
  TOP w0.108: v1(236.94,56.22) 237.35,55.81 237.94,55.81 238.26,56.13 U38.B25
  IN1 w0.089: v1(47.1,91.99) 48.46,93.34 48.46,96.11 48.7,96.35 48.7,97.66 48.56,97.8 48.56,99.87 48.83,100.14 48.83,111.62 48.19,112.26 48.19,112.81 49.23,113.85 49.78,113.85 v1(50.12,113.5)
  IN2 w0.089: v1(247.84,53.84) 247.68,53.68 243.81,53.68 243.41,54.07 242.91,54.07 241.53,55.44 239.37,55.44 239.05,55.77 237.4,55.77 v1(236.94,56.22) ; v1(252.66,39.1) 251.93,39.84 242.7,39.84 241.91,39.05 241.91,38.17 241.26,37.51 228.64,37.51 226.6,35.46 204.74,35.46 203.43,36.77 179.74,36.77 177.82,38.7 174.85,38.7 171.95,41.6 157.95,41.6 152.98,46.57 152.98,48.16 150.65,50.49 150.65,53.34 147.97,56.02 146.14,56.02 144.85,57.3 135.76,57.3 133.51,59.55 133.49,59.55 133.14,59.89 106.64,59.89 88.4,78.13 78.59,78.13 75.11,81.62 75.11,85.27 73.92,86.46 73.26,86.46 69.99,89.73 69.13,89.73 68.2,90.66 68.2,91.35 63.66,95.89 58.29,95.89 58,95.59 54.34,95.59 52.86,94.11 50.33,94.11 49.65,93.43 48.55,93.43 v1(47.1,91.99)
  IN4 w0.089: v1(247.84,53.84) 248.35,53.84 249.07,53.11 249.07,44.6 250.08,43.59 250.08,43.49 251.84,41.73 251.84,40.69 252.66,39.87 v1(252.66,39.1)
  BOTTOM w0.108: v1(50.12,113.5) 50.46,113.5 50.68,113.27 50.68,112.17 51.09,111.76 52.51,111.76 ; v2(247.25,54.19) 247.61,53.84 v1(247.84,53.84)
BIA_PWM_EC_EN#: length 299.5
  TOP w0.108: U37.B55 256.06,56.08 v1(256.2,55.94)
  IN2 w0.089: v1(190.15,95.73) 190.43,96.01 190.43,104.23 189.48,105.18 189.48,105.76 185.96,109.28 185.96,112.08 184.55,113.49 183.65,113.49 182.43,112.28 177.7,112.28 175.45,114.53 175.45,116.69 174.68,117.46 170.44,117.46 170.05,117.84 166.46,117.84 164.74,119.56 162.42,119.56 159.48,122.5 159.48,123.54 158.15,124.88 158.15,124.9 153.8,129.26 142.91,129.26 134.25,137.91 126.68,137.91 125.54,139.05 122.91,139.05 122.03,139.93 122.03,140.15 120,142.18 118.93,142.18 118.43,142.69 105.88,142.69 103.68,144.89 96.32,144.89 95.03,143.6 95.03,138.96 94.67,138.6 91.27,138.6 90.94,138.93 76.71,138.93 73.09,135.3 73.09,132.93 71.89,131.74 71.89,129.7 69.69,127.5 67.37,127.5 64.76,124.89 60.48,124.89 59.72,125.65 59.18,125.65 58.17,124.64 57.24,124.64 56.79,124.19 55.12,124.19 53.43,122.51 53.43,118.75 53.62,118.56 53.62,117.3 53.23,116.9 v1(52.51,116.9)
  IN3 w0.089: v1(205.24,64.33) 204.84,63.93 200.16,63.93 195.62,68.47 192.77,68.47 191.58,69.65 191.58,70.1 191.02,70.66 191.02,76.72 189.73,78.01 189.73,84.32 191.01,85.61 191.01,89.99 190.15,90.85 v1(190.15,95.73)
  IN4 w0.089: v1(251.93,61.08) 251.04,61.96 248.47,61.96 246.77,63.67 245.43,63.67 239.68,69.41 218.31,69.41 213.45,64.55 207.17,64.55 206.82,64.21 205.36,64.21 v1(205.24,64.33)
  BOTTOM w0.108: v1(190.15,95.73) 190.43,96.01 v2(190.43,96.36) ; v1(251.93,61.08) 251.93,60.72 253.05,59.6 253.05,58.03 255.13,55.94 v1(256.2,55.94) ; 52.51,113.66 53.44,113.66 53.73,113.96 53.73,115.69 v1(52.51,116.9)
BIA_PWM_EC_Q: length 2.3
  BOTTOM w0.108: Q4214.3 49.77,112.71 49.32,113.16 49.32,113.72 49.24,113.8 D7123.2
BIA_PWM_R: length 3.6
  BOTTOM w0.108: D7123.3 47.76,110.5 47.48,110.22 46.11,110.22 45.86,110.48 R9696.2
BIA_PWM_SOC_EN#: length 309.7
  TOP w0.108: v1(253.88,55.83) U37.A52 ; v2(46.87,113.4) 47.01,113.53 v1(47.76,113.53)
  IN2 w0.089: v1(47.76,113.53) 48.46,113.53 51.17,116.24 52.82,116.24 55.8,119.22 55.8,119.23 55.87,119.3 55.87,123.16 56.6,123.89 56.74,123.89 57.32,124.47 58.25,124.47 59.25,125.47 59.63,125.47 60.4,124.71 64.84,124.71 67.45,127.32 69.77,127.32 73.98,131.53 73.98,135.73 76.86,138.62 90.9,138.62 91.1,138.42 94.75,138.42 95.21,138.89 95.21,143.53 96.39,144.71 102.02,144.71 104.88,141.85 107.76,141.85 108.2,142.29 118.46,142.29 118.75,142.01 119.92,142.01 121.78,140.15 121.78,139.94 122.92,138.8 125.39,138.8 126.55,137.63 134.1,137.63 142.65,129.08 153.73,129.08 157.97,124.83 157.97,124.8 159.31,123.47 159.31,122.42 162.34,119.39 164.66,119.39 166.38,117.67 169.94,117.67 170.32,117.28 174.61,117.28 175.25,116.64 175.25,114.48 177.63,112.1 182.56,112.1 183.7,113.24 184.45,113.24 185.79,111.9 185.79,109.21 189.14,105.86 189.14,97.12 189.72,96.53 v1(189.72,96.19)
  IN3 w0.089: v1(206.34,65.09) 206.34,64.5 205.59,63.75 200.08,63.75 195.54,68.29 192.69,68.29 191.4,69.58 191.4,70.03 190.84,70.59 190.84,76.65 189.55,77.94 189.55,84.4 190.83,85.68 190.83,89.91 189.97,90.78 189.97,95.09 189.72,95.34 v1(189.72,96.19)
  IN4 w0.089: v1(254.26,58.03) 254.06,57.82 254.06,56 v1(253.88,55.83) ; v1(252.49,60.77) 252.49,61.63 251.83,62.29 248.6,62.29 246.59,64.3 245.76,64.3 242.07,67.98 241.36,67.98 239.76,69.59 218.23,69.59 213.45,64.81 206.62,64.81 v1(206.34,65.09)
  BOTTOM w0.108: v1(254.26,58.03) 254.26,60.44 253.75,60.95 252.56,60.95 252.49,60.87 v1(252.49,60.77) ; v1(47.76,113.53) 47.59,113.35 47.59,113.27 47.36,113.04 46.21,113.04 45.27,112.1 45.27,110.96 44.92,110.61 42.68,110.61 41.99,111.3 Q4213.1
BLUE_CRT: length 25.8
  TOP w0.089: 83.63,129.03 U6.M8
  TOP w0.108: 83.63,129.03 83.31,129.03 C9917.1 82.08,128.72 80.86,128.72 78.09,131.48 73.92,131.48 73.31,132.1 v1(73.02,132.1)
  BOTTOM w0.108: L3.1 C12.1 R2744.2 77.53,139.69 v2(76.46,138.62) 76.06,138.22 76.06,138.22 73.98,136.13 73.98,132.39 73.69,132.1 73.02,132.1 v1(73.02,132.1)
BLUE_CRT_L: length 13
  BOTTOM w0.108: JCRT1.3 83.65,150 83.65,146.77 83.49,146.61 D66.1 81.58,146.61 81.32,146.34 81.32,144.44 80.2,143.32 v2(79.92,143.32) 79.44,143.32 79.37,143.38 C15.1 L3.2
BOARD_ID: length 36.9
  TOP w0.108: U38.B10 234.5,52.69 v1(235.01,53.2) ; R392.2 245.73,36.51 245.68,36.56 C368.1 246.14,37.02 246.31,37.2 v1(246.31,38.72)
  IN1 w0.089: v1(246.31,38.72) 250.43,42.84 251.34,42.84 v1(251.74,43.25) ; v1(235.01,53.2) 235.49,52.72 235.49,52.5 235.89,52.11 243.11,52.11 243.53,51.68 246.9,51.68 247.55,51.03 248.79,51.03 250.09,49.73 250.75,49.73 v1(251.04,50.02)
  BOTTOM w0.108: v2(251.52,44.03) 251.52,44.03 ; 251.52,44.03 251.74,43.81 v1(251.74,43.25) ; 251.52,44.03 251.52,44.03 251.34,44.21 251.34,46.07 251.16,46.26 251.16,46.62 251.34,46.8 251.34,49.71 v1(251.04,50.02)
BQ24777_REGN: length 49.8
  TOP w0.203: PU5201.24 233.98,33.41 233.67,33.59 232.89,34.37 PC5227.1 232.89,34.69 v1(233.64,35.44) 234.2,36.01 PR5242.1
  TOP w0.254: v1(252.66,29.2) 252.54,29.33 PR5204.2 ; v1(254.77,29.22) PR5214.2 ; v1(240.33,38.72) 240.33,38.98 239.75,39.56 PR5245.2 ; PR5221.1 241.44,26.57 v1(241.03,26.16) ; PR5216.2 247.61,32.33 247.97,31.98 247.97,31.36 248.52,30.8 v1(248.52,29.33)
  IN3 w0.254: v1(241.03,26.16) 241.78,26.91 247.5,26.91 248.52,27.93 v1(248.52,29.33) 252.54,29.33 v1(252.66,29.2) 254.75,29.2 v1(254.77,29.22)
  BOTTOM w0.254: v1(241.03,26.16) v2(241.03,27.34) 241.03,28.39 240.75,28.66 240.75,30.75 241.03,31.03 241.03,37.76 240.33,38.46 v1(240.33,38.72) 239.71,38.72 239.58,38.59 239.58,38.05 238.9,37.38 238.29,37.38 237.04,36.13 234.33,36.13 v1(233.64,35.44)
BREATH_GREEN_LED#: length 215.5
  TOP w0.254: R9645.2 v1(264.81,9.26)
  IN1 w0.254: v1(248.85,59.42) 249.13,59.14 255.08,59.14 255.5,58.73 270.38,58.73 v1(270.95,59.3)
  IN3 w0.254: v1(263.21,9.89) 263.84,10.53 263.84,13.81 270.4,20.37 270.4,40.93 271.8,42.33 271.8,46.81 272.54,47.55 272.54,55.26 270.47,57.33 270.47,58.81 v1(270.95,59.3)
  IN4 w0.254: v1(178.55,88.75) 178.52,88.75 178.05,88.28 178.05,86.81 178.51,86.35 178.59,86.35 180.17,84.77 180.17,76.33 176.97,73.13 176.97,64.75 181.67,60.05 181.67,58.46 183.2,56.94 183.2,56.35 183.66,55.89 186.46,55.89 188.72,53.63 198.31,53.63 202.47,49.47 213.58,49.47 214.39,48.65 217.58,48.65 217.81,48.43 220.57,48.43 v1(221.01,48.87)
  BOTTOM w0.254: v1(178.55,88.75) 178.53,88.73 JIOR1.38 ; v1(248.85,59.42) 247.18,61.1 247.1,61.1 244.61,63.58 244.61,63.95 240.88,67.68 239.03,67.68 238.01,68.7 229.37,68.7 227.75,67.08 223.69,67.08 223.26,66.65 223.26,65.58 221.91,64.22 221.91,62.32 219.59,60.01 219.59,55.6 220.2,54.98 220.2,52.46 219.85,52.11 219.85,50.03 v1(221.01,48.87) ; JLED1.6 262.68,7.45 262.93,7.2 263.51,7.2 263.68,7.37 JLED1.4 263.68,9.5 263.28,9.89 v1(263.21,9.89) 263.46,10.15 v2(264.06,10.15) 264.5,10.15 264.81,9.84 v1(264.81,9.26)
BREATH_GREEN_R_LED#: length 7.7
  TOP w0.254: v2(267.88,3.57) 267.77,3.68 266.77,3.68 266.44,3.35 ; 266.44,3.35 Q3610.2 ; 266.44,3.35 266.44,3.92 266.07,4.29 266.07,6.68 266.46,7.06 R9646.1 R9644.1 R9645.1
BREATH_LED#: length 112.7
  TOP w0.254: Q28.1 v1(264.59,11.42) ; v1(232.12,59.7) 232.04,59.63 231.55,59.63 230.81,58.89 230.34,58.89 229.58,58.13 U38.B57
  IN1 w0.254: v1(248.52,63.46) 247.81,62.75 245.65,62.75 242.15,66.26 239.94,66.26 v1(239.84,66.16)
  IN3 w0.254: v1(248.52,63.46) 248.52,63.59 249.16,64.22 270.67,64.22 273.06,61.83 273.06,42.1 271.97,41.01 271.97,38.22 272.43,37.76 272.43,20.89 264.59,13.05 v1(264.59,11.42)
  BOTTOM w0.254: v2(264.59,12.09) v1(264.59,11.42) ; v1(239.84,66.16) 239.33,66.66 238.26,66.66 237.3,67.63 233.2,67.63 232.08,66.51 232.08,65.22 233.32,63.98 233.32,61.7 232.93,61.3 232.45,61.3 232.12,60.97 v1(232.12,59.7)
BREATH_LED_DOCK#: length 222
  TOP w0.254: R9646.2 267.32,7.4 266.57,8.15 v2(266.57,8.5) 266.25,8.5 v1(265.49,9.26)
  IN1 w0.254: v1(160.9,44.01) 160.9,44.94 158.53,47.31 158.53,62.85 164.13,68.45 164.13,92.54 164.11,92.55 164.11,92.64 162.77,93.98 162.77,94.83 163.94,96 163.94,100.17 163.26,100.85 v1(163.26,101.97)
  IN2 w0.254: v1(160.9,44.01) 160.9,43.9 162.09,42.71 172.48,42.71 175.38,39.81 189.44,39.81 190.42,38.84 204.87,38.84 205.55,38.16 215.23,38.16 216.55,36.84 227.3,36.84 228.45,37.99 240.9,37.99 241.44,38.52 241.44,39.25 242.5,40.32 252.66,40.32 252.88,40.1 264.85,40.1 265.85,39.1 271.91,39.1 v1(272.45,38.57)
  IN3 w0.254: v1(265.49,9.26) 265.87,9.64 265.87,13.09 272.98,20.21 272.98,38.03 v1(272.45,38.57)
  BOTTOM w0.254: v1(163.26,101.97) 163.08,102.15 163.06,102.15 162.71,102.5 158.58,102.5 158.23,102.15 JDOCK1.4
BREATH_Q_LED#: length 14.6
  TOP w0.108: v2(262.98,13.32) 263.08,13.42 264.35,13.42 264.59,13.19 Q28.6 264.59,12.17 263.77,11.35 263.77,8.17 264.81,7.14 R9644.2 264.81,6.16 264.27,5.63 R9497.1 264.54,4.16 Q3610.1
BST_+1VALWP_R: length 2.6
  TOP w0.508: v2(130.6,130.37) 131.78,130.37 132.48,129.67 PC5502.2
BT_LED#: length 9.9
  TOP w0.254: R229.2 Q22.4 28.45,130.23 27.87,130.8 v1(27.87,133.47) v2(27.87,134.15)
  BOTTOM w0.254: JWLAN1.16 28.07,133.27 v1(27.87,133.47)
BT_RADIO_DIS#: length 304.7
  TOP w0.108: D14.2 v2(26.63,124.07) 26.05,124.07 v1(24.06,122.09) ; U37.A13 262.53,47.81 262.27,47.54 262.27,47.26 261.85,46.85 v1(261.81,46.85) 261,46.85 R298.2
  IN2 w0.089: v1(24.06,122.09) 21.49,119.51 21.49,114.77 22.74,113.53 24.32,113.53 29.49,108.36 50.76,108.36 52.27,109.87 56.9,109.87 57.51,109.26 59.38,109.26 64.3,104.34 64.3,99.83 71.58,92.56 71.58,91.25 74.24,88.58 81.4,88.58 84.34,85.64 84.34,85.07 106.91,62.49 118.04,62.49 118.67,63.11 132.9,63.11 134.7,61.32 143.36,61.32 144.59,60.09 146.52,60.09 147.06,60.62 148,60.62 149.15,61.77 150.31,61.77 152.55,64.02 152.95,64.02 155.05,61.91 158.68,61.91 159.29,62.52 161.35,62.52 163.68,60.19 164.95,60.19 167.5,57.64 170.22,57.64 171.36,56.51 171.36,54.74 172.9,53.2 175.76,53.2 183.46,45.5 194.89,45.5 197.15,47.76 202.92,47.76 205.58,45.09 209.04,45.09 209.19,45.24 226.25,45.24 226.87,44.62 229.27,44.62 233.46,40.42 239.64,40.42 241.45,42.23 241.79,42.23 249.19,42.23 250.65,43.7 252.47,43.7 253.15,43.01 254.41,43.01 254.97,43.57 259.63,43.57 v1(260.03,43.17)
  IN4 w0.089: v1(261.81,46.85) 261.81,46.65 260.03,44.87 v1(260.03,43.17)
BT_RADIO_DIS#_R: length 3.3
  TOP w0.108: D14.1 30.26,124.07 v1(30.57,123.77) 30.67,123.77 v2(31.16,124.26)
  BOTTOM w0.108: JWLAN1.54 v1(30.57,123.77)
BTN_DET#: length 158.4
  TOP w0.108: v1(144.08,70.47) 144.26,70.3 144.26,66.87 143.44,66.06 142.84,66.06 142.4,65.61 141.05,65.61 137.64,62.2 128.96,62.2 127.86,63.29 v2(127.86,64.96) R479.2 126.92,64.31 126.6,64 125.41,64 124.85,63.44 124.45,63.44 124,62.99 JCSW1.1 ; v1(258.23,50.17) 257.78,49.72 U37.B4
  IN2 w0.089: v1(144.08,70.47) 149.41,70.47 150.9,68.98 157.38,68.98 157.47,68.89 157.48,68.89 159.22,67.15 166.35,67.15 166.97,66.53 168.25,66.53 169,65.77 171.04,65.77 175.95,60.87 177.56,60.87 182.59,55.84 183.62,55.84 184.93,54.54 188.29,54.54 189.71,53.12 193.03,53.12 193.86,52.28 204.69,52.28 207.25,49.73 217.66,49.73 217.84,49.9 224.23,49.9 226.48,52.15 228.45,52.15 230.01,53.71 230.87,53.71 230.94,53.78 233.8,53.78 234.22,53.36 234.22,52.16 234.99,51.4 250.12,51.4 250.8,52.08 255.31,52.08 256.11,51.28 257.12,51.28 v1(258.23,50.17)
CAM_C_DET#: length 208.7
  TOP w0.108: U37.A3 257.53,47.61 257.25,47.32 255.07,47.32 v1(254.95,47.44) 254.52,47 254.52,46.45 254.57,46.39 R9404.2
  IN1 w0.089: v1(254.87,57.85) 254.36,57.33 252.05,57.33 251.71,56.99 248.46,56.99 246.9,58.55 243.03,58.55 242.79,58.31 241.28,58.31 241,58.59 238.77,58.59 238.19,59.16 236.78,59.16 236.36,58.74 236.36,58.34 235.89,57.87 228.92,57.87 228.81,57.97 225.56,57.97 225.08,58.45 223.46,58.45 222.9,59.01 221.38,59.01 218.76,56.38 218.76,54.34 214.19,49.77 206.77,49.77 205.41,48.41 194.94,48.41 194.5,48.85 191.84,48.85 191.23,49.46 191.23,51.42 191.44,51.63 191.44,55.02 188.24,58.23 188.24,60.33 184.18,64.38 184.18,73.49 186.11,75.42 186.11,106.94 187.72,108.55 187.72,109.23 188.17,109.68 188.17,128.16 190.31,130.3 190.31,135.75 190.82,136.26 190.82,138.73 194.5,142.41 194.6,142.41 196.68,144.49 201.82,144.49 202.83,145.5 202.83,147.59 205.16,149.92 207.15,149.92 v1(207.91,150.69)
  BOTTOM w0.108: v1(254.95,47.44) 254.95,48.81 255.35,49.21 255.35,53.28 v2(255.23,53.4) 255.23,53.81 256.61,55.19 256.61,56.79 255.55,57.85 v1(254.87,57.85) ; JRCAM1.6 v1(207.91,150.69)
CAM_MIC_CBL_DET#: length 202.9
  IN2 w0.089: v1(35.77,97.85) 37.5,96.13 38.92,96.13 39.48,95.57 39.48,94.15 42.76,90.87 51.74,90.87 53.21,92.33 55.43,92.33 56.6,93.5 64.48,93.5 67.09,90.89 67.09,90.03 71.58,85.54 72.37,85.54 74,83.91 74,81.16 78.39,76.77 88.2,76.77 106.2,58.77 132.71,58.77 135.35,56.12 143.55,56.12 144.32,55.36 v1(145.1,55.36)
  IN4 w0.076: 141.16,90.41 138.24,90.41 137.79,90.86 136.14,90.86 135.65,91.35 132.07,91.35 v3(131.71,91)
  IN4 w0.089: 141.16,90.41 147.38,90.41 147.76,90.04 148.25,90.04 v1(148.65,90.44) 149.13,90.44 149.48,90.09 149.48,89.81 150.29,89 150.29,88.57 151.83,87.03 151.83,87.02 152.07,86.77 152.07,81.62 154.1,79.6 154.1,78.95 155.56,77.48 155.56,76.63 155.24,76.31 155.24,73.84 154.7,73.29 153.04,73.29 150.92,71.17 150.92,68.18 152.24,66.86 152.24,59.49 v1(151.95,59.21)
  BOTTOM w0.076: v3(131.71,91) 131.71,91.38 UC1.AB11
  BOTTOM w0.108: RC193.1 148.75,90.54 v1(148.65,90.44) ; JEDP1.44 36.03,98.11 v1(35.77,97.85) ; 145.1,55.36 v1(145.1,55.36) ; 145.1,55.36 145.71,55.97 145.71,56.99 146.42,57.7 150.44,57.7 v1(151.95,59.21) ; 145.1,55.36 v2(144.61,54.88)
CAP_LOW#: length 2.8
  TOP w0.108: U37.A42 259.53,60.5 259.78,60.75 259.78,61.08 T7164.1
CFG0: length 57.3
  TOP w0.108: v2(92.49,106.41) 92.49,105.47 92.19,105.17 v1(92.19,104.69)
  IN1 w0.089: v1(74.48,106.31) 74.56,106.31 75.5,107.25 77.5,107.25 77.84,107.59 81.16,107.59 85.78,102.97 87.06,102.97 87.4,103.3 90.69,103.3 92.07,104.69 v1(92.19,104.69)
  BOTTOM w0.076: UC1.E68 99.63,100.95 99.89,101.21 arc(99.97,101.41) 99.99,101.62 99.99,101.72 100.07,101.98 100.07,102.18 100.03,102.29 100.03,102.48 100.06,102.58 100.06,102.93 99.93,103.06 99.93,103.55 99.61,103.87 95.31,103.87 94.83,104.36 93.94,104.36 93.66,104.64
  BOTTOM w0.108: v1(74.48,106.31) 73.95,106.31 73.47,106.8 73.09,106.8 70.97,108.92 70.97,109.29 70.32,109.93 70.32,111.21 69.53,112 69.53,113.45 RC376.1 67.77,115.21 67.77,118.66 69.05,119.94 69.23,119.94 70.29,121 70.29,121.32 70.8,121.83 JXDP1.9 ; 93.66,104.64 93.15,105.15 91.68,105.15 RC399.2 91.76,104.69 v1(92.19,104.69)
CFG1: length 53.9
  TOP w0.108: v2(89.24,104.03) 89.24,104.54 v1(89.41,104.71)
  IN1 w0.089: v1(73.92,106.92) 74.98,107.98 77.26,107.98 77.56,108.28 81.47,108.28 85,104.74 87.46,104.74 87.49,104.71 v1(89.41,104.71)
  BOTTOM w0.076: 93.66,103.54 98.7,103.54 99.3,102.94 99.3,102.62 99.63,102.29 UC1.B67
  BOTTOM w0.108: v1(89.41,104.71) 89.41,104.46 89.87,104 90.36,104 90.94,104.59 91.31,104.59 91.61,104.29 91.61,103.65 91.71,103.54 93.27,103.54 93.28,103.55 93.64,103.55 93.65,103.54 93.66,103.54 ; v1(73.92,106.92) 73.67,107.18 73.23,107.18 71.33,109.07 71.33,109.44 70.68,110.08 70.68,112.84 68.62,114.91 68.62,115.17 68.13,115.66 68.13,118.51 69.15,119.53 69.74,119.53 71.15,120.94 71.15,121.29 71.3,121.44 JXDP1.11 71.3,123.93 71.45,124.08 71.45,125.12 RC384.2
CFG2: length 56
  TOP w0.076: v2(94.61,105.41) v3(94.02,104.81)
  IN1 w0.089: v1(74.53,106.92) 75.25,107.63 77.4,107.63 77.7,107.93 81.32,107.93 84.86,104.4 87.31,104.4 87.41,104.31 90.13,104.31 91.01,105.18 91.02,105.18 91.27,105.43 93.4,105.43 v3(94.02,104.81)
  BOTTOM w0.076: UC1.D65 100.98,100.96 100.65,101.3 100.65,101.67 100.64,101.67 100.55,101.93 100.55,102.17 100.57,102.25 100.57,102.52 100.55,102.58 100.55,102.93 100.65,103.03 100.65,103.4 100,104.05 95.69,104.05 93.97,105.78 93.66,105.78
  BOTTOM w0.108: 93.66,105.78 RC396.2 93.46,105.37 v3(94.02,104.81) ; v1(74.53,106.92) 73.85,107.61 73.31,107.61 71.69,109.22 71.69,109.59 71.04,110.23 71.04,112.99 68.98,115.06 68.98,115.35 68.49,115.84 68.49,118.36 69.3,119.16 70.19,119.16 72.3,121.28 JXDP1.15
CFG3: length 53.3
  IN1 w0.089: v1(86,104) 86,103.63 86.32,103.31 86.89,103.31 86.98,103.4 86.98,103.56 87.07,103.65 87.79,103.65 87.88,103.73 87.88,103.88 87.97,103.97 88.26,103.97 88.35,103.88 88.35,103.73 88.44,103.65 88.73,103.65 88.82,103.73 88.82,103.88 88.91,103.97 89.2,103.97 89.29,103.88 89.29,103.73 89.38,103.65 90.55,103.65 91.04,104.13 91.04,104.26 90.87,104.43 90.87,104.56 91.07,104.76 91.2,104.76 91.37,104.59 91.49,104.59 91.99,105.09 92.63,105.09 v7(92.97,104.74)
  BOTTOM w0.076: 93.66,104 94.3,104 94.59,103.71 99.54,103.71 99.77,103.48 99.77,103 99.9,102.86 99.9,102.61 99.87,102.54 99.86,102.53 99.86,102.26 99.9,102.15 99.9,102 99.9,101.98 99.81,101.73 99.63,101.42 UC1.D67
  BOTTOM w0.108: v1(86,104) 86,105.56 85.78,105.79 85.78,113.6 84.97,114.41 84.97,115.19 83.78,116.38 83.78,119 83.65,119.13 82.07,119.13 81.78,119.42 78.83,119.42 78.66,119.58 76.37,119.58 75.44,120.51 73.59,120.51 72.8,121.31 JXDP1.17 72.8,124.52 72.12,125.2 72.12,126.48 RC389.1 ; 93.66,104 RC385.2 93.46,104.26 v7(92.97,104.74)
CFG4: length 53.6
  TOP w0.108: v1(86.93,105.14) 87.16,104.92 v2(87.16,104.51)
  IN1 w0.089: v1(86.93,105.14) 86.04,105.14 85.91,105.27 85.91,105.6 85.66,105.85 85.66,106.03 85.79,106.16 86.22,106.16 86.35,106.03 86.35,105.63 86.47,105.5 86.69,105.5 86.8,105.61 86.8,106.08 86.93,106.21 90.59,106.21 91.38,106.99 93.54,106.99 94.32,106.21 95.51,106.21 95.95,105.77 95.95,105.66 95.86,105.58 95.34,105.58 95.18,105.42 95.18,101.28 95.31,101.16 95.62,101.16 95.74,101.28 95.74,101.39 95.79,101.44 v3(96.18,101.44)
  BOTTOM w0.076: 96.3,101.31 97.04,100.57 97.36,100.57 97.53,100.41 UC1.E70
  BOTTOM w0.108: RC387.2 93.69,99.94 94.4,99.94 94.65,100.19 94.65,100.53 95.56,101.44 v3(96.18,101.44) 96.3,101.31 ; JXDP1.27 75.3,121.6 75.5,121.4 75.5,120.96 76.52,119.95 78.86,119.95 79.02,119.78 81.93,119.78 82.22,119.49 83.91,119.49 84.14,119.25 84.14,116.53 85.34,115.34 85.34,114.56 86.15,113.74 86.15,105.93 86.36,105.72 86.36,105.71 v1(86.93,105.14)
CFG5: length 49.7
  TOP w0.108: v3(98.48,101.45) 98.36,101.57 v5(97.22,101.57) 96.64,100.99 94.64,100.99 v3(94.04,101.59)
  IN1 w0.089: v1(87.56,105.13) 87.96,105.53 88.67,105.53 88.75,105.44 88.75,105.2 88.84,105.11 89.02,105.11 89.11,105.2 89.11,105.44 89.2,105.53 90.88,105.53 91.66,106.31 92.42,106.31 92.51,106.22 92.51,105.86 92.6,105.77 92.77,105.77 92.86,105.86 92.86,106.22 92.95,106.31 93.21,106.31 94.38,105.14 94.38,104.66 94.02,104.31 92.72,104.31 92.59,104.18 92.59,103.79 92.68,103.7 92.96,103.7 93.1,103.56 93.1,103.47 92.95,103.32 92.68,103.32 92.59,103.23 92.59,103 92.68,102.91 93.01,102.91 93.13,102.79 93.13,102.68 93,102.55 92.8,102.55 92.7,102.45 92.7,102.25 92.83,102.12 93.51,102.12 v3(94.04,101.59)
  BOTTOM w0.076: UC1.C68 v3(98.48,101.45)
  BOTTOM w0.108: RC398.2 93.79,101.34 v3(94.04,101.59) ; JXDP1.29 75.8,121.61 76.01,121.4 76.01,120.97 76.67,120.31 79.18,120.31 79.35,120.14 82.08,120.14 82.37,119.85 84.17,119.85 84.5,119.52 84.5,116.68 85.7,115.49 85.7,114.71 86.55,113.86 86.55,106.15 v1(87.56,105.13)
CFG6: length 53.7
  TOP w0.108: v3(94.09,100.5) 94.38,100.79 97.58,100.79 v3(97.72,100.93)
  IN1 w0.089: v3(97.72,100.93) 97.72,101.31 98.59,102.17 98.59,102.65 98.5,102.74 97.81,102.74 97.72,102.83 97.72,103.01 97.81,103.1 98.5,103.1 98.59,103.18 98.59,103.36 98.5,103.45 97.81,103.45 97.72,103.54 97.72,103.72 97.81,103.81 98.5,103.81 98.59,103.9 98.59,104.07 98.5,104.16 97.81,104.16 97.72,104.25 97.72,104.43 97.81,104.52 98.5,104.52 98.59,104.61 98.59,104.79 98.5,104.87 97.81,104.87 97.72,104.96 97.72,105.14 97.81,105.23 98.5,105.23 98.59,105.32 98.59,105.55 97.05,107.09 96.9,107.09 96.65,106.84 96.36,106.84 96.24,106.96 96.24,107.09 96.49,107.34 96.49,107.67 96.33,107.84 95.42,107.84 95.28,107.7 95.28,107.44 95.19,107.35 95.01,107.35 94.93,107.44 94.93,107.7 94.84,107.79 94.37,107.79 94.14,108.02 88.13,108.02 v1(87.44,107.33)
  BOTTOM w0.076: UC1.D68 v3(97.72,100.93)
  BOTTOM w0.108: JXDP1.33 76.8,121.62 77.23,121.19 79.52,121.19 80.21,120.5 82.23,120.5 82.53,120.21 84.32,120.21 84.87,119.67 84.87,116.83 86.12,115.58 86.12,114.8 86.91,114.01 86.91,108.9 v2(87.11,108.7) 87.44,108.37 v1(87.44,107.33) ; RC395.2 94.06,100.52 v3(94.09,100.5)
CFG7: length 50.4
  TOP w0.108: v3(99.12,102.22) 97.16,102.22 96.97,102.03 95.88,102.03 v5(95.44,101.59) v3(94.68,101.59)
  IN1 w0.089: v3(94.68,101.59) 94.68,102.05 94.58,102.15 94.05,102.15 93.97,102.24 93.97,102.39 94.05,102.48 94.52,102.48 94.68,102.63 94.68,102.78 94.59,102.87 93.52,102.87 93.43,102.96 93.43,103.13 93.52,103.22 94.59,103.22 94.68,103.31 94.68,103.49 94.59,103.58 93.52,103.58 93.43,103.67 93.43,103.85 93.52,103.94 94.59,103.94 94.68,104.02 94.68,105.72 94.51,105.88 94.14,105.88 93.37,106.65 91.52,106.65 90.74,105.87 87.65,105.87 v1(87.55,105.77)
  BOTTOM w0.076: UC1.C67 99.05,102.15 v3(99.12,102.22)
  BOTTOM w0.108: JXDP1.35 77.3,121.66 77.41,121.55 79.67,121.55 80.36,120.87 82.38,120.87 82.68,120.57 84.47,120.57 85.23,119.82 85.23,117.01 86.96,115.28 86.96,114.52 87.3,114.17 87.3,109.27 88.23,108.34 88.23,107.51 87.56,106.85 87.31,106.85 87.18,106.72 87.18,106.13 v1(87.55,105.77) ; RC393.2 94.04,102.22 v3(94.68,101.59)
CFG8: length 49
  IN1 w0.089: v3(95.6,100.39) 95.79,100.58 95.79,100.75 95.69,100.86 95.18,100.86 94.85,101.18 93.91,101.18 93.55,101.55 92.63,101.55 92.44,101.74 92.44,102.02 92.31,102.15 92.31,102.5 92.19,102.63 92.01,102.63 91.86,102.48 91.86,102.38 91.78,102.3 91.65,102.3 91.48,102.48 91.48,103.21 91.4,103.29 91.22,103.29 91.1,103.16 91.1,102.3 90.97,102.17 90.72,102.17 90.51,102.38 90.51,102.78 90.33,102.96 89.85,102.96 89.39,102.5 89.3,102.5 89.21,102.41 89.21,102.25 89.12,102.17 88.83,102.17 88.74,102.25 88.74,102.41 88.65,102.5 88.31,102.5 88.18,102.62 88.05,102.62 87.95,102.72 87.95,102.85 87.85,102.95 87.64,102.95 87.51,102.82 87.51,102.71 87.43,102.62 87.11,102.62 87.02,102.53 87.02,102.32 86.93,102.24 86.77,102.24 86.68,102.32 86.68,102.53 86.59,102.62 86.42,102.62 86.33,102.53 86.33,102.32 86.25,102.24 86.08,102.24 85.99,102.32 85.99,102.53 85.9,102.62 85.64,102.62 85.24,103.02 85.06,103.02 84.88,102.84 84.62,102.84 84.5,102.96 84.5,103.21 84.71,103.43 84.71,103.55 84.16,104.1 83.98,104.1 83.86,103.98 83.86,103.82 83.74,103.71 83.55,103.71 83.43,103.84 83.43,104.21 83.6,104.38 83.6,104.66 81.01,107.25 77.99,107.25 77.61,106.87 76.74,106.87 76.62,106.74 76.62,106.43 76.48,106.29 76.28,106.29 76.13,106.44 v1(76.13,106.82)
  BOTTOM w0.076: v3(95.6,100.39) 95.6,100.16 95.73,100.03 96.28,100.03 96.53,99.78 UC1.F71
  BOTTOM w0.108: JXDP1.10 70.8,116.09 71.4,115.49 71.4,115.18 71.55,115.02 71.77,115.02 71.84,114.95 71.84,114.69 71.77,114.62 71.52,114.62 71.4,114.49 71.4,114.3 72.22,113.48 72.22,111.3 73.09,110.43 73.09,110.28 72.9,110.08 72.9,109.93 73,109.82 73.15,109.82 73.35,110.02 73.5,110.02 73.61,109.92 73.61,109.77 73.41,109.57 73.41,109.42 73.52,109.31 73.67,109.31 73.86,109.51 74.01,109.51 74.73,108.79 74.73,108.4 75.28,107.85 v2(75.62,107.85) 76.42,107.85 76.54,107.73 76.54,107.23 v1(76.13,106.82)
CFG9: length 50.1
  TOP w0.108: v2(84.06,101.38) 84.06,101.99 v1(84.11,102.05)
  IN1 w0.089: v3(95.03,100.39) 94.81,100.39 94.19,101 93.76,101 93.67,101.09 93.52,101.09 93.4,101.21 91.93,101.21 91.32,101.82 87.34,101.82 87.27,101.89 85.61,101.89 85.02,102.48 84.54,102.48 v1(84.11,102.05)
  BOTTOM w0.076: UC1.G69 98.48,99.06 98.13,99.4 98.04,99.4 98.02,99.42 97.71,99.42 97.69,99.4 97.62,99.4 97.51,99.51 97.44,99.59 97.12,99.59 97.09,99.62 96.46,99.62 96.21,99.87 95.55,99.87 v3(95.03,100.39)
  BOTTOM w0.108: v1(84.11,102.05) 84.11,100.98 84.24,100.85 85.8,100.85 85.93,100.72 85.93,100.45 85.72,100.24 81.52,100.24 81.04,99.76 77.84,99.76 75.8,101.79 75.8,105.63 76.95,106.77 76.95,107.96 76.59,108.32 75.32,108.32 75.09,108.55 75.09,108.94 72.58,111.45 72.58,113.94 72.22,114.31 72.22,115.18 71.3,116.1 JXDP1.12
CFG10: length 49.4
  IN1 w0.089: v3(96.16,100.39) 96.54,100.76 96.54,101.89 96.43,101.99 95.63,101.99 95.54,102.08 95.54,102.24 95.63,102.32 96.18,102.32 96.28,102.43 96.28,102.58 96.19,102.67 95.5,102.67 95.41,102.76 95.41,102.94 95.5,103.03 96.19,103.03 96.28,103.12 96.28,103.29 96.19,103.38 95.5,103.38 95.41,103.47 95.41,103.65 95.5,103.74 96.19,103.74 96.28,103.83 96.28,104.01 96.19,104.1 95.5,104.1 95.41,104.18 95.41,104.36 95.5,104.45 96.44,104.45 96.53,104.54 96.53,104.72 96.44,104.81 95.5,104.81 95.41,104.9 95.41,105.07 95.5,105.16 96.44,105.16 96.65,105.37 96.65,105.55 95.55,106.66 94.43,106.66 93.75,107.33 91.05,107.33 90.27,106.55 84.79,106.55 84.71,106.47 83.77,106.47 81.55,108.68 77.28,108.68 76.96,108.36 75.89,108.36 v1(75.5,108.75)
  BOTTOM w0.076: UC1.F70 98.2,99.72 97.87,100.05 97.51,100.05 97.41,99.95 96.6,99.95 v3(96.16,100.39)
  BOTTOM w0.108: JXDP1.16 72.3,115.79 72.58,115.51 72.58,114.46 73.59,113.45 73.59,111.61 v2(73.54,111.57) 73.54,111 75.5,109.05 v1(75.5,108.75)
CFG11: length 50
  TOP w0.108: v1(76.13,108.76) 76.43,108.47 v2(76.72,108.47)
  IN1 w0.089: v3(99.51,99.63) 99.88,100.01 99.88,100.47 99.76,100.6 99.1,100.6 98.97,100.72 98.97,101.01 99.06,101.1 99.79,101.1 99.88,101.19 99.88,103.72 99.76,103.85 99.35,103.85 99.22,103.98 99.22,104.23 99.35,104.36 99.76,104.36 99.88,104.48 99.88,105.47 96.76,108.6 95.97,108.6 95.86,108.71 88.58,108.71 88.28,109.01 88.28,109.44 88.05,109.66 87.56,109.66 87.47,109.57 87.47,109.02 87.38,108.93 87.2,108.93 87.11,109.02 87.11,109.57 87.02,109.66 86.85,109.66 86.76,109.57 86.76,109.02 86.67,108.93 86.49,108.93 86.4,109.02 86.4,109.57 86.31,109.66 86.14,109.66 86.05,109.57 86.05,109.02 85.96,108.93 85.78,108.93 85.69,109.02 85.69,109.57 85.6,109.66 82.61,109.66 81.97,109.03 77.14,109.03 76.87,108.76 v1(76.13,108.76)
  BOTTOM w0.076: UC1.G68 99.51,99.4 v3(99.51,99.63)
  BOTTOM w0.108: JXDP1.18 72.8,115.82 72.91,115.71 73.47,115.71 73.74,115.43 73.74,113.91 73.95,113.71 73.95,112.35 74.05,112.25 74.05,111.01 74.28,110.78 74.28,110.78 76.13,108.92 v1(76.13,108.76)
CFG12: length 49.6
  TOP w0.108: v1(84.74,102.07) 85,102.33 v2(85,102.86)
  IN1 w0.089: v3(94.3,99.43) 93.99,99.12 92.55,99.12 92.49,99.19 92,99.67 91.1,99.67 90.74,100.04 89.17,100.04 89.09,100.13 89.09,100.57 89,100.66 88.83,100.66 88.74,100.57 88.74,100.13 88.65,100.04 88.49,100.04 88.4,100.13 88.4,100.57 88.31,100.66 88.15,100.66 88.06,100.57 88.06,100.13 87.97,100.04 82.59,100.04 82.46,100.17 82.46,100.42 82.59,100.55 84.61,100.55 84.8,100.74 84.8,100.92 84.67,101.05 83.06,101.05 82.97,101.14 82.97,101.41 83.25,101.69 83.65,101.69 83.83,101.51 84.61,101.51 84.74,101.64 v1(84.74,102.07)
  BOTTOM w0.076: UC1.H70 98.05,98.63 arc(97.96,98.7) 97.85,98.72 97.74,98.72 97.73,98.72 97.73,98.72 97.73,98.72 97.64,98.76 97.44,98.76 97.35,98.72 96.99,98.72 96.89,98.83 96.35,98.83 96.18,98.65 96.18,98.46 96.1,98.39 95.92,98.39 95.85,98.46 95.85,98.59 95.73,98.71 95.64,98.71 95.51,98.58 95.51,98.04 95.41,97.94 95.02,97.94 94.89,98.07 94.89,98.83 v3(94.3,99.43)
  BOTTOM w0.108: JXDP1.28 75.3,115.73 75.3,115.73 75.3,112.74 75.49,112.54 75.49,112.53 76.15,111.88 76.15,110.88 76.15,110.58 77.83,108.9 80.32,108.9 84.52,104.7 84.52,102.29 v1(84.74,102.07)
CFG13: length 50
  TOP w0.108: v2(86.68,101.77) 86.68,101.36 v1(86.4,101.08)
  IN1 w0.089: v1(86.4,101.08) 85.76,101.08 85.63,100.95 85.63,100.55 85.51,100.42 85.28,100.42 85.15,100.55 85.15,101.35 85.34,101.54 87.14,101.54 87.19,101.48 87.92,101.48 88.05,101.35 88.05,101.09 88.14,101 88.3,101 88.39,101.09 88.39,101.39 88.48,101.48 88.65,101.48 88.73,101.39 88.73,101.09 88.82,101 88.99,101 89.08,101.09 89.08,101.39 89.17,101.48 89.33,101.48 89.42,101.39 89.42,101.09 89.51,101 89.67,101 89.76,101.09 89.76,101.39 89.85,101.48 90.02,101.48 90.11,101.39 90.11,101.09 90.19,101 90.36,101 90.45,101.09 90.45,101.39 90.54,101.48 91.18,101.48 91.3,101.36 91.3,101.01 91.44,100.86 92.4,100.86 92.53,100.74 92.53,100.56 92.42,100.45 92.42,99.78 92.72,99.48 92.92,99.48 93.05,99.61 93.05,100.64 93.18,100.77 93.36,100.77 93.69,100.44 93.69,99.84 93.81,99.71 93.99,99.71 94.23,99.95 94.23,100.05 94.32,100.14 94.49,100.14 94.57,100.05 94.57,99.95 94.66,99.86 95.31,99.86 95.44,99.73 v3(95.44,99.45)
  BOTTOM w0.076: UC1.G71 96.98,99.16 96.94,99.2 96.26,99.2 96.11,99.05 95.84,99.05 v3(95.44,99.45)
  BOTTOM w0.108: v1(86.4,101.08) 86.24,101.23 84.75,101.23 84.62,101.36 84.62,101.54 84.74,101.66 85.07,101.66 85.2,101.79 85.2,102.05 85.33,102.17 85.43,102.17 85.58,102.32 85.58,102.48 85.38,102.68 85,102.68 84.88,102.8 84.88,104.36 85.01,104.48 85.51,104.48 85.61,104.59 85.61,104.81 85.5,104.92 84.81,104.92 83.45,106.28 83.45,108.09 82.28,109.26 77.98,109.26 76.51,110.73 76.51,112.03 75.86,112.68 75.86,112.69 75.66,112.89 75.66,114.84 76.13,115.31 76.13,115.76 75.8,116.1 JXDP1.30
CFG14: length 49.1
  IN1 w0.089: v3(94.88,99.45) 95.24,99.09 96.39,99.09 96.89,99.58 97.36,99.58 97.45,99.67 97.45,99.92 97.54,100.01 97.71,100.01 97.8,99.92 97.8,99.67 97.89,99.58 98.41,99.58 98.79,99.96 98.79,101.21 98.97,101.38 99.43,101.38 99.55,101.51 99.55,102.63 98.97,103.21 98.97,104.41 99.32,104.76 99.32,105.4 96.51,108.22 95.69,108.22 95.55,108.36 83.81,108.36 v1(82.92,109.26)
  BOTTOM w0.076: UC1.H69 98.62,98.72 98.39,98.72 98.21,98.89 97.76,98.89 97.67,98.92 97.41,98.92 97.32,98.89 97.06,98.89 96.96,98.99 96.28,98.99 96.16,98.87 95.46,98.87 v3(94.88,99.45)
  BOTTOM w0.108: v1(82.92,109.26) 82.45,109.73 78.71,109.73 76.87,111.57 76.87,112.71 v2(76.77,112.81) 76.67,112.92 76.27,112.92 76.16,113.02 76.16,113.21 76.27,113.32 76.74,113.32 76.87,113.45 76.87,113.63 76.76,113.74 76.13,113.74 76.02,113.84 76.02,114.06 76.13,114.17 76.76,114.17 76.87,114.28 76.87,115.71 76.8,115.78 JXDP1.34
CFG15: length 49
  IN1 w0.089: v1(83.93,106.87) 83.99,106.93 87.84,106.93 88.59,107.68 93.9,107.68 94.58,107 95.69,107 97.34,105.35 97.34,104.39 97.25,104.3 96.95,104.3 96.86,104.21 96.86,104.04 96.95,103.95 97.25,103.95 97.34,103.86 97.34,103.68 97.25,103.59 96.95,103.59 96.86,103.5 96.86,103.33 96.95,103.24 97.25,103.24 97.34,103.15 97.34,101.99 97.25,101.9 96.87,101.9 96.78,101.82 96.78,101.64 96.87,101.55 97.25,101.55 97.34,101.46 97.34,101.28 97.25,101.19 96.87,101.19 96.78,101.1 96.78,100.93 96.87,100.84 97.25,100.84 97.34,100.75 97.34,100.34 96.94,99.94 96.49,99.94 v3(96,99.45)
  BOTTOM w0.076: UC1.G70 97.64,99.16 97.44,99.35 97.37,99.42 97.05,99.42 97.02,99.45 96.4,99.45 v3(96,99.45)
  BOTTOM w0.108: JXDP1.36 77.3,111.65 78.86,110.09 83.23,110.09 83.86,109.46 v2(83.86,109.14) 83.86,108.8 84.03,108.62 85.25,108.62 85.42,108.46 85.42,108.19 85.26,108.04 83.96,108.04 83.86,107.94 83.86,107.71 83.98,107.58 85.23,107.58 85.38,107.43 85.38,106.69 85.25,106.57 85.08,106.57 84.97,106.67 84.97,107.02 84.87,107.13 84.68,107.13 84.52,106.97 84.52,106.72 84.39,106.59 84.21,106.59 v1(83.93,106.87)
CFG16: length 54.6
  IN4 w0.102: v1(75.78,106.24) 75.45,105.91 75.45,101.74 77.73,99.45 80.93,99.45 83.42,101.95 83.42,103.53 84.51,104.61 88.32,104.61 89.21,105.5 94.99,105.5 97.63,102.86 99.97,102.86 102.32,100.5 102.32,99.52 102.42,99.42 102.57,99.42 102.72,99.57 v3(102.72,99.63)
  BOTTOM w0.102: 71.3,113.72 70.91,114.1 70.91,115.28 70.36,115.82 69.93,115.82 69.8,115.95 JXDP1.6 ; 71.3,113.72 71.73,113.28 71.73,111.1 72.39,110.45 72.39,109.56 73.63,108.32 74.12,108.32 75.55,106.89 75.55,106.46 v1(75.78,106.24) ; 71.3,113.72 v6(71.3,113.75) ; UC1.E63 102.4,100.24 102.58,100.24 102.72,100.1 v3(102.72,99.63)
CFG17: length 54.6
  IN4 w0.102: v3(102.68,99.05) 102.47,99.05 102.12,99.4 102.12,100.42 99.88,102.65 97.55,102.65 94.91,105.3 89.29,105.3 88.4,104.41 84.59,104.41 83.63,103.44 83.63,101.87 81.01,99.25 77.65,99.25 75.25,101.66 75.25,106.08 v1(75.12,106.21)
  BOTTOM w0.102: v1(75.12,106.21) 75.22,106.21 75.35,106.34 75.35,106.81 74.04,108.12 73.54,108.12 72.19,109.47 72.19,110.36 71.53,111.02 71.53,111.58 ; v3(102.68,99.05) 102.32,99.4 UC1.F63 ; JXDP1.4 69.3,115.87 69.55,115.62 70.28,115.62 70.71,115.19 70.71,114.02 71.53,113.2 71.53,111.58 ; 71.53,111.58 v6(71.51,111.58)
CFG18: length 49
  IN4 w0.102: v3(100.65,99.72) 100.06,99.72 99.94,99.85 99.94,100.09 100.08,100.23 100.08,100.66 98.64,102.1 97.77,102.1 97.55,101.88 97.55,101.61 97.45,101.5 97.04,101.5 96.94,101.61 96.94,101.88 96.72,102.1 95.73,102.1 95.59,102.24 95.59,103.93 95.25,104.27 94.82,104.27 94.57,104.02 94.57,102.65 94.47,102.55 93.82,102.55 93.72,102.65 93.72,103.97 93.48,104.22 92.95,104.22 92.71,103.97 92.71,102.65 92.61,102.55 91.27,102.55 90.97,102.86 90.97,103.4 90.72,103.65 87.79,103.65 87.64,103.49 86.31,103.49 86.06,103.25 86.06,101.82 85.96,101.72 85.55,101.72 85.45,101.82 85.45,102.89 85.23,103.11 84.31,103.11 v1(84.11,103.32)
  BOTTOM w0.102: 75.47,110.57 75.12,110.92 75.12,112.15 74.64,112.64 74.64,114.57 74.43,114.77 74.43,115.79 74.3,115.92 JXDP1.24 ; 75.47,110.57 v6(75.53,110.57) ; 75.47,110.57 77.51,108.52 77.52,108.52 77.63,108.41 80.12,108.41 83.91,104.62 83.91,103.52 v1(84.11,103.32) ; UC1.E66 100.32,100.05 v3(100.65,99.72)
CFG19: length 49.1
  IN4 w0.102: v1(84.08,102.71) 84.29,102.91 85.15,102.91 85.25,102.81 85.25,101.73 85.47,101.51 86.04,101.51 86.26,101.73 86.26,103.16 86.39,103.29 87.73,103.29 87.88,103.44 90.64,103.44 90.77,103.32 90.77,102.77 91.19,102.35 92.69,102.35 92.91,102.57 92.91,103.89 93.04,104.01 93.39,104.01 93.52,103.89 93.52,102.57 93.74,102.35 94.55,102.35 94.77,102.57 94.77,103.94 94.9,104.06 95.17,104.06 95.38,103.85 95.38,102.15 95.64,101.89 96.63,101.89 96.74,101.79 96.74,101.52 96.96,101.3 97.53,101.3 97.75,101.52 97.75,101.79 97.85,101.89 98.55,101.89 99.87,100.58 99.87,100.32 99.75,100.19 v3(99.5,100.19)
  BOTTOM w0.102: UC1.F66 100.18,99.51 v3(99.5,100.19) ; 74.43,114.01 74.43,112.55 74.92,112.07 74.92,110.83 77.43,108.32 77.43,108.32 77.55,108.21 80.03,108.21 83.7,104.54 83.7,103.09 v1(84.08,102.71) ; 74.43,114.01 v6(74.39,114.01) ; 74.43,114.01 74.43,114.48 74.23,114.69 74.23,115.63 73.8,116.06 JXDP1.22
