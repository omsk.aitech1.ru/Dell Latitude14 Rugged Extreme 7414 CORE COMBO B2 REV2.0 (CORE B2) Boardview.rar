# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_RUN_PVDD:
  vias: v2(42.35,118.73) v4(40.93,118.63) v4(43.62,118.71)
+5V_TSP: length 3.5
  TOP w0.508: PJP10.1 40.11,103.91 39.56,103.37 v2(39.56,102.48)
  BOTTOM w0.254: v1(42.92,100.49) 43.03,100.6 JEDP1.30
+5V_TSP_Q: length 7.5
  TOP w0.254: Q1.3 39.35,107.56 39.05,107.86 39.05,108.52 38.44,109.13 v2(38.44,111.19)
  TOP w0.508: PJP10.2 40.75,106.69 39.88,107.56 Q1.3
+5V_USB:
  vias: v1(152.21,137.78) v1(152.89,137.91) v2(149.92,135.5)
+5V_USB_CHG_PWR:
  vias: v1(19.71,100.94) v1(19.71,100.3) v1(19.71,99.63) v1(19.71,99) v2(20.41,97.75)
+P1.0V_PEX_VDD: length 41.7
  IN1 w1.778: 109.92,139.05 110.78,138.19 126.78,138.19 127.8,137.17 131.44,137.17 132.56,136.06 135.83,136.06 140.9,130.98 140.9,125.72 140.75,125.56 140.75,123.65
  vias: v1(109.03,141.67) v1(109.03,141.03) v1(109.03,140.4) v1(112.96,147.71) v1(113.27,147.18) v1(113.6,147.71) v1(120.08,145.66) v1(120.71,145.66) v1(121.35,145.66) v2(133.41,121.35) v4(139.89,122.24) v4(139.89,121.37) v4(139.89,120.51)
+VCC_1P8: length 9.3
  TOP w0.203: RC388.2 136.31,92.95 134.51,92.95 134.18,92.62 133.28,92.62 132.66,92 131.57,92 131.34,92.23 CC269.1 130.95,92.91 v3(130.95,93.24) 130.95,93.38 131.23,93.66 v2(131.76,93.66)
  BOTTOM w0.254: v3(130.95,93.24) 130.95,93.4 UC1.U12 UC1.U11
+VCC_CORE: length 3.2
  BOTTOM w0.203: v3(115.48,103.06) 115.48,102.69 UC1.A39 ; v3(112.71,103.36) 112.71,102.4 UC1.A44
  BOTTOM w0.254: UC1.A34 117.65,102.7 v3(117.93,102.99) ; v3(120.36,102.99) 120.36,102.61 UC1.A30
  vias: v2(110.4,109.94) v2(111.21,116.12) v2(112.3,110) v3(112.89,95.82) v3(112.89,95.26) v3(112.86,94.35) v3(112.86,93.79) v3(112.86,93.05) v3(112.86,92.49) v3(112.86,91.94) v3(112.86,91.38) v3(113.47,97.19) v3(113.47,96.64) v3(114.11,97.19) v3(114.11,96.64) v3(114.51,94.25) v3(114.51,93.69) v3(114.51,93.08) v3(114.51,92.52) v3(114.51,91.96) v3(114.51,91.4) v3(114.66,99.03) v3(114.64,87.69) v3(114.87,88.25) v3(115.4,90.51) v3(115.4,89.95) v3(115.4,89.4) v3(115.4,88.84) v3(115.43,88.25) v3(115.5,87.69) v3(115.68,96.64) v3(115.99,88.25) v3(116.22,97.19) v3(116.24,96.64) v3(116.39,87.69) v3(116.44,99.07) v3(116.77,97.19) v3(116.8,96.64) v3(116.77,88.25) v3(117.36,96.64) v3(117.33,88.25) v3(117.33,87.69) v3(117.38,86.18) v3(117.92,97.18) v3(117.92,96.62) v3(118.07,88.25) v3(118.27,99.02) v3(118.3,90.49) v3(118.3,89.93) v3(118.3,89.37) v3(118.3,88.81) v3(118.3,87.69) v3(118.55,97.19) v3(118.55,96.64) v3(118.63,88.25) v3(119.19,96.62) v3(119.19,88.25) v3(119.19,87.69) v3(119.18,86.19) v3(119.42,95.82) v3(119.42,95.26) v3(119.67,94.04) v3(119.67,93.49) v3(119.67,92.7) v3(119.67,92.14) v3(119.67,91.45) v3(119.67,90.89) v3(119.75,96.64) v3(120.08,99.07) v3(121.02,99.63) v4(110.47,114.85) v4(110.47,113.96) v4(110.47,113.07) v4(110.47,112.18) v4(110.47,111.32) v4(111.33,114.85) v4(111.33,113.96) v4(111.33,113.07) v4(111.33,112.18) v4(111.33,111.32) v4(112.19,114.85) v4(112.19,113.96) v4(112.19,113.07) v4(112.19,112.18) v4(112.19,111.32) v4(113.06,114.85) v4(113.06,113.96) v4(113.06,113.07) v4(113.06,112.18) v4(113.06,111.32) v5(109.38,113.5) v5(109.43,111.65) v5(109.43,109.72) v5(111.03,110.43) v5(112.76,109.94)
+VCC_GT: length 3.5
  BOTTOM w0.203: UC1.A58 v3(105.26,102.9) ; UC1.A53 107.74,102.65 107.65,102.74 v3(107.65,103.08) ; v3(110.44,102.86) 110.22,102.64 UC1.A48 ; v3(100.29,103.26) 100.3,103.24 UC1.A66 ; UC1.A62 v3(102.78,103.19)
  vias: v1(92.64,96.13) v1(93.28,96.13) v1(93.91,96.13) v1(93.91,94.73) v1(93.91,93.59) v1(94.55,96.13) v1(94.55,94.73) v1(94.55,93.59) v1(95.18,96.13) v1(95.18,94.73) v1(95.18,93.59) v1(95.82,96.13) v1(95.82,94.73) v1(95.82,93.59) v1(96.45,96.13) v1(96.45,94.73) v1(96.45,93.59) v2(73.82,95.57) v3(95.13,92.72) v3(95.79,92.72) v3(96.45,92.72) v3(97.52,96.09) v3(97.55,95.19) v3(97.6,94.3) v3(97.6,92.44) v3(97.6,91.56) v3(98.16,96.09) v3(98.21,95.19) v3(98.23,94.3) v3(98.23,92.44) v3(98.23,91.56) v3(98.79,96.09) v3(98.87,95.19) v3(98.87,94.3) v3(98.87,92.44) v3(98.87,91.56) v3(99.43,96.09) v3(99.5,94.3) v3(99.5,92.44) v3(100.19,96.09) v3(100.14,94.3) v3(100.14,92.44) v3(100.14,91.56) v3(100.8,94.3) v3(100.77,92.44) v3(100.77,91.56) v3(100.83,96.09) v3(101.41,94.3) v3(101.41,92.44) v3(101.48,96.1) v3(102.1,96.09) v3(102.04,94.3) v3(102.04,92.44) v3(102.04,91.56) v3(102.68,98.49) v3(103.41,90.36) v3(103.41,89.8) v3(103.57,97.19) v3(103.57,96.64) v3(103.57,95.37) v3(103.57,94.78) v3(103.57,93.64) v3(103.57,93.08) v3(103.57,92.11) v3(103.57,91.56) v3(104.13,97.19) v3(104.13,96.64) v3(104.68,97.19) v3(104.68,96.64) v3(104.71,91.71) v3(104.71,91.15) v3(104.71,90.49) v3(104.71,89.93) v3(104.74,95.67) v3(104.74,95.11) v3(104.74,94.3) v3(104.74,93.74) v3(104.74,93.05) v3(104.74,92.49) v3(105.24,97.19) v3(105.24,96.64) v3(105.9,97.19) v3(105.9,96.64) v3(106.01,95.67) v3(106.01,95.11) v3(106.01,94.3) v3(106.01,93.74) v3(106.01,93.05) v3(106.01,92.49) v3(105.98,91.71) v3(105.98,91.15) v3(105.98,90.49) v3(105.98,89.93) v3(106.46,97.19) v3(106.46,96.64) v3(107,91.71) v3(107,91.15) v3(107,90.49) v3(107,89.93) v3(107.02,97.19) v3(107.02,96.64) v3(107.02,95.67) v3(107.02,95.11) v3(107.02,94.3) v3(107.02,93.74) v3(107.02,93.05) v3(107.02,92.49) v3(108.34,97.19) v3(108.34,96.64) v4(73.29,101.13) v4(73.29,100.27) v4(73.29,99.3) v4(74,92.98) v4(74,92.06) v4(74.05,93.87) v4(74.84,93.33) v4(74.84,92.42) v4(78.67,95.87) v4(78.85,96.91) v4(79.54,96.23) v4(81.21,94.65) v4(81.9,92.17) v4(82.1,94.65) v4(82.79,92.17) v4(82.99,94.65) v4(83.68,92.17) v4(83.88,94.65) v4(84.57,92.17) v4(84.77,94.65) v4(85.46,92.17) v4(85.66,94.65) v4(86.35,92.17) v4(86.55,94.65) v4(87.23,92.17) v4(87.44,94.65) v4(88.12,92.17) v4(88.33,94.65) v4(89.19,92.17) v4(89.22,94.65) v4(90.1,94.65) v4(90.99,94.65) v4(91.88,94.65) v4(92.77,94.65)
+VCC_GTX: length 11.3
  TOP w0.508: v3(104.26,87.92) 103.67,87.92 v2(103.59,87.85)
  IN2 w0.508: v3(104.26,87.92) 101.91,90.27 99.37,90.27 v3(96.65,87.54)
  BOTTOM w0.152: UC1.AK70 96.67,87.57 v3(96.65,87.54)
+VCC_SA: length 46.2
  TOP w0.254: v1(96.33,109.08) v2(96.87,109.63) 97.5,110.25 RC422.1
  IN2 w0.254: v4(127.33,112.15) 126.05,110.87 126.05,109.94 124.93,108.82 124.52,108.82 123.89,109.46 123.89,112.11 119.12,116.88 106.4,116.88 105.73,116.21 105.73,110.86 104.96,110.1 100.62,110.1 99.61,109.08 v1(96.33,109.08)
  vias: v3(121.98,97.35) v3(121.98,96.79) v3(122.74,97.35) v3(122.74,96.79) v3(122.92,87.77) v3(123.61,97.35) v3(123.61,96.79) v3(123.52,87.85) v3(123.84,88.41) v3(124.08,87.88) v4(126.68,114.03) v4(126.69,112.79) v4(127.44,113.4)
+VCC_SFR_OC: length 28
  TOP w0.254: v1(122.64,71.06) 122.56,71.06 121.09,72.52 121.09,75.25 RC453.2 120.53,76.7 120.58,76.75 120.58,77.76 121.17,78.35 121.5,78.35 122.32,79.17 v2(122.32,79.56) 123.99,81.23 123.99,82.13 124.2,82.35 124.2,85 123.56,85.65 123.56,86.27 124.67,87.39 v3(124.67,87.85)
  IN2 w0.305: v1(117.03,67.84) 120.24,71.06 v1(122.64,71.06)
  BOTTOM w0.254: v3(124.67,87.85) 124.67,87.68 124.67,87.67 UC1.AL23
+VDDA_AVDD1: length 0.9
  TOP w0.203: U17.27 38.11,124.07 v1(37.98,124.2)
  vias: v2(40.45,125.95)
+VDDA_PVDD: length 6.8
  TOP w0.221: U17.38 39.92,119.47 39.66,119.22 39.24,119.22 C9903.1
  TOP w0.508: v2(39.94,117.69) 39.37,117.69 v1(39.22,117.84) 39.12,117.84 39.11,117.84 39.08,117.84 38.71,118.21 38.67,118.21 C9903.1
  BOTTOM w0.508: v1(39.22,117.84) 39.22,117.6 C9904.1 38.62,116.96 R9629.1
GND: length 2338.5
  TOP w0.089: 89.32,128.05 89.07,128.05
  TOP w0.102: RC324.2 111.53,97.78 110.63,97.78 110.5,97.91 110.5,98.54 110.63,98.67 111.19,98.67 111.57,99.05 112.7,99.05 113.15,99.5 113.15,99.66 113.56,100.07 113.87,100.07 114.08,99.86 114.08,99.42 v3(113.7,99.04) 113.37,98.71 PC6119.2 112.58,98.47 112.46,98.34 112.46,98.07 RC324.2
  TOP w0.203: PU5401.3 87.08,53.23 v1(87.36,52.95) ; PU5401.1 85.76,52.43 PU5401.23 ; PU5201.22 234.65,34.21 234.3,34.56 v1(234.3,35.42) ; v3(128.09,89.29) 127.84,89.04 C9960.2 ; PU5401.14 83.16,52.83 82.95,52.62 v1(82.95,52.62) ; JUSB1.7 13.11,93.75
  TOP w0.254: v1(80.91,129.25) 80.96,129.3 C9916.2 ; U6.H4 U6.G5 ; U6.G5 v8(88.23,131.31) ; U6.G5 v8(88.23,130.66) ; v1(99.93,108.24) 99.93,108.42 RC423.2 ; U6202.63 267.83,35.88 v1(267.6,35.65) ; v8(84.98,128.71) 85.31,129.03 U6.L8 ; PQ5214.4 250.52,33.12 v1(250.51,33.14) ; PU5703.8 215.85,54.08 215.58,54.34 v1(215.45,54.34) ; v8(90.18,130.66) U6.C5 v8(90.18,131.31) U6.D4 ; v8(90.18,130.66) U6.D5 v8(89.53,131.31) U6.E4 U6.F4 v8(88.23,131.31) ; v8(90.18,130.66) U6.D6 89.74,130.21 89.74,129.81 U6.D7 ; v1(129.09,140.91) 128.75,140.57 U6203.25 ; 70.9,69.3 71.64,70.05 PQ5106.1 ; v8(88.23,130.01) U6.G6 v8(88.23,130.66) ; v8(88.23,130.01) U6.F7 ; v8(88.23,130.01) U6.F6 v8(88.23,130.66) ; v8(88.23,130.01) U6.G7 ; v8(88.23,130.66) U6.F5 v8(88.23,131.31) ; PC6119.2 113.37,98.46 PC6107.2 112.81,97.75 112.58,97.52 112.58,97.09 v3(112.33,96.84) ; U6.J11 86.61,127.08 v8(86.28,126.76) 86.61,126.43 U6.J12 ; v3(128.74,93.49) 129.28,92.94 C9959.2 ; QZ22.4 18.88,121.16 18.98,121.27 v1(18.98,121.65) ; U38.B66 231,53.63 U38.C8 ; U26.16 273.59,43.27 ; RC169.1 155.18,76.09 155.09,75.99 154.64,75.99 JDEG1.10 154.64,76.88 v1(154.4,77.12) ; v8(90.18,127.41) U6.D10 ; PU5701.8 v1(215.85,62.54) ; U6.D9 v8(89.53,128.71) 89.86,129.03 U6.D8 ; U38.B18 238,52.63 v1(237.93,52.57) ; v8(85.63,129.36) 85.63,129.36 85.31,129.68 U6.L7 U6.L6 ; U26.32 267.42,39.77 v1(267.27,39.61) ; v8(88.23,131.31) U6.G4 ; PQ5104.1 74.87,67.39 75.23,67.03 76.42,67.03 76.74,67.35 v1(78.42,67.35) ; U6202.34 v1(260.72,27.42) ; 79.75,129.03 80.12,129.03 80.88,128.26 v1(80.96,128.26) C9917.2 ; v1(124.7,123.31) 124.38,123.62 PU5902.4 ; v1(235.01,52.58) 235.01,52.55 235,52.54 U38.B11 ; v1(146.07,128.22) 145.1,127.24 144.21,127.24 143.44,126.48 143.44,125.21 143.57,125.08 143.57,122.92 143.44,122.8 v1(143.44,122.16) 143.44,121.27 144.06,120.66 147.25,120.66 147.38,120.79 147.38,124.83 147.76,125.21 147.76,125.87 148.55,126.66 148.55,128.07 C117.2
  TOP w0.279: v1(187.01,138.86) U22.1 ; U26.26 267.25,42.77 v1(267.14,42.66) ; v1(145.69,53.15) 145.96,52.88 JKB1.8 ; JAPS1.8 158.63,81.41 v1(158.46,81.59) ; U37.B27 264.61,54.08 264.35,54.34 v1(264.35,54.47) ; JDEG2.11 143.03,75.82 143.5,75.35 143.5,73.27 v1(143.39,73.17) ; v1(16.12,95.11) 16.61,95.11 16.61,95.11 D17.3 18.81,95.11 v1(18.86,95.06) ; v1(142.78,60.62) 142.6,60.8 JTP1.8 ; JDEG2.9 142.03,75.82 141.64,75.43 v3(140.54,75.43) ; v1(145.65,53.77) 145.67,53.77 145.78,53.88 JKB1.10 ; U6202.2 267.22,37.3 v1(267.77,37.85) ; JCSW1.2 v1(124.5,61.08) 125.03,61.08 125.41,61.46 126.2,61.46 126.5,61.76 JCSW1.6 ; U26.11 273.86,40.77 ; U38.B54 229.63,59.63 v1(230.03,60.03) ; v1(230.03,56.63) U38.B60
  TOP w0.305: v1(258.27,26.79) 258.27,27.02 258.01,27.28 PQ5210.1 ; PQ5220.4 229.54,38.15 v1(229.86,38.47) ; v1(117.03,65.44) 117.16,65.44 117.8,64.8 JLID1.6 ; v3(129.36,90.98) 129.36,90.63 129,90.27 C9639.2 ; v3(130.97,87.87) 131.29,88.19 C9638.2 ; v1(160.29,84.11) 159.99,84.41 JAPS1.14 ; PC6082.2 124.67,98.79 v3(124.67,98.94) ; PQ5202.4 250.36,26.44 250.31,26.5 v1(250.31,26.5) ; C9625.2 128.01,90.21 128.74,90.94 v3(128.74,90.97) ; JLID1.4 116.8,64.61 v1(117.03,64.83) 117.3,64.56 JLID1.5 ; C9507.2 161.86,137.15 v1(162.49,137.78) ; v1(77.86,111.93) 77.8,111.87 77.22,111.87 PC5815.1 ; PQ5202.1 251.66,27.48 251.9,27.24 v1(251.9,26.51) ; R9544.2 93.58,118.75 v1(93.58,117.88) 93.92,117.88 C9906.1 ; v1(249.93,35.01) 249.93,34.62 249.73,34.42 PQ5214.1 ; v3(132.24,89.85) 132.24,89.64 CC24.2 ; PC5826.1 78.29,110.41 78.74,110.85 v1(78.76,110.85) ; PU5202.3 232.54,39.07 v1(232.27,38.8) ; 139.1,60.85 JTP1.1 ; JAPS1.10 v1(158.45,82.41) ; JAPS1.12 158.96,83.41 158.59,83.04 v1(158.42,83.04) ; RC96.1 133.39,90.57 v3(133.39,91) ; PQ5220.1 v1(230.84,38.72) ; PQ5210.4 256.71,24.91 256.87,24.75 v1(257.36,24.75) ; U6207.4 46.88,88.97 47.13,89.22 v1(47.13,89.85)
  TOP w0.356: v1(246.24,44.82) 246.35,44.93 Q5.4 ; v1(80.71,34.15) 80.82,34.26 U5.3 ; R372.1 245.3,47.23 244.87,46.8 Q5.1 v1(245.93,46.23) ; v1(47.76,89.85) 47.76,88.02 48.12,87.67 U6207.1 ; v1(216.47,69.33) 216.47,67.93 216.87,67.54 U6218.3 ; Q17.1 45.77,97.97 v1(45.71,98.03) ; v1(47.25,100.57) 47.07,100.38 Q17.4 ; PU1.2 v1(252.54,41.37)
  TOP w0.381: PR5312.1 v1(192.37,62.68) ; RN4146.2 v1(164.02,61.33) ; v1(241.11,53.53) 241.11,53.28 241.39,53 241.58,53 242.02,52.55 242.02,52.38 C367.2 242.73,52.11 243.04,51.8 R394.1 ; C390.2 180.88,90.92 180.48,91.32 v1(180.48,91.58) 180.73,91.58 180.96,91.81 C9841.2 ; C9506.2 158.41,129.27 v1(158.05,128.91) ; v1(241.92,35.78) 241.82,35.68 PC5237.1 ; CD132.2 146.75,34.34 v1(146.75,34.93) 146.75,35.24 RD66.2 ; CE1.2 CE2.2 32.53,101.77 v1(32.14,101.38) ; PC5836.2 71.17,109.67 71.17,109.86 v1(71.61,110.3) ; PH5801.1 59.57,91.25 59.83,91.5 ; PR5258.2 v1(224.9,44.12) ; 129.78,69.1 v1(129.78,69.11) 130.01,68.89 CC289.1 ; v1(129.78,71.41) 130.21,70.98 130.55,70.98 CC25.1 ; v1(232.52,27.75) 232.65,27.88 PC5203.2 ; v1(80.27,137.15) 80.2,137.08 C42.2 82.47,136.56 82.53,136.63 84.13,136.63 85.05,135.71 v1(85.05,135.16) ; v3(102.07,97.04) 102.07,97.57 RC114.1 ; PC5704.2 218.91,64.44 v1(218.61,64.75) ; RC593.2 136.89,89.94 v3(136.4,89.45) ; U6205.27 168.44,49.21 C9553.2 ; 80.86,133.9 81.14,134.18 82.04,134.18 82.52,134.66 83.1,134.66 84.16,133.6 84.16,133.4 v8(84.31,133.25) ; C9915.2 81.11,130.67 ; UC14.3 125.81,67.43 v1(126.2,67.43) ; C9640.2 138.43,96.66 v3(138.69,96.39) ; v1(224.23,46.49) 224.23,46.68 C342.1 ; v1(224.23,46.49) 224.45,46.49 224.9,46.04 PR5261.1 ; v1(224.23,46.49) 224.01,46.27 PC5240.1 ; v1(253.83,63.59) 253.81,63.56 R9684.1 ; RC324.2 111.54,97.16 v3(111.54,96.81) ; PC5224.1 v1(241.86,31.48) ; RN4139.2 v1(164.02,63.23) ; v1(129.78,122.31) 129.68,122.21 PR5509.2 ; v1(183.07,108.7) 182.9,108.53 182.24,108.53 182.23,108.55 C9927.2 ; PC5319.2 193.43,60.97 v1(193.43,61.51) ; PC5241.1 v1(224.01,44.12) ; CC269.2 132.34,92.52 v3(133.01,93.18) ; C68.2 34.94,102.34 C9908.2 ; 123.76,74.25 123.76,74.97 R801.2 123.96,75.38 v3(123.58,75.76) ; PR5916.1 108.47,128.79 v1(108.47,128.41) ; v1(227.14,48.55) 227.61,48.55 228.06,49 C343.2 C354.2 ; PC5843.1 68.72,122.24 v1(68.26,121.78) ; v1(241.92,34.39) 241.9,34.41 PC5234.1 ; RN4141.2 163.84,60.44 v1(164.04,60.64) ; RN4133.2 RN4132.2 v1(170.5,64.25) ; v1(217.38,64.76) 217.13,64.5 PR5703.2 ; v1(169.86,59.93) 170.95,59.93 RN4145.2 ; v1(74.02,75.76) 74.02,73.36 73.48,72.82 PQ5106.4 ; C9493.2 176.01,50.13 v1(175.8,50.33) ; C9900.2 34.61,119.62 34.22,119.24 v1(33.95,119.24) ; v1(245.71,38.75) 245.68,38.72 C368.2 ; RC153.2 101.41,113.02 v1(101.03,113.4) ; v1(239.1,28.08) 238.8,28.39 PC5214.2 ; PR5801.1 PC5801.2 65.34,120.61 v1(65.95,121.22) ; PR5224.1 239.3,26.24 v1(239.23,26.16) ; PC5222.1 v1(241.9,30.6) ; v3(129.09,77.2) 129.67,76.63 C9644.2 C9645.2 ; RC158.2 132.09,96.11 v3(132.22,96.24) ; v1(245.58,59.42) 245.58,60.21 C363.2 ; CC5.1 130.09,65.62 v1(129.85,65.62) 129.85,64.79 130.38,64.26 CC287.1 ; v1(47.31,120.38) 47.56,120.64 C139.2 ; C9886.2 170.48,65.9 v1(169.99,66.4) ; PR5714.2 211.54,54.42 v1(211.14,54.42) ; v1(107.88,124.65) PH5804.1 ; CE14.2 171.68,66.79 170.38,66.79 170,66.41 ; v1(55.94,90.03) 56.45,90.03 57.39,90.97 PR5914.1 ; PR5307.1 v1(195.72,69.36) ; RN31.1 174.23,49.52 v1(174.38,49.37) ; v1(144.97,28.18) 145.27,28.49 RD72.2 ; C189.2 v1(145.6,125.72) ; PR5704.2 214.23,64.2 214.67,64.64 v1(215.29,64.64) ; RN4134.2 v1(169.86,59.17) ; PC5809.1 81.01,115.56 v1(80.86,115.41) ; RN4107.2 172.43,61.56 v1(173.16,61.56) ; PC5514.2 131.89,123.23 131.86,123.2 v1(131.76,123.2) ; v1(176.16,50.86) 176.16,51.52 C9494.2 C9495.2 C9926.2 176.01,54.48 C3079.2 ; RN4140.2 163.89,62.35 v1(164.02,62.22) ; C9627.2 137.81,89.73 138.09,90.01 139.3,90.01 139.81,89.5 RC21.2 139.94,89.27 v3(139.94,88.71) ; C349.2 233.41,64.83 233.44,64.81 R366.1 234,65.46 v1(234.01,65.48) ; C9554.2 167.14,61.92 U6206.29 ; R268.2 80.25,126.07 v1(80.53,126.35) ; 42.66,132.8 42.43,132.58 R9617.2 v1(43.09,132.17) ; v1(231.6,65.65) 231.71,65.54 C362.2 231.25,64.83 231.15,64.94 CC286.1 ; PC5835.2 69.05,107.89 v1(68.9,107.73) ; v3(135.42,96.25) 135.42,96 134.91,95.49 RC480.2 ; v1(190.28,62.03) 190.8,62.03 PR5308.1 ; RN4147.2 v1(164.02,59.55) ; v1(101.46,114.8) 102.25,115.58 RC155.2 ; v1(241.21,47.23) 241.21,46.95 241.97,46.19 R9583.1 ; C9512.2 C9911.2 41.52,102.48 41.9,102.86 v1(42.15,102.86) ; PR5713.2 PC5722.2 213.8,54.78 v1(213.35,54.78) ; v1(250.89,44.74) 250.98,44.65 UC13.3 ; v1(222.16,68.49) 222.16,67.78 222,67.62 UC11.3 ; v1(77.86,112.76) 77.38,112.76 PC5812.1 ; PC5901.2 105.29,125.51 v1(105.22,125.44) ; CC279.1 125.74,73.09 v1(126.2,72.63) ; C369.2 v1(243.52,47.87) ; v1(159.74,137.11) 159.74,136.76 159.44,136.46 U24.3 ; C391.2 180.12,97.91 v1(179.94,97.73) 179.94,97.55 180.19,97.31 180.52,97.31 180.81,97.02 C397.2 ; PR5232.2 v1(241.9,32.37) ; C380.2 148.13,64.12 v1(147.65,63.64) 147.12,64.17 D22.2 ; PC5825.1 v1(78.07,113.7) 78.19,113.58 78.67,113.58 ; C9508.1 v1(34.94,99.81) ; v1(132.7,123.97) 131.7,123.97 PR5506.1
  TOP w0.406: v1(139.25,126.61) 139.38,126.48 R182.1 ; RC128.2 136.01,26.28 136.2,26.48 v1(136.52,26.48) ; v1(73.76,108.76) 73.51,108.76 73.14,108.4 PC5842.1 ; PC5715.2 186.83,112.08 186.65,112.26 186.07,112.26 185.58,111.77 v1(184.14,111.77) ; C263.2 15.62,140.13 v1(15.68,140.07) ; 123.76,74.25 123.76,74.03 123.33,73.6 RC421.2 ; C395.1 v1(227.32,65.52) ; R802.2 126.02,75.38 v3(126.23,75.58) ; PC5716.2 PR5708.2 185.84,110.96 185.58,111.21 184.31,111.21 v1(184.19,111.09) ; v1(151.23,80.78) 151.39,80.62 UC3.3 ; v1(59.69,115.84) 59.08,115.84 58.58,115.35 UC12.3 ; UC10.3 v1(187.64,100.51) ; RC198.1 131.51,76.59 131.21,76.89 v3(131.02,76.89) ; PR5508.1 132.37,124.91 v1(132.29,124.83) ; v1(65.42,90.01) 65.39,90.03 PC5925.2 ; v1(159.14,88.99) 158.55,89.59 CC94.2 157.3,89.59 157.05,89.34 UC9.3 ; v1(94.58,123.43) 95.06,123.43 95.31,123.69 R47.2
  TOP w0.432: R175.2 142.38,127.7 v1(142.58,127.5) ; PR5834.1 69,104.59 68.64,104.94 v1(68.64,105.53) ; v1(181.15,123.69) 181.15,124.88 C3054.2 ; C9509.2 43.68,100.7 43.53,100.55 v1(43.53,100.55) ; CC282.1 v1(255.46,44.69) ; PR7408.2 181.95,25.62 v1(181.95,23.48) ; v1(251.19,51.27) 251.6,51.68 R9417.1 ; v1(266.42,44.7) 266.63,44.92 R321.2 ; C9907.2 43.68,103.04 v1(43.88,103.24) ; v1(135.95,40.5) 135.7,40.5 135.37,40.17 RC83.2 ; R474.2 15.43,119.37 v1(14.92,119.88) ; R9529.1 192.77,146.19 193.2,145.76 v1(193.36,145.76) ; JTAG1.2 229.42,70.17 ; R9394.2 270.86,29.87 v1(271.21,30.21) ; 90.36,55.84 90.74,55.84 90.94,55.64 v1(90.94,55.56) 90.94,55.16 90.74,54.95 90.36,54.95 ; C9941.2 259.04,39.89 v1(258.56,39.41) ; R9692.1 61.94,120.51 v1(62.24,120.21) ; R373.1 238.31,70.17 ; v1(261.61,6.23) 262.06,5.78 R438.1 ; RD67.2 147.89,35.04 v1(148.02,34.91) ; R9587.1 v1(243.7,46.34) ; v1(255.97,63.11) 255.71,62.85 R310.1 ; CC281.1 v1(251.28,52.69) ; R377.1 233.28,70.14 ; PC7406.2 v1(196.58,25.36) ; C9923.2 v1(181.54,135.45) ; R309.1 v1(262.95,62.98)
  TOP w0.457: v1(250.63,53.32) 250.68,53.26 R354.1 ; v1(66.53,115.31) 67.02,115.31 PC5805.2 ; PC5840.1 73.24,106.16 v1(73.52,106.16) ; v1(80.55,113.03) 80.55,112.21 80.07,111.72 PR5828.2 ; R9690.1 248.65,51.7 248.61,51.74 248.61,52.29 v1(248.2,52.7) ; PC5822.1 63.38,112.89 v1(63.6,112.67) ; v1(250.26,46.93) 250.26,47.53 249.81,47.98 C9982.2 ; PC5839.1 64.04,111.11 63.84,110.91 v1(63.84,110.63) ; C136.2 v1(50.35,122.8) ; R9492.1 43.75,97.96 v1(43.75,98.03) ; v1(66.2,113.58) 66.23,113.6 PC5820.1 ; C340.1 v1(225.88,48.55) C344.2 ; v1(64.01,114.19) 64.36,113.83 PC5814.1 ; C3083.2 181.14,128.42 180.88,128.17 180.88,127.45 181.21,127.12 v1(181.45,127.12) ; PC5817.1 83.5,112.73 v1(83.06,113.17) ; v1(181.19,96.28) 181.6,95.87 C396.2 ; v3(128.1,93.49) 128.01,93.4 C9637.2 ; v1(74.61,105.27) 73.39,105.27 73.21,105.45 PC5837.2 ; R32.2 v1(79.63,30.92) ; R9673.1 55.26,115.98 54.93,116.31 v1(54.93,116.57) ; PC5808.2 62.85,116.24 v1(63.08,116.02) ; v1(186.73,109.22) PR5709.2 ; R803.2 127.06,75.2 v1(127.68,74.58) 127.9,74.81 RC89.2 RC88.2 ; PC5824.1 82.41,110.91 82,111.32 v1(82,111.88) ; v1(232.24,35.37) 232.73,35.37 PC5238.1
  TOP w0.508: JUSB1.13 7.03,101.6 ; JUSB1.13 3.37,101.6 ; JUSB1.13 5.2,102.43 ; C9842.1 181.9,88.84 181.47,89.27 v1(180.5,89.27) ; C9956.2 270.44,45.97 v1(270.44,45.33) 270.39,45.28 C9953.2 ; 144.08,142.48 144.53,142.94 JUSB2.7 144.53,145.2 ; v1(144.01,39.74) 144.21,39.55 144.21,38.98 ; v1(146.94,126.44) 147.17,126.21 C190.2 ; JCRT1.16 70.32,147.53 ; JCRT1.16 68.45,147.53 ; JCRT1.16 69.38,145.65 ; PC5915.2 123.58,128.82 ; v1(271.84,35.29) 272.55,36.01 C9955.2 ; v1(150.68,65.27) 150.38,64.96 C378.2 ; v1(41.82,110.61) 41.82,110.26 C61.2 ; CD85.2 146.26,45.86 v1(145.76,45.36) ; C9905.2 182.13,109.51 v1(182.56,109.08) ; 10.8,103.12 JHDMI1.22 ; JHDMI1.22 12.63,104.05 ; JHDMI1.22 8.97,104.05 ; JHDMI1.22 10.8,104.98 ; Q3610.3 v1(265.49,4.69) ; C331.2 256.47,44.64 255.92,44.08 v1(255.46,44.08) ; v1(117.03,66.66) 115.87,66.66 115.19,65.98 C1189.2 ; RN4112.2 RN4111.2 v1(170.5,52.57) ; C351.2 v1(242.44,58.71) ; v1(268.67,43.17) U26.33 v1(268.67,39.87) ; JCRT1.8 83.23,149.76 v1(83.12,149.64) ; PR5227.1 239.81,28.61 v1(240.4,28.03) ; D7113.2 v1(194.03,145.91) ; C379.2 148.22,61.47 147.78,61.02 v1(147.75,61.02) 147.72,61.02 147.59,61.16 D25.2 ; C426.2 v1(183.7,135.56) ; C198.1 162.39,140.73 ; PC5406.2 89.43,52.87 v1(88.53,52.87) ; C452.2 v1(184.47,140.2) ; C9647.2 146.39,109.16 146.47,109.08 146.47,109.03 v1(146.67,108.83) ; C364.2 226.69,54.85 v1(227.14,54.85) ; RN4121.2 v1(164.02,49.01) ; v1(18.81,97.42) 18.78,97.4 C291.2 ; C371.2 242.47,60.88 242.85,61.27 v1(243.08,61.27) ; v1(126.3,60.91) 126.87,60.91 JCSW1.8 ; PR5716.2 v1(64.96,136.82) ; R9486.2 29.02,95.65 29.4,96.03 v1(29.4,97.91) ; C337.2 251.65,58.28 v1(251.39,58.03) ; v1(224.09,60.69) 224.34,60.44 C356.2 ; C330.2 251.39,53.71 251.16,53.94 v1(251.16,53.96) ; CD98.2 143.19,34.71 v1(142.81,35.09) ; C393.1 181.99,99.75 v1(182.05,99.81) ; v1(173.44,122.42) 173.53,122.33 C9885.2 ; CD61.2 126.68,26.33 v1(127.01,26.66) ; CD34.2 106.74,25.13 ; CD34.2 107.54,25.96 ; CD34.2 105.76,25.96 ; v1(237.3,65.49) 237.3,64.94 R368.1 ; v1(144.84,45.43) 144.84,45.95 CD24.2 ; v1(64.91,138.04) PC5726.2 ; v1(224.85,55.49) R370.2 ; X1.4 v1(146.33,125.08) ; v1(28.79,97.91) 28.79,96.3 28.13,95.65 R9483.2 ; v1(144.08,108.83) 144.36,109.11 144.36,110.31 144.35,110.32 C9649.2 ; v1(138.48,37.09) 137.98,37.59 CD97.2 ; v1(243.65,23.1) 243.93,22.82 PQ5211.2 ; C389.2 v1(180.48,89.9) ; CD133.2 147.26,31.48 v1(147.89,31.48) ; 146.49,140.35 146.49,137.73 R184.1 ; C1002.2 259.01,5.89 v1(259.01,6.47) ; U7.4 71.94,140.7 v1(71.69,140.96) ; CC285.1 238.19,66.49 v1(238.19,66.1) ; C9552.2 v1(161.85,53.2) ; 13,99.22 JUSB1.11 13,101.08 ; v1(198.92,22.9) 199,22.82 PQ5209.2 ; C339.2 v1(270.64,54.76) ; v1(73.85,24.05) C50.2 ; R399.2 v1(221.77,56.58) ; C9445.2 C9446.2 v1(259.21,24.75) ; C68.2 34.39,102.88 v1(34,102.88) ; RN4126.2 v1(164.02,49.9) ; C345.2 222.86,51.07 222.87,51.03 v1(222.87,50.53) ; v1(264.76,39.26) C9433.2 ; 10.57,108.55 JHDMI1.2 11.22,109.2 ; X1.2 143.78,121.82 v1(143.44,122.16) ; v1(271.13,26.25) 271.03,26.15 v8(271.03,25.34) ; PC5415.2 v1(83.81,55.77) ; v1(144.64,52.59) 144.51,52.59 144.02,52.1 C375.2 C376.2 ; v1(271.21,30.85) 271.02,31.04 C9449.2 ; JSER1.11 103.32,147.47 ; JSER1.11 104.2,145.68 ; JSER1.11 105.07,147.47 ; RN4127.2 v1(164.02,48.12) ; CC57.1 126.49,70.25 v1(126.2,69.97) ; PR5311.1 v1(193.91,66.66) ; PQ5215.2 v1(255.74,32.5) ; v1(135.06,67.98) 134.43,67.98 134.22,67.77 C9642.2 C9643.2 ; v1(154.09,102.27) 154.84,101.52 C9653.2 ; v1(244.16,28.94) 244.22,29.01 PQ5217.2 ; v1(206.26,148.89) 206.83,148.89 C3602.2 ; R384.1 v1(230.95,68.2) ; JUSB1.10 13,88.2 ; JUSB1.10 13,86.5 ; JUSB1.10 14.41,87.35 ; PR5116.2 67.5,85.54 v1(67.5,83.3) ; PU5203.4 222.28,46 222.21,46.06 v1(222.21,46.47) ; Y1.4 78.84,137.9 ; JCRT1.17 100.31,147.53 ; JCRT1.17 98.43,147.53 ; JCRT1.17 99.37,145.65 ; v8(19.57,132.27) v1(19.57,133.23) ; C332.2 259.01,62.85 259.22,63.06 v1(259.22,63.62) ; JHDMI1.23 12.63,122.35 ; JHDMI1.23 10.8,123.28 ; JHDMI1.23 8.97,122.35 ; JHDMI1.23 10.8,121.42 ; R9415.1 251.65,59.81 v1(251.5,59.65) ; v1(252.79,32.6) 253.14,32.95 PQ5216.2 ; C9505.2 v1(182.43,137.1) ; RC20.2 134.22,110.91 v1(134.07,111.06) ; CD13.2 126.81,37.58 127.44,36.95 v1(127.6,36.95) 127.95,37.3 127.95,37.84 CD12.2 ; C9447.2 v1(262.37,40.81) 261.86,40.81 261.33,40.27 C9451.2 ; v8(271.84,25.34) v1(271.84,26.3) ; C3053.2 180.99,120.38 180.53,120.84 v1(180.53,121.45) ; C366.2 245.55,53.5 v1(245.55,52.69) ; 182.94,149.17 JLAN1.10 184.02,151.28 ; 21.63,132.25 v1(21.63,133.11) ; v1(135.24,139.05) 135.24,138.87 C9456.2 ; CC266.2 PR6091.2 156.32,93.15 156.32,93.67 156.04,93.94 v1(155.69,93.94) 155.69,93.33 RC374.1 ; v1(84.39,36.95) 84.01,37.33 CD95.2 ; C9631.2 131.89,99.62 v3(131.95,99.68) ; v1(244.18,29.78) 244.49,29.78 244.87,30.16 PR5225.2 ; v1(70.42,124.47) PC5802.1 ; CC290.1 127.57,70.4 v1(127.95,70.03) 128.27,70.03 128.71,70.47 CC80.1 ; PR5248.1 238.9,37.88 ; PU5903.14 62.09,91.73 PR5833.1 ; v1(164.07,122.59) 164.5,122.16 D2801.2 166.69,122.16 v1(167.04,122.52) 167.54,122.52 C2802.2 ; SW5.2 v1(185.23,141.42) ; C34.2 77.91,146.42 ; v1(141.16,108.19) 140.27,109.08 C9656.2 139.92,110.68 CC278.1 ; JLID1.8 119.45,60.62 v1(119.55,60.72) ; v1(181.32,93.33) 181.7,92.95 C9843.1 ; C3603.2 v1(210.56,142.42) ; 112.79,150.63 JSER1.5 ; PR5816.1 PR5819.1 77.7,120.55 v1(77.91,120.77) ; v1(226.93,51.42) 226.87,51.49 C365.2 ; v1(153.73,98.77) 153.87,98.77 C9654.2 ; v1(174.72,56.13) 175.89,54.97 C3079.2 ; C9491.1 245.45,59.3 v1(245.58,59.42) ; 1.87,122.35 JHDMI1.21 ; JHDMI1.21 3.7,123.28 ; JHDMI1.21 5.53,122.35 ; RC132.2 130.36,26.21 v1(130.01,26.56) ; C410.2 44.97,116.32 v1(45.05,116.24) ; v1(241.21,47.23) 241.21,47.49 241.68,47.96 C355.2 ; C9555.2 162.03,64.17 v1(161.92,64.06) ; v1(130.49,40.37) 130.01,40.37 129.78,40.15 129.78,39.56 130.18,39.16 RC69.2 ; C347.2 v1(221.55,58.61) ; PC5408.1 81.03,52.3 v1(80.63,51.91) ; C329.2 v1(269.4,55.23) ; C117.2 R185.1 149.54,127.22 150.02,126.73 v1(150.81,126.73) ; C9633.2 128.78,94.39 v3(128.74,94.35) ; Q4200.2 193.49,148.04 193.97,147.56 193.97,146.92 193.56,146.52 v1(193.38,146.52) ; v1(84.26,48.25) 84.52,47.99 85.69,47.99 PC5416.2 ; v1(125.01,26.9) 125.28,26.63 CD60.2 ; CD106.2 135.44,27.04 134.9,26.49 v1(134.52,26.49) ; v1(76.44,121.17) 75.73,121.17 PC5804.1 ; PR5717.2 v1(64.86,139.18) ; JLID1.7 113.65,60.48 v1(113.97,60.8) ; v3(136.4,89.45) 136.27,89.32 CC26.2 ; C377.2 149.87,60.26 v1(149.64,60.26) ; C9448.2 v1(271.14,35.29) ; RN4125.2 v1(170.62,48.5) ; CC284.1 245.43,56 v1(245.68,55.74) ; Q4.2 46.86,103.53 v1(46.57,103.82) ; v1(67.27,141.95) 68.32,141.95 PC5730.2 ; v8(271.03,15.59) v1(271.03,14.85) ; C2750.1 v1(50.43,123.76) ; v8(22.82,131.46) v1(23.85,131.46) ; PQ5102.2 247.31,41.14 v1(247.1,40.93) ; C62.2 v1(43.82,104.58) ; C9957.1 271.91,49.45 v1(271.59,49.77) ; v1(257.11,29.71) 257.24,29.83 C9450.2 ; v1(180.48,87.39) 181.01,87.39 C401.2 ; 170,66.41 v1(169.99,66.4) ; JHDMI1.5 9.14,110.7 v1(9.74,110.1) ; PC5512.2 v1(132.29,127.24) ; v1(230.85,34.1) 231.28,34.53 PC5227.2 ; R371.1 v1(243.14,56.88) ; PC5411.2 v1(88.5,53.73) ; v1(79.69,57.39) 79.89,57.19 79.89,56.35 80.4,55.84 81.19,55.84 81.28,55.93 PC5409.2 ; v1(73.73,121.08) PC5803.1 ; C266.2 14.1,137.52 ; v1(158.66,96.65) 158.42,96.41 C9655.2 ; PQ5212.2 v1(248.67,31.55) ; RN4119.2 v1(164.02,51.68) ; RN4120.2 v1(164.02,50.79) ; C353.2 v1(223.96,57.52) ; PC5201.2 235.14,27.13 v1(235.14,26.62) ; C9929.2 v1(73.15,29.38) ; v1(180.48,86.09) 180.81,85.76 C400.1 ; PC5314.2 190.25,69.3 190.64,69.69 191.35,69.69 191.7,69.33 v1(192.47,69.33) ; v1(146.29,43.65) 146.29,44.4 CD86.2 ; JHDMI1.20 5.53,104.05 ; JHDMI1.20 3.7,103.12 ; JHDMI1.20 1.87,104.05 ; 7.03,85.9 JUSB1.12 3.37,85.9 ; C9454.2 131,146.42 v1(131,147.04) ; v1(80.81,39.18) 81.7,39.18 R34.1 ; PC5235.2 234.41,37.87 234.41,37.93 234.18,38.16 v1(234.18,38.75) ; v1(260.11,41.77) 260.65,41.77 C9437.2 ; v1(142.1,108.78) 142.1,109.21 142.31,109.42 C9648.2 ; C374.2 145.21,63.91 v1(145.45,63.67) ; PR5240.2 v1(244.18,35.04) ; v1(159.91,76.66) 159.91,76.19 160.29,75.81 JAPS1.19 ; C346.2 C352.2 242.63,54.48 v1(242.63,53.58) ; C9899.2 v1(47.51,123.05) ; v1(76.06,134.27) Y1.2 77.24,133.2 ; v1(160.79,73.57) 160.79,73.65 160.31,74.13 158.71,74.13 157.27,72.7 JDEG1.12 ; v1(159.75,87.8) 160.23,87.8 160.95,88.51 JAPS1.20 ; JSER1.10 134.18,146.28 135.82,144.64 135.82,142.94 135.82,142.94 C9855.2 ; 18.63,131.15 v1(17.71,131.15) ; v1(258.51,63.62) C336.2 ; v1(37.91,103.5) 37.91,103.49 C64.2 ; OCS4801.2 v1(265.66,40.78) ; v1(104.86,40.37) 105.73,40.37 106.17,39.93 CD3.2 ; RD73.2 150.43,31 v1(150.91,31.48) ; v1(236.19,38.71) 236.19,38.56 236.61,38.14 PC5236.2 ; 161.76,151.28 JLAN1.9 162.84,149.03 ; JCRT1.6 78.65,149.78 78.24,149.37 ; CD23.2 v1(83.5,34.91) ; C9954.2 v1(272.29,46.56) ; JCSW1.7 122.35,60.5 v1(121.99,60.87) ; v1(170.61,62.54) 170.94,62.22 RN4135.2 ; RC617.2 166.28,60.73 U6206.26 ; RN4113.2 v1(170.62,47.49) ; v1(139.34,130.63) 139.09,130.63 138.62,130.16 C180.2 ; v1(87.85,149.37) 87.81,149.4 JCRT1.10 ; C3701.2 v1(263.41,40.76) ; PR5259.1 224.01,39.82 ; v8(266.97,18.84) v1(266,18.84) ; 161.2,143.8 JUSB2.8 160.03,145.2 ; CD100.2 v1(94.02,37.2) ; v8(266.97,20.46) v1(266.17,20.46) ; C1187.2 v1(258.89,10.07) ; v1(225.36,62.73) 225.49,62.85 C360.2 ; R383.2 v1(245.48,58.15) ; PR5110.1 241.74,36.31 241.92,36.13 v1(241.92,35.78) ; v1(35.24,109.84) C440.2 ; v1(50.38,121.53) C135.2 ; C9514.2 13.78,142.02 ; C9840.2 v1(180.48,86.73) ; C9513.2 12.89,142.02 ; v8(22.82,130.65) v1(23.91,130.65) ; RN4114.2 v1(170.5,50.53) ; JHDMI1.8 11.29,112.2 ; v8(271.84,15.59) v1(271.84,14.77) ; JCRT1.5 89.72,150.73
  IN1 w0.203: JUSB1.7 13.11,93.75
  IN1 w0.508: JCRT1.16 69.38,145.65 ; JCRT1.16 70.32,147.53 ; JCRT1.16 68.45,147.53 ; 183.93,151.28 JLAN1.10 182.94,149.26 ; 77.89,150.73 JCRT1.6 78.65,149.97 ; JCRT1.17 100.31,147.53 ; JCRT1.17 99.37,145.65 ; JCRT1.17 98.43,147.53 ; 13,99.3 JUSB1.11 ; JUSB1.11 14.41,100.15 ; JUSB1.11 13,101 ; JHDMI1.23 10.8,123.19 ; JHDMI1.23 12.54,122.35 ; JHDMI1.23 10.8,121.51 ; JHDMI1.23 9.06,122.35 ; 6.94,85.9 JUSB1.12 3.34,85.9 ; JHDMI1.22 12.54,104.05 ; JHDMI1.22 10.8,103.21 ; JHDMI1.22 9.06,104.05 ; JHDMI1.22 10.8,104.89 ; 143.72,143.8 JUSB2.7 144.53,145.11 ; 103.41,147.47 JSER1.11 104.98,147.47 ; JHDMI1.21 3.7,123.19 ; JHDMI1.21 1.96,122.35 ; JHDMI1.21 5.44,122.35 ; 13,86.5 JUSB1.10 ; JUSB1.10 13,88.2 ; JUSB1.10 14.41,87.35 ; 87.81,149.97 JCRT1.10 ; 11.24,112.2 JHDMI1.8 9.9,112.2 ; 13.11,90.25 JUSB1.4 ; JUSB1.4 14.69,90.25 ; JUSB1.4 13.9,89.46 ; JUSB1.4 13.9,91.04 ; 83.23,149.97 JCRT1.8 ; 160.85,143.8 JUSB2.8 160.03,145.11 ; 80.94,149.97 JCRT1.7 ; JHDMI1.11 9.69,113.7 ; 162.84,149.26 JLAN1.9 161.85,151.28 ; JUSB2.4 147.51,140.45 v1(147.48,140.48) ; JHDMI1.2 11.24,109.2 ; JHDMI1.2 10.57,108.53 ; JHDMI1.2 9.9,109.2 ; 112.84,150.63 JSER1.5 ; 3.46,101.6 JUSB1.13 ; JUSB1.13 5.2,102.34 ; JUSB1.13 6.94,101.6 ; JCRT1.5 89.72,150.73 ; 1.96,104.05 JHDMI1.20 ; JHDMI1.20 5.44,104.05 ; JHDMI1.20 3.7,103.21 ; JHDMI1.5 9.69,110.7
  IN2 w0.203: JUSB1.7 13.11,93.75
  IN2 w0.508: 161.85,151.28 JLAN1.9 162.84,149.26 ; 3.7,103.21 JHDMI1.20 ; JHDMI1.20 5.44,104.05 ; JHDMI1.20 1.96,104.05 ; 6.94,85.9 JUSB1.12 3.3,85.9 ; JUSB1.13 6.94,101.6 ; JUSB1.13 3.46,101.6 ; JUSB1.13 5.2,102.34 ; JCRT1.16 69.38,145.65 ; JCRT1.16 70.41,147.53 ; JCRT1.16 68.29,147.53 68.29,147.54 ; 13,86.5 JUSB1.10 ; JUSB1.10 14.41,87.35 ; JUSB1.10 13,88.2 ; 10.8,103.21 JHDMI1.22 ; JHDMI1.22 9.06,104.05 ; JHDMI1.22 10.8,104.89 ; JHDMI1.22 12.54,104.05 ; 182.94,149.26 JLAN1.10 183.93,151.28 ; 143.72,143.8 JUSB2.7 144.53,145.11 ; 11.24,112.2 JHDMI1.8 9.9,112.2 ; JHDMI1.17 9.69,116.7 ; 9.06,122.35 JHDMI1.23 ; JHDMI1.23 12.54,122.35 ; JHDMI1.23 10.8,123.19 ; JHDMI1.23 10.8,121.51 ; JHDMI1.2 11.24,109.2 ; JHDMI1.2 10.57,108.53 ; JHDMI1.2 9.9,109.2 ; 160.85,143.8 JUSB2.8 160.03,145.11 ; 1.96,122.35 JHDMI1.21 ; JHDMI1.21 3.7,123.19 ; JHDMI1.21 5.44,122.35 ; JHDMI1.5 9.69,110.7 ; 104.2,145.77 JSER1.11 ; JSER1.11 103.41,147.47 ; JSER1.11 104.98,147.47 ; 99.37,145.65 JCRT1.17 ; JCRT1.17 100.31,147.53 ; JCRT1.17 98.43,147.53 ; 78.65,150.02 JCRT1.6 77.89,150.73 ; 147.91,140.45 JUSB2.4 ; JUSB1.4 14.69,90.25 ; JUSB1.4 13.9,89.46 ; JUSB1.4 13.11,90.25 ; JUSB1.4 13.9,91.04 ; 112.84,150.63 JSER1.5 ; JHDMI1.11 9.69,113.7 ; 83.23,149.97 JCRT1.8 ; JUSB1.11 14.41,100.15 ; JUSB1.11 13,99.3 ; JUSB1.11 13,101 ; JCRT1.10 87.81,150 ; JCRT1.5 89.72,150.73 ; 80.94,149.97 JCRT1.7
  IN3 w0.203: JUSB1.7 13.11,93.75
  IN3 w0.508: 1.96,104.05 JHDMI1.20 ; JHDMI1.20 3.7,103.21 ; JHDMI1.20 5.44,104.05 ; 143.72,143.8 JUSB2.7 144.53,145.11 ; 13,86.5 JUSB1.10 ; JUSB1.10 14.41,87.35 ; JUSB1.10 13,88.2 ; 104.98,147.47 JSER1.11 103.41,147.47 ; 147.91,140.45 JUSB2.4 ; 160.85,143.8 JUSB2.8 160.03,145.11 ; 13,99.3 JUSB1.11 ; JUSB1.11 14.41,100.15 ; JUSB1.11 13,101 ; 100.31,147.53 JCRT1.17 98.57,147.53 98.39,147.71 ; 9.9,109.2 JHDMI1.2 ; JHDMI1.2 10.57,108.53 ; JHDMI1.2 11.24,109.2 ; JUSB1.13 5.2,102.34 ; JUSB1.13 6.94,101.6 ; JUSB1.13 3.46,101.6 ; 112.84,150.63 JSER1.5 ; 9.06,122.35 JHDMI1.23 ; JHDMI1.23 10.8,123.19 ; JHDMI1.23 12.54,122.35 ; JHDMI1.23 10.8,121.51 ; JHDMI1.17 9.69,116.7 ; 11.24,112.2 JHDMI1.8 9.9,112.2 ; 6.94,85.9 JUSB1.12 3.37,85.9 ; 183.93,151.28 JLAN1.10 182.94,149.26 ; JUSB1.4 13.9,91.04 ; JUSB1.4 13.11,90.25 ; JUSB1.4 14.69,90.25 ; JUSB1.4 13.9,89.46 ; 78.65,149.97 JCRT1.6 77.89,150.73 ; JHDMI1.22 12.54,104.05 ; JHDMI1.22 10.8,103.21 ; JHDMI1.22 9.06,104.05 ; JHDMI1.22 10.8,104.89 ; JCRT1.16 70.32,147.53 ; JCRT1.16 69.38,145.65 ; JCRT1.16 68.45,147.53 ; JHDMI1.21 5.44,122.35 ; JHDMI1.21 1.96,122.35 ; JHDMI1.21 3.7,123.19 ; 161.85,151.28 JLAN1.9 162.84,149.26 ; JCRT1.5 89.72,150.73 ; v1(87.85,149.37) 87.81,149.4 JCRT1.10 ; JHDMI1.11 9.69,113.7 ; v1(83.12,149.64) 83.23,149.76 JCRT1.8 ; JHDMI1.5 9.69,110.7
  IN4 w0.203: JUSB1.7 13.11,93.75
  IN4 w0.254: v3(117.84,101.21) 117.79,101.16 117.79,100.11 117.41,99.73 116.29,99.73 116.04,99.99 116.04,100.58 116.83,101.36
  IN4 w0.508: 13,86.5 JUSB1.10 ; JUSB1.10 14.41,87.35 ; JUSB1.10 13,88.2 ; JCRT1.16 70.32,147.53 ; JCRT1.16 69.38,145.65 ; JCRT1.16 68.45,147.53 ; JHDMI1.23 10.8,123.19 ; JHDMI1.23 9.06,122.35 ; JHDMI1.23 12.54,122.35 ; JHDMI1.23 10.8,121.51 ; 13.11,90.25 JUSB1.4 ; JUSB1.4 13.9,91.04 ; JUSB1.4 13.9,89.46 ; JUSB1.4 14.69,90.25 ; JCRT1.5 89.72,150.73 ; 7.03,85.9 JUSB1.12 3.46,85.9 ; JHDMI1.2 11.24,109.2 ; JHDMI1.2 10.57,108.53 ; JHDMI1.2 9.9,109.2 ; 100.31,147.53 JCRT1.17 98.43,147.53 ; 104.98,147.47 JSER1.11 103.41,147.47 ; JUSB1.11 14.41,100.15 ; JUSB1.11 13,101 ; JUSB1.11 13,99.3 ; 78.65,149.97 JCRT1.6 77.89,150.73 ; 10.8,103.21 JHDMI1.22 ; JHDMI1.22 9.06,104.05 ; JHDMI1.22 12.54,104.05 ; JHDMI1.22 10.8,104.89 ; JHDMI1.21 5.44,122.35 ; JHDMI1.21 1.96,122.35 ; JHDMI1.21 3.7,123.19 ; JHDMI1.17 9.69,116.7 ; JUSB1.13 5.2,102.34 ; JUSB1.13 6.94,101.6 ; JUSB1.13 3.46,101.6 ; 182.94,149.26 JLAN1.10 183.93,151.28 ; 9.9,112.2 JHDMI1.8 11.24,112.2 ; 80.94,149.97 JCRT1.7 ; 119.75,107.31 119.75,105.78 v1(119.14,105.17) 118.57,104.6 118.57,101.93 v3(117.84,101.21) ; 83.23,149.97 JCRT1.8 ; JHDMI1.5 9.69,110.7 ; 3.7,103.21 JHDMI1.20 ; JHDMI1.20 1.96,104.05 ; JHDMI1.20 5.44,104.05 ; 116.83,101.36 v1(116.83,106.41) 116.83,106.8 116.47,107.15 ; 112.84,150.63 JSER1.5 ; JCRT1.10 87.81,149.4 v1(87.85,149.37) ; 147.91,140.45 JUSB2.4 ; 160.85,143.8 JUSB2.8 160.03,145.11 ; 144.53,145.11 JUSB2.7 143.72,143.8 ; 162.84,149.26 JLAN1.9 161.85,151.28 ; JHDMI1.11 9.69,113.7
  BOTTOM w0.076: 136.55,84.99 136.55,85.47 ; 136.23,85.76 136.23,86.17 ; 137.2,85.07 137.2,85.55 ; 137.53,85.6 137.53,86.08 ; 136.87,85.74 136.87,86.22
  BOTTOM w0.127: 132.72,82.41 133.47,82.41 UC1.AW8 ; UC1.D58 105.05,100.94 105.05,101.29 105.26,101.5 UC1.B58
  BOTTOM w0.152: PU5602.6 169.76,102.23 169.51,101.97 169.51,101.59 169.38,101.46 168.8,101.46 168.65,101.31 v1(168.21,101.31) ; UC1.BB60 103.99,79.43 v3(103.95,79.39)
  BOTTOM w0.178: v3(119.44,77.84) 119.44,78.08 118.7,78.82 118.7,80.39 UC1.BB34 ; UC1.BB64 101.64,80 101.64,79.88 101.64,79.54 v3(101.61,79.52) ; v3(116.4,79.42) 116.36,79.46 UC1.BB38 ; U18.11 49.11,129.4 v1(49.03,129.48) ; v3(113.73,79.46) 113.76,79.49 UC1.BB43 ; UC1.BB30 121.34,80 121.34,79.76 121.34,79.31 v3(121.47,79.18) ; v3(96.52,83.89) 96.65,83.89 97.11,83.89 UC1.AT71 ; v3(96.44,86.16) 96.53,86.24 97.26,86.24 UC1.AM71 ; v3(96.2,89.4) 96.7,88.9 97.01,88.9 97.11,88.9 UC1.AG71 ; UC1.H71 96.66,98.49 v3(96.07,97.91) ; v1(56.2,119.06) 56.45,119.32 56.45,120.12 U51.11 ; v3(106.63,79.49) 106.6,79.52 106.6,80.02 106.6,80.4 UC1.BB55 ; UC1.BB26 123.68,80.39 123.68,79.51 v3(123.75,79.45)
  BOTTOM w0.203: UC1.AH67 99.17,87.68 UC1.AK68 99.17,87.44 99.58,87.03 99.58,86.81 99.49,86.73 UC1.AM68 ; v3(105.47,87.79) UC1.AL58 ; v3(135.42,96.25) 135.42,96.1 UC1.N6 ; v3(98.61,78.6) 99.63,79.62 UC1.BB67 ; UC1.AK16 128.67,86.81 128.15,86.81 127.77,87.2 UC1.AK18 ; UC1.AW14 130.27,82.36 130.36,82.45 131,82.45 UC1.AW12 ; UC1.C1 138.04,101.94 v3(138.49,101.94) ; v3(110.04,99.05) 110.13,99.05 UC1.G48 ; UC1.AV1 138.28,82.57 v3(138.37,82.66) ; v3(99.4,103.34) 99.52,103.22 99.52,102.82 UC1.A67 ; v3(109.12,87.79) UC1.AL52 ; UC1.BA1 137.38,80.54 UC1.BA2 UC1.AY3 ; v3(107.29,87.79) UC1.AL55 ; JUSB1.7 13.11,93.75
  BOTTOM w0.254: Q19.4 188.96,44.38 v1(188.94,44.41) ; v1(71.87,124.37) 71.8,124.3 JXDP1.13 ; UC1.BA23 v3(125,81.85) ; 126.43,136.77 126.43,137.22 126.2,137.45 JGFX1.24 ; 127.7,136.41 JGFX1.18 ; JEDP1.45 35.53,102.6 ; JXDP1.14 71.8,118.29 v1(72.58,119.06) ; v3(106.36,99.02) 106.5,99.02 106.55,98.98 UC1.G55 ; UC1.AR16 128.46,84.17 128.33,84.17 v3(128.33,84.17) ; 52.53,100.7 JEDP1.11 52.53,102.65 ; 135.32,84.37 135.48,84.37 UC1.AT4 136.18,83.95 v3(136.37,84.14) 136.56,83.95 UC1.AT2 ; v1(48.35,100.57) 48.53,100.76 JEDP1.19 48.53,102.65 ; UC1.F22 124.73,98.94 v3(124.67,98.94) ; v3(103.37,90.92) 103.19,90.92 UC1.AD62 ; UC1.R13 131.07,95.24 131.12,95.24 ; v1(105.74,129.48) 106.37,129.48 106.47,129.58 JWWAN1.33 ; Q19.1 v1(190.83,41.05) ; v3(126.49,86.09) 126.4,86.09 UC1.AM21 125.76,86.73 v3(125.59,86.73) ; UC1.F13 130.94,99.67 v3(131.02,99.67) 131.21,99.67 UC1.E11 131.65,99.99 v3(131.95,99.68) ; v1(47.25,100.57) 47.03,100.8 JEDP1.22 47.03,102.65 ; UC1.J28 121.01,98.88 UC1.F28 121.72,99.08 v3(121.93,99.08) 122.13,99.08 UC1.F27 122.84,98.88 UC1.J25 ; v3(132.9,84.17) 133.03,84.17 UC1.AR8 ; v3(98.38,100.43) 98.45,100.37 UC1.D69 UC1.F68 ; U15.6 191.19,49.73 190.9,50.01 v1(190.47,50.01) 190.68,49.81 190.68,49.53 U15.5 ; v3(108.16,99.03) 108.33,99.03 UC1.G52 ; 54.03,102.65 JEDP1.8 54.03,100.7 ; UC1.AL38 v3(116.44,86.1) ; UC1.BA36 v3(117.54,81.85) ; UC1.J8 133.36,97.2 UC1.L8 134.12,96.43 v3(134.12,96.25) ; UC1.AK69 98.5,87.57 98.7,87.77 98.97,87.77 UC1.AK68 ; JGFX1.36 123.2,137.55 122.57,136.92 122.57,136.78 ; UC1.G58 104.86,98.69 104.55,98.99 v3(104.55,99.03) 104.21,98.69 UC1.G60 ; PU5601.6 173.69,78.34 174.05,78.7 v1(174.56,78.7) ; 53.03,100.7 JEDP1.10 53.03,102.65 ; JXDP1.8 70.3,118.34 v1(69.94,118.71) 69.24,118.71 68.8,118.26 JXDP1.2 ; UC1.A5 135.58,103.11 v3(135.82,103.36) ; UC1.AF1 137.51,89.27 136.88,89.27 UC1.AF2 136.59,89.26 v3(136.4,89.45) 136.2,89.26 UC1.AF4 135.44,88.81 135.44,88.66 UC1.AH6 134.69,88.75 v3(134.69,88.94) ; UC1.AP70 v3(98.88,85.06) ; v1(179.94,97.73) 179.94,97.85 179.57,98.23 JIOR1.19 ; UC1.J11 131.4,97.39 v3(131.04,97.75) 130.68,97.39 UC1.J13 ; v3(101.51,93.37) 101.52,93.38 101.52,93.58 UC1.U64 UC1.U63 ; UC1.C25 122.91,101.41 v3(122.74,101.25) ; UC1.B34 117.65,101.4 v3(117.84,101.21) 117.65,101.02 UC1.D34 ; UC1.L18 127.77,96.53 v3(128.1,96.86) ; v3(136.37,99.66) 136.37,99.65 ; 136.37,99.65 136.58,99.86 UC1.F2 UC1.F1 ; 136.37,99.65 136.1,99.65 UC1.F4 ; UC1.AW10 v3(132.28,81.85) UC1.BA10 ; JXDP1.7 70.3,124.35 v1(70.42,124.47) ; v3(132.42,101.26) 132.52,101.16 UC1.D10 ; v3(132.42,101.26) 132.52,101.36 UC1.B10 ; v3(132.42,101.26) 131.92,100.76 UC1.D11 ; UC1.F8 133.32,99.34 v3(132.9,98.92) 132.67,98.92 UC1.G10 ; UC1.AV69 UC1.AV70 UC1.AV71 ; 37.53,102.65 JEDP1.41 v1(37.53,100.52) ; UC1.AF10 132.24,89.67 132.24,89.85 v3(132.24,89.85) ; UC1.AK21 125.82,86.96 v3(125.59,86.73) ; v1(73.73,121.08) 73.3,121.51 JXDP1.19 ; U6206.7 169.51,63.36 v1(169.86,63.36) ; UC1.AM55 106.52,86.13 106.39,86.13 v3(106.38,86.13) ; UC1.AA68 99.48,91.68 v3(99.48,91.52) ; v3(129.24,84.11) 129.3,84.17 129.31,84.17 129.7,84.48 UC1.AR15 ; v1(199.45,34.81) 199.31,34.95 JODD1.16 ; v1(43.53,100.55) JEDP1.29 43.53,102.65 ; JEPC1.5 175.63,58.33 v1(175.5,58.46) ; UC1.E71 96.81,100.3 v3(96.72,100.39) ; 45.53,102.65 JEDP1.25 45.53,100.8 v1(45.35,100.62) 45.03,100.94 JEDP1.26 45.03,102.65 ; UC1.D58 105.26,100.47 v3(105.48,100.25) ; UC1.L4 136.19,97.21 v3(136.38,97.02) 136.58,97.21 UC1.L2 ; UC1.U10 132.59,93.66 133.01,93.25 v3(133.01,93.18) 133.01,92.76 UC1.W9 ; v1(129.09,140.91) 129.42,140.91 129.7,141.18 JGFX1.9 ; JGFX1.39 122.2,141.02 ; UC1.BA1 138.43,81.13 v3(138.43,81.39) ; UC1.BA14 v3(129.86,81.72) ; v3(122.74,101.25) 122.61,101.11 UC1.D26 ; v3(122.74,101.25) 122.96,101.03 123.01,101.03 UC1.D25 123.47,100.57 123.51,100.57 v3(123.73,100.34) ; UC1.BB6 UC1.BA6 134.7,81.84 134.68,81.86 134.67,81.85 v3(134.67,81.84) ; UC1.B22 UC1.D22 125.14,100.72 v3(125.59,100.27) 125.74,100.27 126.03,99.99 UC1.E21 ; JXDP1.20 73.3,118.41 73.58,118.69 v1(73.58,119.06) ; U6205.7 169.71,51.4 v1(169.86,51.55) ; JLED1.12 259.68,7.13 v1(259.65,7.1) ; UC1.T2 136.58,94.56 v3(136.36,94.33) 136.12,94.33 UC1.T4 135.72,94.73 UC1.R6 ; 131.12,95.24 v3(131.38,95.24) ; 131.12,95.24 131.12,95.26 130.59,95.8 UC1.N13 ; JXDP1.25 v1(74.8,124.4) ; v3(130.11,99.68) 130,99.68 UC1.E15 129.7,100.38 UC1.D14 UC1.B14 ; v3(124.67,98.94) 124.92,98.69 UC1.G22 ; v3(124.67,98.94) 124.46,99.15 124.4,99.15 UC1.F23 124.12,99.43 123.99,99.43 v3(123.76,99.66) ; v1(49.87,100.55) 50.03,100.71 JEDP1.16 50.03,102.65 ; UC1.BA45 v3(112.58,81.81) ; JGFX1.30 124.7,136.69 125.03,136.36 ; 111.43,100.32 111.43,100.01 UC1.E46 ; v1(104.13,126.48) 104.13,126.78 105.21,127.87 106.25,127.87 106.46,128.08 JWWAN1.27 ; UC1.AY71 96.97,81.2 96.4,80.63 v3(96.11,80.63) ; UC1.B30 120.13,101.41 v3(120.33,101.21) 120.13,101.01 UC1.D30 ; UC1.D6 134.81,100.88 v3(134.81,101.26) 135.43,101.26 UC1.C5 ; v3(125.59,86.73) 125.58,86.73 125.13,87.18 UC1.AK22 ; UC1.E6 134.1,99.99 v3(133.79,99.68) ; JWLAN1.63 24.74,121.52 24.49,121.27 24.49,121.19 v1(24.04,120.74) ; 53.53,102.65 JEDP1.9 53.53,100.7 ; JWWAN1.5 106.45,122.58 105.98,123.05 v1(105.98,123.69) ; UC1.BA41 v3(115.06,81.85) ; v3(130.97,87.87) 130.97,87.92 UC1.AH13 129.99,88.33 UC1.AJ15 ; U15.8 191.91,49.01 192.14,49.23 192.14,49.8 v1(191.95,49.99) 191.71,49.75 U15.7 ; UC1.AJ18 127.71,88.05 127.41,87.75 127.41,87.5 127.69,87.21 UC1.AK18 ; UC1.G5 135.06,98.69 v3(134.75,99) 134.43,98.69 UC1.G6 ; v3(119.18,99.1) 119.24,99.1 119.48,99.34 UC1.F32 ; UC1.H15 129.07,97.41 UC1.K16 129.22,97.12 129.22,96.59 UC1.L16 129.01,96.38 128.47,96.38 UC1.L17 128.42,96.54 v3(128.1,96.86) ; v3(101.52,95.19) 101.12,95.59 UC1.N65 ; v1(158.04,86.18) 158.01,86.15 JDOCK1.36 ; UC1.B62 102.77,101.72 v3(102.77,101.25) 102.78,101.24 UC1.D62 ; JWLAN1.57 24.33,123.02 v1(24.01,122.7) ; v3(101.41,91.55) 101.12,91.85 UC1.AA65 ; UC1.BA62 v3(102.81,81.85) ; v1(200.7,34.81) 199.84,33.95 JODD1.14 ; JGFX1.42 121.7,137.33 122.25,136.78 122.57,136.78 ; v1(264.09,7.1) 264.48,7.1 264.68,7.3 JLED1.2 ; UC1.AM13 130.28,86.12 v3(130.15,86.12) ; JXDP1.31 76.3,124.33 v1(76.26,124.37) ; v1(174.38,49.37) 174,49.75 JSH1.9 172.3,49.75 172.07,49.98 172.07,51.02 172.3,51.25 JSH1.6 173.92,51.25 v1(174.28,50.89) ; v1(77.2,124.37) 77.44,124.37 77.8,124 JXDP1.37 ; UC1.AD8 133.39,90.89 v3(133.39,91) 133.39,91.1 UC1.AB8 ; JODD1.5 199.25,29.45 ; JGFX1.41 121.7,141.26 121.91,141.06 ; UC1.H18 127.87,97.37 UC1.K18 127.77,97.19 v3(128.1,96.86) ; UC1.F33 118.27,99.79 v3(118.27,100.24) ; UC1.G63 101.75,98.28 UC1.K64 ; 71.69,137.7 v1(71.69,132.14) ; UC1.AA2 136.58,91.91 v3(136.35,91.68) 136.12,91.91 UC1.AA4 135.2,92.6 UC1.W6 ; UC1.J42 113.7,98.23 UC1.G43 113.35,98.69 v3(113.7,99.04) 114,99.34 UC1.F42 ; v3(124.65,96.84) 124.88,96.84 125.13,97.09 UC1.K22 ; 74.31,145.74 C13.2 73.71,145.01 ; v1(122.57,136.77) 122.57,136.78 ; UC1.L11 131.86,96.59 v3(132.22,96.24) 132.51,95.94 UC1.N10 ; v3(99.49,95.19) 99.49,95.32 UC1.N68 ; UC1.BA53 v3(107.77,81.85) ; JGFX1.37 122.7,141.05 ; UC1.B39 115.44,101.47 115.44,100.99 UC1.D39 115.17,100.7 v3(115.56,100.32) ; U32.5 200.12,42.01 200.28,41.86 ; UC1.E65 100.91,100.34 100.69,100.34 UC1.D66 100.29,100.73 v3(100.29,101.24) 100.29,101.72 UC1.B66 ; 40.53,102.65 JEDP1.35 40.53,100.91 v1(40.07,100.45) ; UC1.BA32 v3(120.01,81.74) ; UC1.E18 127.66,99.99 v3(127.42,100.23) 127.56,100.38 UC1.D18 UC1.B18 ; v3(99.76,98.39) 99.82,98.39 UC1.G66 ; JEDP1.48 34.03,102.68 ; UC1.J38 115.52,97.32 115.63,97.22 v3(115.63,97.19)
  BOTTOM w0.279: JDOCK1.24 157.74,92.15 157.98,91.91 157.98,90.93 157.7,90.65 JDOCK1.27 ; v1(80.96,118.91) 80.96,118.68 80.8,118.52 JXDP1.50 ; v1(74.18,119.04) 74.8,118.42 JXDP1.26 ; JWLAN1.7 v1(26.71,135.52) ; U92.11 183.6,134.5 v1(183.83,134.74) ; v1(263.2,9.26) 263.18,9.24 JLED1.5 ; U25.23 189.06,142.82 188.87,142.63 188.82,142.63 188.8,142.62 188.31,142.62 188.3,142.63 v1(188.07,142.63) ; v1(156.25,87.85) 156.45,87.65 JDOCK1.33 ; v1(192.59,143.12) 192.66,143.18 U25.16 ; JXDP1.59 84.01,122.87 v1(84.57,123.43) ; U25.32 v1(186.88,147.28) ; v1(193.36,147.17) 193.25,147.28 U25.9 192.06,147.28 U25.33 ; v1(105.6,121.78) 106.14,121.78 106.44,122.08 JWWAN1.3 ; R9638.1 v1(184.72,143.75)
  BOTTOM w0.292: 199.45,31.66 199.16,31.95 JODD1.10 ; JODD1.2 199.22,27.95 ; 199.43,27.45 JODD1.1 ; 199.12,30.95 JODD1.8
  BOTTOM w0.305: JIOR1.44 v1(178.53,85.73) ; 106.71,37.31 106.51,37.51 JDIMM1.102 106.51,40.09 ; 141.52,23.96 JDIMM2.234 v1(141.52,26.51) ; JDIMM1.48 93.01,37.27 ; v1(144.77,32.13) JDIMM2.247 144.77,34.66 ; 125.76,48.07 JDIMM1.171 125.76,45.43 v1(125.66,45.33) ; 138.76,45.64 JDIMM1.223 138.76,47.72 v1(138.49,47.99) ; v1(137.98,40.37) 138.21,40.37 138.51,40.07 JDIMM1.222 138.51,37.12 ; 134.26,48.25 JDIMM1.205 134.26,45.42 v1(134.17,45.33) ; 89.76,45.44 JDIMM1.35 89.76,48.09 ; v1(144.84,45.43) 144.84,45.45 144.76,45.53 JDIMM1.247 144.76,47.97 ; UC1.AT42 113.87,84.14 v3(113.7,84.14) ; 106.75,48.06 106.76,48.05 JDIMM1.103 v1(106.76,45.43) ; JSTRG1.18 v1(156.73,56.35) ; 102.5,23.84 102.52,23.85 JDIMM2.86 v1(102.52,26.53) ; v3(97.09,79.44) 97.68,80.03 UC1.BB70 ; 93.02,23.87 JDIMM2.48 v1(93.02,26.53) ; v1(85.52,26.51) JDIMM2.18 85.52,23.88 ; v1(105.73,26.53) 105.52,26.32 JDIMM2.98 105.52,23.87 ; JGFX1.72 114.2,139.21 v1(113.96,139.46) 113.7,139.2 JGFX1.74 ; v1(139.52,26.78) JDIMM2.226 139.52,23.82 ; JSH1.16 174.85,46.25 v1(175.33,46.74) ; 104.27,34.76 JDIMM2.93 104.27,32.13 ; 130.27,32.08 JDIMM2.189 130.27,34.88 ; 133.27,34.93 JDIMM2.201 133.27,32.24 ; v1(156.73,60.34) 156.72,60.35 JSTRG1.10 ; v1(84.26,27.29) 84.64,26.91 84.64,26.3 84.52,26.17 JDIMM2.14 84.52,23.87 84.52,23.86 ; JSH1.11 170.87,48.75 v1(170.62,48.5) ; US2.1 140.83,136.15 140.52,135.84 v1(140.52,135.5) ; 104.26,48.04 JDIMM1.93 104.26,45.28 ; v1(134.48,32.12) 134.27,32.33 JDIMM2.205 134.27,34.88 ; 100.52,23.87 JDIMM2.78 v1(100.52,26.53) ; 130.26,45.4 JDIMM1.189 130.26,48.19 ; 91.02,23.89 JDIMM2.40 v1(91.02,26.51) ; v1(96.1,34.68) 95.57,34.68 95.26,34.38 JDIMM2.57 95.26,31.79 ; 81.27,34.65 JDIMM2.1 81.27,32.17 80.96,31.87 v1(80.98,31.87) ; 145.77,32.12 JDIMM2.251 145.77,34.37 145.48,34.66 145.48,35.29 ; v1(136.52,26.48) JDIMM2.214 136.52,23.97 ; JGFX1.10 129.7,139.35 v1(129.91,139.56) 129.35,139.56 129.2,139.41 JGFX1.12 ; 127.01,23.89 JDIMM2.176 v1(127.01,26.66) ; 131.26,48.19 JDIMM1.193 131.26,45.76 131.39,45.63 ; JGFX1.19 127.2,141.16 v1(127.66,140.7) 127.7,140.75 ; 98.02,23.98 JDIMM2.68 v1(98.02,26.48) ; 94.02,26.19 JDIMM2.52 94.02,23.89 ; JGFX1.45 120.7,142.87 v1(120.41,143.17) 120.2,142.96 JGFX1.47 ; 96.61,44.75 v1(96.76,44.75) 96.96,44.75 97.26,45.06 JDIMM1.65 97.26,48.04 ; 137.51,39.5 JDIMM1.218 137.51,36.7 ; 88.51,39.96 JDIMM1.30 88.51,37.41 ; v1(76.69,118.91) 76.3,118.52 JXDP1.32 ; UC1.AR55 107.2,84.14 v3(107.29,84.14) ; JDIMM1.2 81.51,37.41 v1(82.14,36.78) ; JSTRG1.1 156.62,64.85 v1(156.76,64.99) ; 135.24,31.38 135.27,31.41 JDIMM2.209 135.27,35.06 ; v1(141.76,45.44) JDIMM1.235 141.76,47.96 v1(141.79,47.99) ; v1(101.27,32.12) JDIMM2.81 101.27,34.67 ; v1(87.52,26.45) JDIMM2.26 87.52,23.89 ; 137.52,23.8 JDIMM2.218 137.52,26.24 137.51,26.25 137.51,26.74 137.93,27.17 v1(138.02,27.17) 138.1,27.17 138.52,26.74 138.52,25.19 JDIMM2.222 ; 102.26,34.84 102.27,34.83 JDIMM2.85 102.27,32.15 102.42,31.99 v1(102.4,31.99) ; v1(156.27,98.03) 156.39,98.15 JDOCK1.12 ; JSTRG1.36 v1(157.52,47.35) ; v1(88.71,32.14) 88.72,32.14 88.77,32.19 JDIMM2.31 88.77,34.73 ; v1(156.69,48.85) JSTRG1.33 v1(155.17,48.85) ; v1(129.01,26.48) JDIMM2.184 129.01,23.87 ; v1(90.04,39.74) 90.01,39.71 JDIMM1.36 90.01,37.21 v1(90.03,37.2) ; 84.77,34.82 JDIMM2.15 84.77,32.11 84.68,32.03 v1(84.68,31.99) ; 90.02,23.93 JDIMM2.36 v1(90.02,26.49) ; 140.52,23.82 JDIMM2.230 v1(140.52,26.52) ; 98.26,34.6 JDIMM2.69 98.26,31.96 98.17,31.87 v1(98.15,31.87) ; 105.51,37.15 JDIMM1.98 105.51,39.82 104.96,40.37 v1(104.86,40.37) ; v1(92.83,45.33) 92.76,45.4 JDIMM1.47 92.76,48.24 ; JWLAN1.39 24.64,127.52 24.53,127.62 24.52,127.62 24.39,127.75 v1(24.19,127.75) ; 87.77,34.83 JDIMM2.27 87.77,32.28 ; JGFX1.25 125.7,140.85 v1(125.79,140.75) ; v1(156.7,54.52) 156.37,54.85 JSTRG1.21 v1(155.17,54.85) ; JWLAN1.18 v1(30.77,132.77) ; 103.27,32.04 JDIMM2.89 103.27,34.8 ; JDOCK1.44 157.82,82.15 157.9,82.07 157.9,81.68 157.87,81.65 ; 137.26,48.13 JDIMM1.217 v1(137.26,45.33) ; v3(96.45,79.87) 96.54,79.87 UC1.BA71 ; 82,124.63 81.7,124.32 81.09,124.32 80.8,124.03 JXDP1.49 ; 127.7,140.75 JGFX1.17 ; 127.7,140.75 128.2,141.25 JGFX1.15 ; 92.02,23.87 JDIMM2.44 v1(92.02,26.53) ; v1(158.45,82.41) 158.26,82.41 158.02,82.65 JDOCK1.43 ; 90.76,45.27 JDIMM1.39 90.76,47.89 v1(90.99,48.12) ; 126.01,24.02 JDIMM2.172 v1(126.01,26.53) ; UC1.A70 97.39,103 96.9,103 v3(96.66,102.76) 96.66,102.55 96.96,102.25 UC1.B71 ; 95.01,39.93 JDIMM1.56 95.01,37.05 ; v1(156.69,53.35) JSTRG1.24 v1(155.17,53.35) ; 143.76,47.69 JDIMM1.243 143.76,45.34 143.76,45.34 ; v1(141.51,39.84) JDIMM1.234 v1(141.51,36.69) ; 128.26,48.17 JDIMM1.181 128.26,45.59 ; JEPC1.2 174.13,58.18 v1(174.33,58.38) ; UC1.U66 100.47,93.72 v3(100.14,93.4) 99.82,93.72 UC1.U67 ; v1(178.53,87.01) 178.32,87.22 177.69,87.22 JIOR1.41 ; 89.77,34.69 JDIMM2.35 89.77,32 ; 96.02,23.8 JDIMM2.60 v1(96.02,26.47) ; v1(127.01,39.82) JDIMM1.176 127.01,37.17 ; JWLAN1.51 24.38,124.52 v1(24.32,124.58) ; v1(84.39,36.95) 84.51,37.07 JDIMM1.14 84.51,39.4 84.63,39.52 ; v1(145.15,39.74) 145.01,39.61 JDIMM1.248 145.01,37.52 145.11,37.43 ; v1(158.46,81.59) 158.39,81.65 157.87,81.65 ; 103.52,23.92 JDIMM2.90 v1(103.52,26.53) ; 128.01,36.76 JDIMM1.180 128.01,39.69 ; v1(86.69,34.91) 86.07,34.91 85.77,34.61 JDIMM2.19 85.77,32.11 ; v1(141.77,32.02) JDIMM2.235 141.77,34.58 ; v1(94.02,37.2) 94.01,37.2 JDIMM1.52 v1(94.01,39.74) ; v1(156.69,50.35) JSTRG1.30 v1(155.17,50.35) ; v1(98.23,45.44) 98.23,45.45 98.26,45.48 JDIMM1.69 v1(98.26,48.22) ; 130.01,23.91 JDIMM2.188 v1(130.01,26.56) ; 145.02,23.79 JDIMM2.248 v1(145.02,26.42) ; v1(100.43,39.86) 100.43,39.82 100.51,39.74 JDIMM1.78 100.51,37 ; 144.02,23.95 JDIMM2.244 v1(144.02,26.43) ; v1(108.39,133.97) 108.29,134.08 JWWAN1.51 ; 143.77,34.71 JDIMM2.243 143.77,32.1 143.15,31.48 v1(143.06,31.48) ; 126.01,37.39 JDIMM1.172 126.01,39.59 ; UC1.F37 117.05,99.34 v3(117.33,99.06) 117.61,99.34 UC1.F35 ; JDIMM1.64 v1(97.01,39.74) ; UC1.AR48 110.78,84.21 v3(110.95,84.21) 111.12,84.21 UC1.AR46 ; v1(140.62,39.74) 140.51,39.63 JDIMM1.230 140.51,37.16 ; 156.26,93.65 155.98,93.65 v1(155.69,93.94) ; 156.26,93.65 JDOCK1.21 158.27,93.65 v4(158.3,93.69) ; 156.26,93.65 156.26,92.37 156.49,92.15 JDOCK1.24 ; 83.52,23.88 JDIMM2.10 v1(83.52,27.17) ; 124.77,34.74 JDIMM2.167 124.77,32.21 124.71,32.16 v1(124.71,32.13) ; v1(94.01,47.99) 93.76,47.75 JDIMM1.51 93.76,45.16 93.76,45.16 ; v1(116.17,143.17) 116.2,143.13 JGFX1.63 ; 140.76,47.85 JDIMM1.231 140.76,45.28 ; v1(87.51,39.74) JDIMM1.26 ; 132.27,34.91 JDIMM2.197 132.27,32.28 ; 130.01,37.01 JDIMM1.188 130.01,39.54 ; 132,37.12 132.01,37.13 JDIMM1.196 v1(132.01,39.78) ; v1(114.4,143.17) 114.2,142.98 JGFX1.71 ; 99.26,48.13 JDIMM1.73 99.26,45.3 ; 133.27,48.17 133.26,48.17 JDIMM1.201 133.26,45.55 ; v1(86.52,26.5) JDIMM2.22 86.52,23.9 ; 129.27,34.67 JDIMM2.185 129.27,32.24 v1(129.38,32.12) ; 135.51,37.01 JDIMM1.210 135.51,39.47 135.36,39.62 ; v1(133.92,40.5) 134.17,40.5 134.51,40.16 JDIMM1.206 134.51,36.92 v1(134.48,36.89) ; v1(99.26,32.12) 99.27,32.12 JDIMM2.73 99.27,34.61 ; v1(133.52,26.84) JDIMM2.202 133.52,24.04 ; 132.02,23.86 JDIMM2.196 v1(132.02,26.53) ; JDIMM1.94 104.51,37.2 ; v1(145.76,45.36) JDIMM1.251 145.76,48.09 ; 125.01,37.08 JDIMM1.168 125.01,39.62 ; v1(88.52,26.47) JDIMM2.30 88.52,23.95 ; 137.27,34.76 JDIMM2.217 137.27,32.2 v1(137.41,32.06) ; v1(124.84,45.3) 124.76,45.38 JDIMM1.167 124.76,48.07 ; JGFX1.66 v1(115.7,139.48) ; JGFX1.27 125.2,143.05 125.08,143.17 v1(124.67,143.17) 124.7,143.14 JGFX1.29 ; v1(103.57,27.17) 103.82,27.17 104.52,26.47 JDIMM2.94 104.52,23.92 ; v1(135.95,44.69) 135.57,44.69 135.26,45 JDIMM1.209 135.26,48.21 ; JGFX1.48 120.2,139.56 v1(120.15,139.61) 120.4,139.61 120.7,139.31 JGFX1.46 ; v1(96.14,32.12) 96.26,32.25 JDIMM2.61 ; JDOCK1.39 158.09,84.65 v1(158.4,84.34) 158.25,84.34 158.06,84.15 JDOCK1.40 ; v1(107.51,39.87) JDIMM1.106 107.51,37.06 ; 83.26,48.1 JDIMM1.9 83.26,45.17 82.83,44.74 v1(82.67,44.74) 82.44,44.74 82.1,45.07 82.1,45.58 82.26,45.74 JDIMM1.5 82.26,48.03 ; v1(100.37,32.12) 100.27,32.23 JDIMM2.77 100.27,34.7 ; 95.02,26.23 JDIMM2.56 95.02,23.95 ; v1(158.42,83.04) 158.3,83.15 157.82,83.15 ; v3(110.04,84.14) 109.94,84.14 UC1.AR50 ; 78.07,114.24 77.68,114.62 77.68,115.54 77.68,115.54 77.68,115.86 77.8,115.98 JXDP1.38 ; 125.77,34.7 JDIMM2.171 125.77,32.18 v1(125.82,32.12) ; 128.4,32.31 128.27,32.44 JDIMM2.181 128.27,34.81 ; v1(92.01,39.74) JDIMM1.44 92.01,36.97 ; v1(126.78,45.33) 126.76,45.34 JDIMM1.175 126.76,48.07 ; 105.76,45.25 JDIMM1.99 105.76,48.07 ; v1(134.52,26.49) JDIMM2.206 134.52,23.9 134.5,23.89 ; 129.26,45.44 JDIMM1.185 129.26,48.2 ; 86.51,39.74 JDIMM1.22 v1(86.51,37.2) ; v1(139.65,35.09) 139.77,34.98 JDIMM2.227 139.77,32.16 139.76,32.15 ; v3(119.18,97.19) UC1.J32 ; v1(101.52,26.55) JDIMM2.82 101.52,23.9 ; v1(129.01,39.87) JDIMM1.184 129.01,37.08 129.01,37.07 ; v1(140.77,31.36) JDIMM2.231 140.77,34.83 ; 157.87,81.65 JDOCK1.45 ; 144.01,36.93 JDIMM1.244 v1(144.01,39.74) ; JWLAN1.33 25.03,129.02 24.45,129.6 v1(24.24,129.6) ; 103.51,37.17 JDIMM1.90 103.51,39.75 ; v1(156.69,51.85) JSTRG1.27 v1(155.17,51.85) ; 146.01,39.76 JDIMM1.252 146.01,37.1 ; UC1.AR45 111.99,84.16 v3(111.88,84.16) ; JGFX1.3 131.2,142.81 130.77,143.24 v1(130.74,143.24) ; v1(101.28,48.25) 101.26,48.23 JDIMM1.81 101.26,45.47 v1(101.38,45.35) ; JIOR1.28 178.42,93.73 v1(178.53,93.84) ; 99.02,23.84 JDIMM2.72 v1(99.02,26.42) ; v1(158,76.15) JDOCK1.56 ; JIOR1.50 v1(176.59,82.73) ; v1(98.08,35.34) 97.26,34.53 JDIMM2.65 97.26,32.22 ; 86.94,45.53 86.76,45.7 JDIMM1.23 86.76,48.21 ; JDIMM1.40 91.01,36.85 ; 157.82,83.15 JDOCK1.42 ; 157.82,83.15 157.82,83.54 157.72,83.65 JDOCK1.41 ; 84.76,48.11 JDIMM1.15 84.76,45.45 84.43,45.12 v1(84.2,45.12) ; 107.77,34.66 JDIMM2.107 107.77,32.46 107.3,31.99 v1(106.77,31.99) JDIMM2.103 106.77,34.62 ; JWWAN1.57 106.15,135.58 v1(105.98,135.75) ; v1(107.76,47.92) JDIMM1.107 107.76,45.51 ; v1(100.24,45.33) 100.26,45.33 100.26,45.71 100.26,45.71 JDIMM1.77 100.26,48.12 ; JWWAN1.71 108.09,139.08 108.39,139.38 v1(108.39,139.58) JWWAN1.73 ; 82.27,34.72 JDIMM2.5 82.27,31.9 v1(82.23,31.87) ; v1(104.58,132.91) 104.58,132.75 104.76,132.58 JWWAN1.45 ; 102.51,39.92 JDIMM1.86 102.51,36.98 ; 135.52,24.05 JDIMM2.210 135.52,26.61 ; v1(92.77,34.79) 92.77,34.78 JDIMM2.47 v1(92.77,32.13) ; 142.52,23.98 JDIMM2.238 v1(142.52,26.79) ; v1(96.01,39.74) 96.01,39.73 JDIMM1.60 96.01,36.83 ; JIOR1.47 178.39,84.23 v1(178.6,84.44) ; JDOCK1.18 v1(158.91,95.15) ; 131.27,34.83 JDIMM2.193 v1(131.27,31.99) ; 93.77,34.78 JDIMM2.51 v1(93.77,32.01) ; 142.76,48.01 JDIMM1.239 142.76,45.33 ; UC1.G45 112.56,98.92 113.01,98.92 UC1.G43 ; 136.51,37.08 JDIMM1.214 136.51,39.79 ; v1(126.93,32.12) 126.77,32.29 JDIMM2.175 126.77,34.75 ; v1(86.77,31.99) JDIMM2.23 86.77,34.45 ; 125.01,23.83 JDIMM2.168 v1(125.01,26.9) ; JWLAN1.45 24.62,126.02 v1(24.32,125.72) ; UC1.AR43 113.51,84.77 v3(113.7,84.77) 113.84,84.77 114.11,84.5 UC1.AR42 ; v1(101.53,39.74) 101.51,39.72 JDIMM1.82 101.51,36.97 v1(101.53,36.95) ; JGFX1.79 112.2,140.66 112.53,140.32 v1(112.53,140.13) ; JGFX1.13 128.7,141.1 128.89,140.91 v1(129.09,140.91) ; JGFX1.44 121.2,139.64 v1(121.37,139.82) ; v1(178.43,58.55) 178.63,58.35 JEPC1.11 178.63,56.71 178.32,56.4 177.15,56.4 177.02,56.27 ; v1(107.52,26.53) JDIMM2.106 107.52,24.03 ; 139.76,48.04 JDIMM1.227 139.76,45.48 v1(139.55,45.26) ; v1(111.96,139.56) 112.2,139.32 JGFX1.80 ; JIOR1.34 178.74,90.73 179.13,91.12 v1(179.13,91.12) ; 142.51,37.35 JDIMM1.238 v1(142.51,39.74) ; 83.51,37.12 JDIMM1.10 83.51,39.79 ; v3(105.48,100.25) 105.66,100.25 UC1.E56 ; v1(131.02,26.51) JDIMM2.192 131.02,23.98 ; 133.51,37.09 JDIMM1.202 133.51,39.43 133.37,39.57 ; v1(118.7,139.61) JGFX1.54 ; 91.77,48.14 91.76,48.14 JDIMM1.43 91.76,45.69 91.89,45.57 ; 105.77,34.82 JDIMM2.99 105.77,32.22 105.46,31.92 v1(105.09,31.92) ; v1(138.77,31.95) JDIMM2.223 138.77,34.55 ; 128.01,24.03 JDIMM2.180 128.01,27.23 127.32,27.93 v1(127.01,27.93) ; 146.02,23.82 JDIMM2.252 146.02,26.73 145.24,27.51 ; 102.26,48.22 JDIMM1.85 102.26,45.63 102.57,45.33 v1(103.11,45.33) 103.26,45.48 JDIMM1.89 103.26,47.84 v1(103.11,47.99) ; JGFX1.53 118.7,142.93 v1(118.93,143.17) 119.2,142.9 JGFX1.51 ; 136.27,34.58 JDIMM2.213 136.27,32 v1(136.27,31.99) ; JDIMM1.68 98.01,36.95 ; JDOCK1.30 158.14,89.15 v1(158.38,88.91) ; UC1.U69 98.52,93.75 v3(98.18,93.42) 97.87,93.74 UC1.U70 ; 96.26,45.64 JDIMM1.61 96.26,48.15 ; 91.77,34.93 JDIMM2.43 91.77,31.97 ; JWWAN1.39 106.36,131.08 106.16,131.28 v1(106.01,131.28) ; v1(87.75,45.33) 87.76,45.34 JDIMM1.27 87.76,48.19 ; 106.52,23.86 JDIMM2.102 106.52,26.63 v1(105.98,27.17) ; v1(156.73,62.83) 156.71,62.85 JSTRG1.5 ; v3(109.1,84.8) 108.97,84.8 UC1.AR52 108.46,84.29 107.96,84.29 UC1.AR53 ; v1(81.52,26.53) JDIMM2.2 81.52,23.91 ; JRCAM1.3 v1(206.11,150.79) ; 82.52,23.8 JDIMM2.6 v1(82.52,26.53) ; 136.44,45.56 136.26,45.73 JDIMM1.213 v1(136.26,48.06) ; 139.51,37.27 JDIMM1.226 v1(139.51,39.74) ; JSTRG1.2 156.68,64.35 v1(156.76,64.28) ; 88.76,48.1 JDIMM1.31 88.76,45.64 ; JEPC1.5 175.63,55.7 JSH1.17 ; 82.51,37.28 JDIMM1.6 v1(82.51,39.74) ; 132.26,45.54 JDIMM1.197 132.26,48.11 ; 83.27,34.72 JDIMM2.9 83.27,32.16 v1(83.45,31.97) ; v1(94.46,44.06) 94.82,44.06 95.26,44.5 JDIMM1.57 95.26,48.07 ; JDIMM2.239 142.77,34.56 ; 97.02,23.99 JDIMM2.64 v1(97.02,26.61) ; v1(90.86,32.12) 90.77,32.21 JDIMM2.39 90.77,34.55 ; 99.01,39.88 JDIMM1.72 99.01,37.02 ; v1(85.51,39.74) 85.51,39.74 JDIMM1.18 ; 131.01,37.1 JDIMM1.192 131.01,40.07 130.71,40.37 v1(130.49,40.37) ; 85.76,48.22 JDIMM1.19 85.76,45.12 86.2,44.69 v1(86.36,44.69) ; JDOCK1.15 v1(158.66,96.65) ; JGFX1.60 v1(117.2,139.43) ; v3(117.35,97.19) UC1.J35
  BOTTOM w0.356: v1(54.49,88.65) U6223.1 ; v1(156.2,129.5) 155.95,129.26 Q3605.1
  BOTTOM w0.381: v1(135.75,113.55) 135.75,113.71 136.14,114.1 UC8.3 ; v1(174.56,79.34) 174.64,79.26 PR5602.1 ; v1(176.77,78.4) PC5601.1 ; v1(91.98,105.91) 91.88,106.01 RC399.1 ; v1(176.46,103.11) 176.19,103.11 PC5620.2 PR5623.2 ; RC48.2 132.73,75.47 132.37,75.83 132.08,75.83 v3(131.02,76.89) ; CC270.1 90.23,102.22 v1(89.98,102.48) ; PC5615.2 v1(174.23,104.13) ; CC275.1 154.19,94.6 155.28,94.6 155.69,94.2 v1(155.69,93.94) ; v1(200.28,41.21) 200.12,41.06 C413.2 ; R9446.1 89.07,109.74 89.07,109.26 89.09,109.24 89.09,109.23 v1(89.22,109.11) 89.5,109.11 89.88,109.5 C9541.1 ; RC359.1 100.62,109.26 99.93,108.57 v1(99.93,108.24) ; C3085.2 89.65,127.02 90.04,127.41 v8(90.18,127.41) ; CC91.2 144.7,76.17 v1(145.15,76.17) ; v3(128.08,77.2) 128.2,77.08 CC280.1 CC277.1 ; v1(72.63,128.26) 72.38,128 RC390.1 ; v1(181.46,126.51) 181.56,126.4 C3062.2 ; C9543.2 93.2,109.24 v1(93.33,109.11) ; v1(174.05,76.95) 174.38,76.62 PR5609.2 PR5608.2 ; PC5611.1 168.03,101.13 v1(168.21,101.31) ; v1(144.59,89.52) 144.26,89.52 RC339.2 ; v3(140.54,75.43) 140.09,75.87 C9884.2 139.42,75.87 139.29,76 C9958.2 ; C9539.1 94.96,109.57 94.47,109.08 94.07,109.08 v1(94.02,109.13) 94.02,109.71 C9542.2 ; PR5612.2 PC5610.2 v1(166.83,76.44) ; C9528.2 v1(15.3,116.55) ; CC271.1 v1(92.02,103.11)
  BOTTOM w0.406: v1(18.48,119.06) 17.23,119.06 17.05,119.24 C87.2 ; RC393.1 92.59,101.34 RC398.1 RC395.1 92.08,100.52 v1(92.01,100.45) ; JSTRG1.41 158.43,64.59 v1(157.76,63.93) ; C28.2 91.19,130.01 v8(90.83,130.01) ; v1(209.87,150.84) 209.71,150.68 JRCAM1.9 ; JRCAM1.10 210.31,150.42 210.5,150.61 v1(210.5,150.87) ; C9527.2 16.42,117.08 v1(15.94,116.6) ; 52.89,96.87 52.74,96.71 R95.1 C9986.2 ; RC396.1 92.11,105.78 v1(91.98,105.91) ; PC5104.2 v1(27.76,99.15)
  BOTTOM w0.432: PR7401.1 192.39,23.38 v1(192.44,23.33) ; R2730.1 R2732.1 188.89,134.43 v1(188.53,134.43) ; v1(195.16,141.34) 195.16,141.14 194.75,140.73 194.19,140.73 194.07,140.86 C9924.2 ; CC276.1 139.56,111.8 RC227.1 140.04,112.38 140.65,112.99 v1(140.65,113.53) ; CC89.2 183.98,126 v1(184.14,126.15) ; v1(191.04,134.6) 191.07,134.57 R2729.1 ; 131.68,124.73 130.69,125.72 C9963.2 C9964.2 131.94,126.89 v1(132.29,127.24) ; v1(187.2,124.96) 186.88,124.96 CC90.2
  BOTTOM w0.457: RC383.2 76.39,132.43 76.08,132.73 75.65,132.73 v1(75.3,133.08) ; v1(92.02,103.98) 92.04,104 RC385.1 ; R9454.1 91.76,109.55 91.76,109.19 v1(91.84,109.11) ; RC360.1 99.3,112.97 v1(98.88,113.39) ; v1(90.36,109.11) 90.36,109.24 90.71,109.59 C9544.2 ; v1(104.93,113.63) 104.89,113.59 RC369.1 ; RC305.2 RC306.2 144.38,110.86 144.65,111.13 v1(144.65,111.32) ; RC387.1 92.37,99.71 v1(91.88,99.23) 92.21,98.9 RC449.2 ; C183.2 147.06,133.66 U21.51 ; R4104.1 55,94.79 55.36,94.44 v1(55.36,94.32) ; C9540.1 92.37,109.38 v1(92.64,109.11) ; 79.42,142.52 C15.2 78.85,141.92 ; v1(141.84,111.37) 141.84,111.21 142.37,110.69 C9628.2
  BOTTOM w0.508: JHDMI1.23 10.8,123.19 ; JHDMI1.23 10.8,121.51 ; JHDMI1.23 9.06,122.35 ; JHDMI1.23 12.54,122.35 ; v1(160.13,104.58) 160.13,104.6 160.45,104.92 JDOCK1.57 ; 1.96,104.05 JHDMI1.20 ; JHDMI1.20 5.44,104.05 ; JHDMI1.20 3.7,103.21 ; v1(187.01,137.78) 186.47,137.78 186.24,137.55 C3059.2 C3060.2 ; JUSB2.6 161.04,148.85 ; JUSB2.6 160.06,150.4 ; JUSB2.6 160.06,147.3 ; RC338.2 140.02,88.63 v3(139.94,88.71) ; U2.4 146.75,108.9 v1(146.67,108.83) ; CC6.2 120.66,109.97 v1(120.28,109.59) ; JCSW2.5 178.92,124.25 179.49,123.69 v1(179.89,123.69) ; C635.2 C633.2 187.77,53.9 v1(187.84,53.82) ; v1(10.96,141.16) 11.02,141.23 JSIMUAJ1.22 11.73,142.5 ; 183.93,151.28 JLAN1.10 182.94,149.26 ; ME1.2 138.33,64.95 v1(138.33,65.48) ; JEDP1.53 55.19,105.57 ; JEDP1.53 56.68,106.55 ; JEDP1.53 58.17,105.57 ; JEDP1.53 56.68,104.43 ; JHS1.12 174.43,27.4 ; JHS1.12 173.58,26.8 173.14,26.35 ; JHS1.12 172.73,27.4 ; JHS1.12 173.58,28.56 ; v1(148.91,97.37) 148.91,97.24 RC156.2 ; C9919.2 171.03,43.93 v1(171.05,43.96) ; v1(14.74,100.15) JUSB1.11 13,101.08 ; JHDMI1.21 5.44,122.35 ; JHDMI1.21 1.96,122.35 ; JHDMI1.21 3.7,123.19 ; RC384.1 70.32,124.58 v1(70.42,124.47) ; v1(105.12,120.71) 105.28,120.71 105.51,120.48 JWWAN1.76 ; v1(175.63,36.28) 175.93,36.28 176.19,36.54 JSEC1.24 ; v1(189.42,127.9) 189.29,128.03 C3063.2 ; v1(56.5,98.24) C9912.2 ; JRTC1.1 73.39,30.27 ; JRTC1.1 70.9,30.27 ; JRTC1.1 v1(71.99,29.26) ; C634.2 189.46,54.37 v1(189.46,52.57) ; JCRT1.5 89.72,150.73 ; v1(106.69,142.25) 107.01,141.93 JWWAN1.77 ; JSEC1.29 v1(178.19,41.64) 177.11,41.64 176.69,41.22 JSEC1.25 ; C9565.2 196.13,143.07 v1(196.37,142.84) ; RC584.1 52.72,124.4 v1(52.94,124.63) ; v1(138.45,66.13) 138.85,66.13 CMOS1.2 ; v1(75.32,74.88) 74.25,74.88 73.91,74.55 ; 3.43,85.9 JUSB1.12 7.11,85.9 ; C9441.2 v1(118.81,148.12) ; v1(88.83,145.12) 88.83,144.87 89.13,144.58 D4.2 ; JHDMI1.17 9.67,116.7 ; 9.92,112.2 JHDMI1.8 11.22,112.2 ; v1(189.16,117.34) 188.5,117.34 ; C9611.2 122.75,114.23 122.34,114.64 122.34,115.41 v1(122.57,115.63) 123.82,114.38 123.82,113.48 123.77,113.43 C9609.2 ; v1(162.37,32.31) 162.9,32.31 PD5101.2 ; 43.79,105.57 JEDP1.54 ; JEDP1.54 45.28,104.6 ; JEDP1.54 46.77,105.57 ; JEDP1.54 45.28,106.55 ; v1(133.16,108.01) 133.08,108.09 C9650.2 ; CC272.2 v1(75.37,125.82) ; v1(174.41,33.69) C208.2 ; v1(46.85,129.38) C148.1 ; JRTC1.4 74.89,32.39 ; JRTC1.4 74.89,35.65 ; JRTC1.4 73.06,34.07 ; JUSB2.7 144.53,143.06 144.08,142.61 ; JUSB2.7 143.72,143.8 ; JUSB2.7 144.53,145.11 ; v1(163.22,111.44) 163.22,111.84 163.78,112.4 JGPS1.1 ; C9564.2 187.23,139.92 v1(187.16,139.84) ; JCRT1.17 100.31,147.53 ; JCRT1.17 99.37,145.65 ; JCRT1.17 98.43,147.53 ; JUSB1.10 13,88.2 ; JUSB1.10 14.41,87.35 ; JUSB1.10 13,86.5 ; D1.1 v1(70.62,79.52) ; v1(46.85,130.52) C147.1 ; v1(60.27,116.44) 60.27,116.14 60.45,115.96 CC41.2 ; v1(33.92,115.89) 34.35,116.32 34.35,117.87 33.95,118.28 v1(33.95,119.24) ; v1(48.86,95.13) 48.86,94.55 C9430.2 ; v1(77.86,112.76) 77.86,113.5 v1(78.07,113.7) ; 75.55,37.28 JDIMM2.264 76.89,39.61 ; v1(83.06,113.17) 82.74,113.49 CC93.2 ; C76.1 154.4,123.18 v1(154,123.57) ; R96.1 v1(48.96,98.59) ; JSER1.10 134.97,147.47 ; JSER1.10 133.4,147.47 ; JSER1.10 134.18,145.77 ; C9921.2 171.49,34.9 v1(171.49,34.07) ; v1(173.16,61.56) 172.88,61.56 171.65,60.32 JEPC1.39 172.8,59.55 173.16,59.91 v1(173.16,60.95) ; CC288.1 137.04,110.61 v1(136.38,111.27) 135.93,110.81 C9887.2 ; JCSW2.4 179.17,125.5 179.64,125.03 v1(179.77,125.03) ; C9559.2 158.55,122.53 v1(158.51,122.49) ; JRTC1.3 74.89,29.03 ; JRTC1.3 v1(72.88,27.72) ; JRTC1.3 74.89,26.41 ; v1(15.86,139.36) 16.23,138.99 JSIMUAJ1.11 ; v1(181.15,123.69) 181.15,123.18 C3061.2 ; CC7.2 117.14,110.14 v1(117.14,109.75) ; C9563.2 189.4,151.09 v1(189.7,151.09) ; 12.79,104.05 12.79,104.05 JHDMI1.22 ; JSEC1.27 163.69,39.79 163.38,39.49 v1(163.38,38.98) ; CC10.2 78.32,114.49 78.07,114.24 v1(78.07,113.7) ; C9920.2 172.21,43.66 v1(172.43,43.88) ; C9462.2 158.62,129.48 v1(158.05,128.91) ; 104.2,145.77 JSER1.11 ; JSER1.11 103.41,147.47 ; JSER1.11 104.98,147.47 ; v1(163.44,122.72) 163.29,122.58 C9918.2 164.2,120.66 ; 31.56,103.62 JEDP1.52 ; JEDP1.52 30.63,101.69 ; JEDP1.52 30.63,105.99 ; C16.2 84.06,146.65 v1(84.24,146.83) ; C9641.2 145.17,91.63 v1(145.22,91.68) ; JUSB2.5 144.51,150.4 ; JUSB2.5 144.51,147.3 ; JUSB2.5 143.53,148.85 ; 9.92,109.2 JHDMI1.2 ; JHDMI1.2 10.57,108.55 ; JHDMI1.2 11.22,109.2 ; v1(155.43,109.23) 155.43,109.31 155.58,109.45 JSPI1.4 ; JHDMI1.22 10.8,102.91 ; JHDMI1.22 8.9,104.05 ; JHDMI1.22 10.8,105.16 ; JRCAM1.11 v1(203.96,147.56) ; R195.1 v1(176.31,33.8) 175.68,33.8 175.42,34.05 C9492.1 ; C18.2 v1(86.8,145.78) ; JRCAM1.12 211.26,148.58 v1(211.26,149.6) ; C9560.2 152.33,117.54 v1(151.88,117.08) ; v1(266.83,6.47) JLED1.13 v1(266.83,4.31) ; JPSEN1.6 93.13,113.47 v1(92.54,114.06) ; D66.2 82.1,145.66 v1(81.85,145.91) ; C409.2 53.76,118.2 52.87,118.2 52.49,117.82 v1(52.49,117.52) ; C9922.2 173.75,33.88 v1(173.75,33.67) ; C333.2 v1(16.52,125.09) ; C9442.2 122.24,147.87 v1(121.98,148.12) ; 13.9,89.44 JUSB1.4 ; JUSB1.4 14.71,90.25 ; JUSB1.4 13.9,91.06 ; 194.53,25.8 JODD1.17 ; JODD1.17 195.48,24.64 ; JODD1.17 195.48,26.96 ; v1(164.02,38.98) 164.02,38.6 163.69,38.27 JSEC1.28 ; C9566.2 v1(195.87,144.26) ; PR5620.2 v1(168.21,104.79) PR5619.2 ; CC268.2 80.36,126.19 v1(80.53,126.35) ; D69.2 v1(157.59,138.85) ; JHDMI1.5 9.67,110.7 ; U9.2 54.58,94.15 v1(54.73,94) ; v1(39.08,98.01) 39.08,96.78 39.45,96.41 D7120.2 ; PD5102.2 162.52,33.52 v1(162.37,33.67) ; R2677.2 199.96,46.11 v1(199.96,46.39) ; C9562.2 187.23,150.57 v1(187.23,151.04) ; 161.99,21.45 161.98,21.46 JHS1.11 ; C184.2 C185.2 141.73,134.8 141.16,135.37 v1(141.16,135.5) ; v1(88.23,115.2) 88.23,114.74 88.45,114.52 88.45,113.66 JPSEN1.5 89.5,113.47 89.94,113.03 JPSEN1.4 ; v1(170.17,55.31) 170.19,55.31 170.65,54.85 CE22.2 ; JSEC1.30 178.9,37.4 v1(179.33,37.83) ; v1(23.97,117.42) JWLAN1.77 25.73,116.56 v1(25.56,116.4) ; D67.2 v1(154.7,138.6) ; CC273.2 81.42,113.6 v1(81.42,113.02) ; JEDP1.51 59.93,101.69 ; JEDP1.51 59.93,105.7 ; JEDP1.51 59,103.62 ; D7109.2 v1(17.11,93.59) ; v1(181.45,127.12) 182,127.12 R2720.2 ; JHDMI1.11 9.67,113.7 ; 87.81,149.87 JCRT1.10 ; 76.25,143.27 C14.2 ; JUSB1.13 6.94,101.6 ; JUSB1.13 3.46,101.6 ; JUSB1.13 5.2,102.34 ; v1(86.55,122.42) 86.8,122.16 86.8,120.38 88.4,118.79 Q1701.2 ; R9648.1 v1(23.56,120.28) ; 68.45,147.53 JCRT1.16 ; JCRT1.16 70.32,147.53 ; JCRT1.16 69.38,145.65 ; RC191.1 v1(56.27,124.7) ; v1(11.73,136.72) JSIMUAJ1.21 10.82,138.23 10.78,138.19 ; Q3607.2 92.91,118.24 93.27,117.88 v1(93.58,117.88) ; 112.79,150.63 JSER1.5 ; 78.65,149.9 JCRT1.6 77.89,150.73 ; v1(82.26,137.12) 82.23,137.1 C9914.2 ; D7108.2 18.79,97.44 v1(18.81,97.42) ; v1(175.7,121.43) 175.7,121.4 JCSW2.6 ; 33.88,106.55 JEDP1.55 ; JEDP1.55 32.19,105.57 ; JEDP1.55 33.88,104.6 ; JEDP1.55 35.37,105.57 ; C9981.2 193.29,150.95 v1(192.84,150.95) 192.3,150.42 C9567.2 ; C9459.2 154.21,98.29 v1(153.73,98.77) ; v1(78.07,113.7) 78.32,113.45 CC11.2 ; C85.1 143.22,119.53 v1(143.22,120.43) ; C9207.2 175.16,43.22 174.64,43.74 v1(174.64,44.08) 174.64,44.46 174.77,44.6 JSH1.18 ; 90.49,145.91 91.32,145.07 C17.2 ; JSEC1.10 v1(169.19,36.28) ; JSEC1.6 167.19,38.59 v1(167.4,38.8) 167.69,39.09 JSEC1.7 ; PD5103.2 162.6,34.79 v1(162.42,34.61) ; v1(19.18,119.8) HDMIU1.1 ; 160.03,145.11 JUSB2.8 160.85,143.8 ; v1(122.11,106.41) 121.73,106.41 121.35,106.79 121.35,107.92 122.75,109.31 C9608.2 ; CC267.2 133.67,74.16 134.29,73.53 v1(135.01,73.53) ; 161.85,151.28 JLAN1.9 162.84,149.26 ; v1(15.68,140.07) 15.73,140.12 JSIMUAJ1.12 15.73,142.38 ; 153.26,34.5 JBAT1.8 ; C9526.2 16.45,114.19 ; CC92.2 v1(145.65,72.63) ; v1(41.95,95.79) 41.32,96.41 D7119.2 ; 15.3,114.21 C9525.2 ; v1(117.66,148.12) C9464.2 ; 188.48,116.68 v1(189.19,116.68) ; v1(116.01,113.27) 116.01,114.64 v1(116.11,114.75) 116.58,115.21 v1(117.26,115.21) v1(118.45,115.21) v1(119.59,115.21) 120.69,115.21 121.65,114.24 v1(121.65,113.48) v1(121.65,112.54) v1(121.65,111.75) v1(121.65,111.13) v1(121.65,110.43) v1(121.65,109.74) 121.65,109.64 120.33,108.32 120.33,106.36 v1(119.14,105.17) 118.07,105.17 v1(116.83,106.41) 116.01,107.23 v1(116.01,109.87) v1(116.01,110.81) v1(116.01,111.9) v1(116.01,113.27)
  vias: v1(0.95,139.59) v1(0.95,136.45) v1(1.1,123.71) v1(1.05,122.31) v1(1.01,85.86) v1(1.46,141.59) v1(1.78,103.42) v1(1.74,102.56) v1(1.82,101.64) v1(2.2,142.79) v1(2.63,101.59) v1(2.71,85.92) v1(2.86,102.81) v1(3.01,136.44) v1(3.67,123.92) v1(5.83,123.89) v1(5.83,122.04) v1(5.93,102.63) v1(6.28,104.39) v1(6.72,103.95) v1(6.9,102.78) v1(7.05,122.11) v1(7.3,123.87) v1(7.58,102.33) v1(7.84,85.87) v1(7.94,101.57) v1(8.14,103.8) v1(8.34,136.64) v1(8.55,102.84) v1(8.7,123.82) v1(8.7,123.03) v1(8.83,101.59) v1(9.01,142.56) v1(9.08,107.81) v1(9.33,85.84) v1(9.49,137.79) v1(9.56,119.93) v1(9.59,106.42) v1(9.69,141.16) v1(9.64,118.56) v1(9.74,111.29) v1(9.84,139.64) v1(9.89,121.1) v1(9.84,105.09) v1(9.89,101.57) v1(10.07,102.86) v1(10.45,136.57) v1(10.81,123.97) v1(10.76,119.83) v1(10.88,139.61) v1(10.88,137.79) v1(10.91,102.33) v1(11.29,142.51) v1(11.36,115.02) v1(11.36,114.24) v1(11.44,111.4) v1(11.52,121.07) v1(11.52,112.97) v1(11.72,109.77) v1(12.18,140.07) v1(12.26,139.41) v1(12.25,106.36) v1(12.36,120.77) v1(12.38,108.22) v1(12.46,85.87) v1(12.69,114.08) v1(12.71,94.76) v1(12.76,103.09) v1(12.77,102.12) v1(12.82,104.94) v1(12.82,92.78) v1(12.92,123.36) v1(12.96,119.95) v1(12.99,114.9) v1(12.94,113.04) v1(12.99,88.87) v1(13.02,116.63) v1(13.15,98.57) v1(13.3,137) v1(13.24,121.5) v1(13.22,111.14) v1(13.5,122.57) v1(13.65,142.54) v1(13.7,108.93) v1(13.68,107.1) v1(13.9,120.97) v1(14.13,121.78) v1(14.24,113.15) v1(14.36,113.94) v1(14.46,114.9) v1(14.44,85.97) v1(14.51,107.81) v1(14.79,122.34) v1(14.87,103.86) v1(14.89,102.32) v1(14.84,89.07) v1(14.92,123.79) v1(15.1,131.82) v1(15.1,130.39) v1(15.1,127.93) v1(15.03,106.07) v1(15.13,133.06) v1(15.15,125.8) v1(15.23,91.07) v1(15.45,134.94) v1(15.56,113.96) v1(15.56,113.2) v1(15.58,111.32) v1(15.68,142.61) v1(15.71,109.01) v1(15.81,92.57) v1(15.91,105.18) v1(15.94,90.16) v1(15.94,87.65) v1(16.78,85.94) v1(16.87,103.68) v1(17,91.13) v1(17.2,106.77) v1(17.21,108.09) v1(18.21,104.52) v1(18.55,135.14) v1(18.6,106.62) v1(18.66,108.09) v1(19.04,128.97) v1(19.19,135.17) v1(19.11,116.75) v1(19.24,113.66) v1(19.24,110.99) v1(19.25,92.61) v1(19.34,105.22) v1(19.82,108.98) v1(20.04,114.23) v1(20.07,113.42) v1(20.07,110.91) v1(20.13,129.02) v1(20.13,118.2) v1(20.16,115.76) v1(20.13,111.54) v1(20.25,108.03) v1(20.25,106.61) v1(20.49,104.16) v1(20.69,126.33) v1(20.86,127.5) v1(20.91,105.38) v1(21.27,124.68) v1(21.32,122.14) v1(22.17,104.15) v1(22.39,127.24) v1(22.54,111.49) v1(23.1,135.98) v1(23.1,112.41) v1(23.18,114.52) v1(23.18,98.54) v1(23.48,116.73) v1(24.12,93.66) v1(24.22,111.95) v1(24.37,136.94) v1(24.98,111.04) v1(25.05,92.53) v1(25.08,86.1) v1(25.97,98.54) v1(26.12,95.19) v1(26.12,93.82) v1(27.12,86.1) v1(27.46,137.94) v1(27.47,129.43) v1(27.6,125.98) v1(28.12,136.43) v1(28.41,137.96) v1(28.76,98.54) v1(29.15,86.1) v1(29.93,124.78) v1(30.03,116.19) v1(30.03,115.56) v1(31.33,138.19) v1(31.53,137.38) v1(31.79,85.97) v1(31.88,106.6) v1(31.81,104.38) v1(32.14,137.38) v1(32.27,131.23) v1(32.24,102.88) v1(32.5,117.97) v1(32.55,130.44) v1(32.55,129.81) v1(33.13,106.67) v1(33.21,104.38) v1(33.49,98.77) v1(34.5,97.85) v1(34.81,86) v1(34.96,99.15) v1(34.94,98.44) v1(35.14,115.35) v1(36.05,115.35) v1(36.46,99.05) v1(36.51,106.67) v1(36.72,94.3) v1(36.92,110.58) v1(36.94,99.76) v1(37.27,115.32) v1(37.25,85.94) v1(37.91,105.78) v1(37.91,104.51) v1(38.01,98.16) v1(38.42,89.78) v1(39.31,89.78) v1(39.56,106.67) v1(40.22,91.15) v1(40.27,85.89) v1(42.61,94.83) v1(42.84,133.24) v1(42.91,85.87) v1(43.32,94.86) v1(44.36,126.45) v1(44.65,104.26) v1(44.66,103.49) v1(44.94,133.21) v1(45.63,85.87) v1(46.14,95.26) v1(46.33,98.03) v1(47.08,105.78) v1(47.05,104.64) v1(47.15,116.83) v1(47.15,116.22) v1(47.73,96.17) v1(47.81,133.34) v1(48.02,85.82) v1(48.13,106.49) v1(48.13,105.83) v1(48.43,103.96) v1(48.43,103.35) v1(49.87,99.93) v1(50.3,85.82) v1(50.35,133.34) v1(50.96,131.15) v1(50.95,127.46) v1(51.4,103.92) v1(51.37,103.26) v1(51.6,131.13) v1(51.56,127.44) v1(51.73,98.61) v1(52.31,85.82) v1(52.39,99.25) v1(52.34,98.63) v1(52.89,133.34) v1(52.91,99.66) v1(54.8,121.2) v1(55.1,85.82) v1(55.38,108.12) v1(55.39,107.51) v1(55.4,106.89) v1(55.43,133.34) v1(55.54,116.6) v1(56.7,94.48) v1(56.98,87.24) v1(57.97,133.34) v1(58.13,121.07) v1(58.41,107.96) v1(58.38,107.35) v1(58.84,106.81) v1(59.45,87.97) v1(59.55,106.81) v1(59.88,107.94) v1(60.51,133.34) v1(62.04,110.06) v1(62.55,88) v1(62.82,146.09) v1(63.01,135.02) v1(63.11,144.29) v1(63.05,139.43) v1(63.05,136.89) v1(63.13,142.21) v1(64.43,87.16) v1(64.93,143.37) v1(65.7,85.21) v1(65.8,146.17) v1(65.75,82.41) v1(65.75,79.47) v1(65.75,76.88) v1(65.97,144.74) v1(66.97,146.93) v1(68.01,148.28) v1(68.9,28.31) v1(69.4,70.73) v1(69.54,135.96) v1(69.54,135.33) v1(69.78,143.24) v1(70.29,30.34) v1(70.47,87.97) v1(70.64,144.65) v1(70.75,148.17) v1(70.8,143.24) v1(70.8,68.7) v1(70.9,147.21) v1(70.9,87.54) v1(71.51,146.49) v1(71.46,145.46) v1(71.56,86.98) v1(71.56,32.37) v1(72.05,86.5) v1(72.07,66.41) v1(72.38,148.12) v1(72.58,133.13) v1(72.58,34.41) v1(72.88,32.45) v1(73.21,64) v1(73.52,135.17) v1(73.52,133.77) v1(73.72,85.54) v1(73.72,36.69) v1(73.98,61.58) v1(73.95,21.19) v1(74.41,148.07) v1(74.36,38.98) v1(74.53,145.66) v1(74.67,147.17) v1(74.67,133.25) v1(74.64,36.34) v1(74.86,58.92) v1(74.99,41.26) v1(74.99,21.2) v1(75.22,133.77) v1(75.37,145.66) v1(75.37,56.38) v1(75.63,43.8) v1(75.8,140.98) v1(75.75,53.96) v1(75.73,39.56) v1(75.82,142.41) v1(75.91,40.22) v1(75.96,136.44) v1(76.01,46.22) v1(76.13,51.55) v1(76.13,49.01) v1(76.51,147.15) v1(76.7,148.12) v1(76.62,142.41) v1(76.67,140.98) v1(77,150.74) v1(76.97,74.66) v1(77.15,145.66) v1(77.47,150.09) v1(78.17,145.66) v1(78.32,130.42) v1(78.47,147.17) v1(78.8,145.66) v1(79.31,147.41) v1(79.94,144.04) v1(80.1,142.38) v1(80.2,132.4) v1(80.2,131.79) v1(80.35,148.07) v1(80.38,147.38) v1(80.33,133.47) v1(80.88,137.16) v1(81.34,148.1) v1(81.34,147.38) v1(81.98,144.01) v1(82.21,147.38) v1(82.2,29.97) v1(82.54,48.25) v1(82.56,28.46) v1(82.89,140.86) v1(83.09,137.78) v1(83.2,147.49) v1(83.27,144.03) v1(83.35,98.41) v1(83.4,30.06) v1(83.86,89.62) v1(84.14,40.37) v1(84.24,98.44) v1(84.47,89.62) v1(85.08,89.62) v1(85.15,98.44) v1(85.69,89.62) v1(85.66,57.52) v1(86.04,98.44) v1(86.29,89.62) v1(86.29,57.52) v1(86.68,147.99) v1(86.91,89.62) v1(86.96,100.75) v1(86.93,98.44) v1(87.44,61.84) v1(87.55,89.65) v1(87.79,98.44) v1(87.89,29.21) v1(87.87,28.55) v1(88.15,146.52) v1(88.63,135.95) v1(88.66,98.44) v1(88.71,34.79) v1(88.71,27.74) v1(88.81,123.81) v1(88.72,37.2) v1(89.18,44.69) v1(89.5,146.52) v1(89.5,87.62) v1(89.55,98.44) v1(90,148.91) v1(90.33,148.02) v1(90.46,150.71) v1(90.71,97.8) v1(90.84,147.41) v1(90.86,34.79) v1(91.22,134.94) v1(91.31,44.69) v1(91.37,146.95) v1(91.32,97.8) v1(91.83,147.87) v1(92.24,129.37) v1(92.33,130.44) v1(92.87,127.51) v1(92.95,131.2) v1(93.02,28.38) v1(93.79,56.88) v1(93.79,56.25) v1(93.79,55.61) v1(93.79,54.98) v1(93.77,30.03) v1(93.92,147.95) v1(93.97,128.79) v1(93.97,127.65) v1(94.53,27.14) v1(94.86,29.19) v1(94.93,147.21) v1(96.02,28.45) v1(96.15,148.15) v1(96.35,146.37) v1(97.32,119.85) v1(97.43,117.23) v1(97.6,136.51) v1(97.6,135.9) v1(97.98,148.2) v1(98.31,146.77) v1(98.23,37.07) v1(98.6,29.97) v1(98.6,28.64) v1(98.92,117.31) v1(99.15,119.95) v1(99.32,116.73) v1(99.74,48.28) v1(100.65,148.28) v1(100.75,119.37) v1(100.82,117.29) v1(100.98,147.64) v1(101.21,152.24) v1(101.77,149.19) v1(101.76,124.93) v1(101.84,147.38) v1(102.17,128.51) v1(102.42,152.24) v1(103.01,146.93) v1(103.14,148.1) v1(103.26,129.63) v1(103.8,113.25) v1(103.82,32.12) v1(104.07,70.54) v1(104.07,69.93) v1(104.07,69.28) v1(104.89,36.44) v1(105.37,148.22) v1(106.25,116.03) v1(106.25,115.42) v1(106.25,114.81) v1(106.25,114.19) v1(106.25,113.58) v1(106.25,112.97) v1(106.25,112.36) v1(106.25,111.75) v1(106.25,111.14) v1(106.25,110.53) v1(106.67,148.25) v1(108.16,148.25) v1(109.48,148.2) v1(109.79,49.14) v1(110.5,35.9) v1(110.5,35.17) v1(110.81,147.59) v1(111.26,124.73) v1(111.31,103.49) v1(111.57,48.63) v1(111.8,150.64) v1(112.21,148.76) v1(112.3,107.56) v1(112.53,105.25) v1(112.71,35.95) v1(112.69,35.32) v1(113.09,28.3) v1(113.37,140.83) v1(113.73,106.67) v1(114.21,104.56) v1(114.29,136.39) v1(114.49,36.03) v1(114.5,35.34) v1(114.59,140.86) v1(114.6,135.79) v1(114.52,114.92) v1(114.52,114.31) v1(114.52,113.7) v1(114.52,113.09) v1(114.52,112.48) v1(114.52,111.88) v1(114.52,111.27) v1(114.51,105.14) v1(114.62,48.88) v1(114.62,48.26) v1(116.01,48.25) v1(116.29,36.79) v1(116.25,35.88) v1(116.25,35.17) v1(116.6,140.78) v1(116.93,134.55) v1(117.03,69.91) v1(117.03,69.28) v1(117.03,68.64) v1(117.23,30.16) v1(117.79,24.88) v1(118.03,36.11) v1(118.04,28.06) v1(118.17,134.58) v1(118.4,140.78) v1(118.39,27.39) v1(118.55,24.88) v1(119.44,140.78) v1(119.57,134.62) v1(119.95,148.12) v1(119.99,36.11) v1(119.98,35.44) v1(120.33,140.78) v1(121.09,148.12) v1(121.14,135.73) v1(121.84,35.89) v1(121.84,35.23) v1(122.64,65.46) v1(122.82,135.29) v1(122.82,49.75) v1(123.19,140.77) v1(123.33,49.26) v1(123.77,50.04) v1(123.84,48.76) v1(124.23,49.64) v1(124.67,49.19) v1(124.67,36.89) v1(125.59,105.6) v1(125.51,40.37) v1(125.64,136.26) v1(125.79,149.04) v1(126.2,150.51) v1(126.25,136.26) v1(126.38,147.82) v1(126.43,35.55) v1(126.93,30.12) v1(127.2,140.07) v1(127.6,36.18) v1(127.6,35.04) v1(128.54,147.39) v1(128.71,44.69) v1(129.38,30.16) v1(129.47,36.89) v1(129.47,36.18) v1(129.47,35.09) v1(130.54,118.45) v1(130.59,114.19) v1(130.59,113.55) v1(130.59,112.92) v1(130.59,112.28) v1(130.59,111.65) v1(130.74,116.65) v1(130.87,147.74) v1(130.92,44.64) v1(131.68,106.69) v1(131.92,36.86) v1(131.92,36.18) v1(131.92,35.55) v1(132.78,44.69) v1(133.11,147.66) v1(135.01,71.84) v1(135.57,148.07) v1(136.27,36.89) v1(136.27,36.06) v1(136.27,35.09) v1(136.46,152.14) v1(136.46,150.23) v1(136.88,28.32) v1(137.02,124.83) v1(137.41,30.15) v1(137.63,124.83) v1(138.09,149.24) v1(138.03,60.64) v1(138.44,148.07) v1(138.44,124.83) v1(138.49,36.46) v1(138.49,34.91) v1(138.67,124.02) v1(138.64,71.11) v1(138.67,60.64) v1(138.72,150.33) v1(139,152.14) v1(139.28,60.67) v1(139.63,149.21) v1(139.68,36.95) v1(139.68,36.24) v1(140.02,139.18) v1(140.4,150.33) v1(140.45,148.28) v1(140.65,139.18) v1(141.29,139.18) v1(141.41,149.21) v1(141.48,36.06) v1(141.54,35.04) v1(142.05,152.13) v1(142.28,147.89) v1(142.33,150.31) v1(142.91,149.19) v1(143.02,60.05) v1(143.22,68.95) v1(143.32,44.81) v1(144.36,140.86) v1(144.46,152.04) v1(144.49,150.79) v1(144.46,146.96) v1(144.49,145.89) v1(144.68,140.09) v1(144.78,35.8) v1(144.78,35.04) v1(145.48,139.79) v1(145.73,42.03) v1(146.37,72.63) v1(146.42,68.49) v1(147.38,32.12) v1(147.8,43.98) v1(147.8,42.01) v1(147.86,57.24) v1(148.02,32.12) v1(148.4,139.31) v1(148.53,41.33) v1(148.58,38.93) v1(148.58,38.32) v1(148.58,37.71) v1(149.03,139.31) v1(149.03,96.34) v1(149.29,133.52) v1(149.67,139.31) v1(149.67,72.73) v1(149.9,49.42) v1(149.92,50.08) v1(150.02,140.45) v1(150.35,96.34) v1(151.09,56.3) v1(151.18,54.44) v1(151.22,130.37) v1(151.24,117.08) v1(151.6,73.47) v1(151.52,55.82) v1(151.57,53.97) v1(152.6,31.31) v1(152.7,63.01) v1(153.22,33.69) v1(153.25,32.55) v1(154.37,110.43) v1(154.52,140.42) v1(157.01,133.11) v1(157.01,132.47) v1(157.29,140.5) v1(159.25,140.05) v1(159.25,45.13) v1(160.03,150.66) v1(160.21,152.09) v1(160.29,147.16) v1(160.26,146.19) v1(160.26,55.28) v1(160.72,141.32) v1(160.93,47.13) v1(161.61,152.06) v1(161.63,149.57) v1(161.68,109.16) v1(161.74,140.83) v1(161.77,55.99) v1(161.81,54.7) v1(161.99,142.48) v1(162.55,117.29) v1(162.55,46.42) v1(162.85,144.14) v1(163.3,56.54) v1(163.39,148.53) v1(163.33,94.25) v1(163.44,147.51) v1(164.53,46.67) v1(164.65,32.78) v1(164.88,44.79) v1(165.49,102.72) v1(165.52,99.45) v1(165.67,127.75) v1(165.67,126.99) v1(165.8,101.56) v1(165.77,97.63) v1(166.71,56.4) v1(166.71,55.74) v1(166.76,127.62) v1(166.85,72.89) v1(166.99,44.79) v1(167.17,85.13) v1(167.38,67.46) v1(167.42,99.45) v1(167.9,127.62) v1(168.11,44.21) v1(168.54,68.31) v1(168.97,75.81) v1(168.97,75.2) v1(169.1,77.84) v1(169.09,56.38) v1(169.1,55.51) v1(169.3,127.62) v1(169.56,68.11) v1(169.73,23.99) v1(169.99,94.1) v1(170.37,23.99) v1(170.37,23.36) v1(170.37,22.72) v1(170.62,94.1) v1(170.7,31.76) v1(170.75,107.3) v1(170.75,106.67) v1(170.75,106.03) v1(171.08,127.62) v1(171.03,67.91) v1(171.13,23.99) v1(171.31,31.76) v1(171.77,23.99) v1(171.92,31.76) v1(172.4,72.05) v1(172.4,23.99) v1(172.43,23.36) v1(172.43,22.72) v1(172.55,118.89) v1(172.55,31.76) v1(172.65,75.3) v1(172.86,127.62) v1(173.01,72.05) v1(172.98,32.45) v1(172.98,28.77) v1(173.16,118.89) v1(173.19,21.12) v1(173.29,75.3) v1(173.59,32.45) v1(173.59,28.77) v1(173.67,72.05) v1(173.92,75.3) v1(174.1,56.12) v1(174.2,32.45) v1(174.2,28.77) v1(174.38,127.62) v1(174.71,64.18) v1(174.99,88.41) v1(174.99,87.8) v1(174.99,87.19) v1(174.97,86.3) v1(174.97,85.69) v1(174.97,85.08) v1(175.45,97.4) v1(175.45,96.76) v1(175.45,96.13) v1(175.45,95.49) v1(175.59,48.27) v1(175.65,127.62) v1(177.05,48.1) v1(178.37,47.49) v1(179.33,38.47) v1(179.94,38.47) v1(179.94,37.83) v1(180.58,38.47) v1(180.58,37.83) v1(180.91,81.14) v1(180.91,80.51) v1(181.01,134) v1(181.7,20.79) v1(182.18,58.76) v1(182.26,141.24) v1(182.28,140.25) v1(182.28,138.39) v1(182.44,148.96) v1(182.44,147.06) v1(182.61,142.02) v1(182.56,102.6) v1(182.56,101.97) v1(182.61,66.18) v1(182.62,58.32) v1(182.92,21.53) v1(183.09,37.83) v1(183.2,143.17) v1(183.2,102.6) v1(183.2,101.97) v1(183.3,144.54) v1(183.33,91.56) v1(183.65,97.5) v1(183.7,37.83) v1(184.06,144.85) v1(184.16,152.24) v1(184.16,148.83) v1(184.19,146.8) v1(184.12,58.54) v1(184.21,150.49) v1(184.24,20.79) v1(184.32,51.35) v1(184.9,37.83) v1(184.9,23.33) v1(185.56,37.83) v1(185.62,58.43) v1(185.92,152.26) v1(186.07,24.83) v1(186.7,37.83) v1(186.78,20.79) v1(187.39,52.41) v1(187.34,37.83) v1(187.69,104.43) v1(187.64,101.16) v1(187.61,99.74) v1(187.72,105.04) v1(188.07,50.39) v1(188.33,152.26) v1(188.56,24.83) v1(188.66,50.6) v1(189.01,65.77) v1(189.01,65.14) v1(189.22,119.18) v1(189.32,20.79) v1(189.7,26.8) v1(189.75,116.24) v1(189.77,115.53) v1(190.12,109.23) v1(190.12,108.61) v1(190.31,27.41) v1(190.31,26.8) v1(190.41,119.19) v1(190.47,50.81) v1(190.56,152.26) v1(190.59,107.13) v1(190.59,106.46) v1(190.87,21.53) v1(190.94,27.41) v1(190.94,26.8) v1(191.4,47) v1(191.55,27.41) v1(191.55,26.8) v1(192.16,27.41) v1(192.16,26.8) v1(192.28,47.03) v1(192.34,136.77) v1(192.34,134.23) v1(192.34,131.69) v1(192.34,129.15) v1(192.34,126.61) v1(192.34,124.07) v1(192.34,121.53) v1(192.34,118.99) v1(192.34,116.45) v1(192.34,113.91) v1(192.34,111.37) v1(192.34,108.83) v1(192.34,106.29) v1(192.34,103.75) v1(192.34,101.21) v1(192.34,98.67) v1(192.34,96.38) v1(192.34,93.59) v1(192.34,91.05) v1(192.37,87.52) v1(192.34,85.97) v1(192.34,83.43) v1(192.34,80.89) v1(192.34,78.35) v1(192.34,75.81) v1(192.37,73.14) v1(192.42,21.53) v1(192.8,27.41) v1(192.82,152.29) v1(192.82,26.8) v1(192.87,22.87) v1(192.97,138.67) v1(193.43,27.41) v1(193.43,26.8) v1(193.69,46.45) v1(194.04,70.76) v1(194.07,27.41) v1(194.07,26.8) v1(194.07,21.2) v1(194.29,46.42) v1(194.35,152.34) v1(194.68,27.39) v1(195.16,34.81) v1(195.29,27.39) v1(195.39,139.69) v1(195.79,34.81) v1(196.47,49.06) v1(196.91,21.2) v1(197.08,49.06) v1(197.32,70.5) v1(197.69,49.06) v1(197.93,139.69) v1(197.98,68.55) v1(198.33,49.06) v1(198.46,141.19) v1(199.07,66.06) v1(199.45,21.2) v1(199.52,37.45) v1(200.14,141.26) v1(201.89,61.96) v1(201.92,64.61) v1(201.99,21.2) v1(202.68,142.43) v1(203.01,152.39) v1(203.69,146.88) v1(204.28,145.66) v1(204.25,65.12) v1(204.47,150.8) v1(204.53,21.2) v1(204.81,142.25) v1(204.74,60.58) v1(205.35,60.58) v1(205.55,152.39) v1(205.63,66.34) v1(205.88,64.61) v1(206.72,141.34) v1(206.94,68.44) v1(206.94,67.04) v1(207.07,70.47) v1(207.07,21.2) v1(207.33,69.46) v1(207.83,65.65) v1(207.94,142.81) v1(208.09,152.39) v1(208.09,139.69) v1(208.47,65.65) v1(208.7,70.5) v1(209.61,21.2) v1(210.63,152.39) v1(210.63,139.69) v1(211.55,150.59) v1(211.73,58.28) v1(212.15,21.2) v1(212.25,52.41) v1(212.25,51.8) v1(212.34,58.28) v1(213.17,152.39) v1(213.17,149.85) v1(213.17,147.31) v1(213.17,144.77) v1(213.17,142.23) v1(213.17,139.69) v1(213.93,59.77) v1(213.97,51.8) v1(214.54,59.77) v1(214.59,51.8) v1(214.69,21.2) v1(215.15,59.77) v1(215.23,51.8) v1(215.94,70.53) v1(216.22,30.47) v1(216.85,30.47) v1(217.23,21.2) v1(217.87,30.47) v1(218.02,70.45) v1(218.5,30.47) v1(219.52,30.47) v1(219.77,21.2) v1(220.15,30.47) v1(220.28,70.47) v1(220.28,56.38) v1(220.27,48.91) v1(220.33,51.85) v1(222.31,70.47) v1(222.31,21.2) v1(224.85,70.47) v1(224.85,21.2) v1(227.14,39.61) v1(227.39,70.47) v1(227.39,21.2) v1(229.47,65.62) v1(229.93,70.47) v1(229.93,21.2) v1(232.47,70.47) v1(232.47,21.2) v1(235.01,70.47) v1(235.01,21.2) v1(237.55,70.47) v1(237.55,21.2) v1(239.08,38.49) v1(240.09,70.47) v1(240.09,21.2) v1(240.47,69.46) v1(242.12,69.46) v1(242.63,70.47) v1(242.63,21.2) v1(242.99,63.25) v1(245.17,21.2) v1(247.71,21.2) v1(250.25,21.2) v1(251.27,65.83) v1(252.79,21.2) v1(253.81,65.65) v1(255.33,21.2) v1(256.35,65.65) v1(257.49,19.67) v1(257.49,17.13) v1(257.49,14.59) v1(257.49,12.05) v1(257.49,10.51) v1(257.47,8.63) v1(257.42,6.57) v1(257.44,4.05) v1(257.44,2.02) v1(258.86,1.03) v1(259.4,65.65) v1(261.05,3.04) v1(261.05,2.4) v1(261.43,65.65) v1(261.86,1.06) v1(262.7,15.3) v1(262.75,19.62) v1(262.75,18.23) v1(262.72,16.83) v1(263.54,21.3) v1(263.59,3.04) v1(263.59,2.4) v1(263.97,65.65) v1(264.4,19.65) v1(264.45,18.17) v1(264.48,16.83) v1(264.61,1.01) v1(264.68,21.3) v1(265.44,19.67) v1(265.49,3.04) v1(265.49,2.4) v1(266.51,65.65) v1(266.51,12.05) v1(266.51,11.29) v1(266.51,10.4) v1(266.53,57.95) v1(266.7,48.69) v1(267.07,0.98) v1(267.4,3.04) v1(267.4,2.4) v1(268.18,11.82) v1(269.05,65.65) v1(269.56,10.28) v1(269.56,9.26) v1(269.81,1.01) v1(271.08,28.39) v1(271.08,27.32) v1(271.51,57.01) v1(271.59,65.65) v1(271.61,62.6) v1(271.87,34.53) v1(271.89,32.65) v1(271.94,54.67) v1(271.92,52.67) v1(271.94,30.24) v1(272.15,1.01) v1(272.4,61.08) v1(272.68,64.43) v1(273.98,65.55) v1(273.98,63.01) v1(273.98,60.47) v1(273.98,57.93) v1(273.98,55.39) v1(273.98,52.85) v1(273.98,50.31) v1(273.98,47.77) v1(273.98,45.23) v1(273.98,42.69) v1(273.98,40.15) v1(273.98,37.61) v1(273.98,35.07) v1(273.98,32.53) v1(273.98,29.99) v1(273.98,27.45) v1(273.98,24.91) v1(273.98,22.37) v1(273.98,19.83) v1(273.98,17.29) v1(273.98,14.75) v1(273.98,12.21) v1(273.98,9.67) v1(274.03,1.67) v2(71.44,86.09) v3(94.55,90.68) v3(98.61,75.3) v3(98.9,82.84) v3(98.94,76.26) v3(99.06,82.28) v3(99.02,75.7) v3(99.48,76.06) v3(99.99,86.04) v3(100.16,89.7) v3(100.77,97.04) v3(100.79,89.7) v3(100.87,86.09) v3(101.43,97.04) v3(101.81,86.04) v3(101.82,84.82) v3(101.82,84.16) v3(102.04,88.8) v3(102.07,87.88) v3(102.77,86.1) v3(103.64,86.13) v3(104.58,86.13) v3(104.58,85.46) v3(104.58,84.82) v3(104.59,84.18) v3(105.29,81.85) v3(105.5,86.13) v3(105.5,83.53) v3(105.47,82.85) v3(106.45,82.87) v3(107.57,101.24) v3(108.2,86.09) v3(109.66,95.57) v3(109.66,95.01) v3(109.66,94.32) v3(109.66,93.76) v3(109.66,93.1) v3(109.66,92.55) v3(109.66,91.86) v3(109.66,91.3) v3(109.66,90.74) v3(110.04,86.11) v3(110.17,81.85) v3(110.22,95.57) v3(110.22,95.01) v3(110.22,94.32) v3(110.22,93.76) v3(110.22,93.1) v3(110.22,92.55) v3(110.22,91.86) v3(110.22,91.3) v3(110.22,90.74) v3(110.95,86.12) v3(111.54,95.57) v3(111.54,95.01) v3(111.54,94.32) v3(111.54,93.76) v3(111.54,93.1) v3(111.54,92.55) v3(111.54,91.86) v3(111.54,91.3) v3(111.54,90.74) v3(112.53,101.2) v3(112.81,86.1) v3(113.7,85.43) v3(114.23,90.79) v3(114.23,88.25) v3(114.61,85.43) v3(115.53,99.07) v3(115.52,84.8) v3(115.52,82.87) v3(115.86,94.6) v3(115.86,94.04) v3(115.86,93.49) v3(115.86,92.83) v3(115.86,92.27) v3(115.86,91.58) v3(115.86,91.02) v3(117.16,94.6) v3(117.35,85.43) v3(117.35,84.8) v3(117.35,84.14) v3(118.02,94.6) v3(118.02,94.04) v3(118.02,93.49) v3(118.02,92.83) v3(118.02,92.27) v3(118.02,91.58) v3(118.02,91.02) v3(118.26,86.2) v3(118.27,85.43) v3(119.18,85.49) v3(119.21,84.85) v3(119.18,82.85) v3(119.77,89.9) v3(119.77,89.27) v3(119.77,88.51) v3(120.1,85.48) v3(120.97,94.81) v3(120.97,94.25) v3(120.97,93.46) v3(120.97,92.9) v3(120.97,92.22) v3(120.97,91.66) v3(120.97,90.84) v3(120.97,90.29) v3(121.01,85.48) v3(121.01,84.82) v3(121.01,84.18) v3(122.01,104.38) v3(121.92,86.13) v3(122.26,94.81) v3(122.26,94.25) v3(122.26,93.69) v3(122.26,93.13) v3(122.26,92.57) v3(122.52,81.85) v3(122.64,105.32) v3(122.84,86.13) v3(123.12,94.81) v3(123.12,94.25) v3(123.12,93.69) v3(123.12,93.13) v3(123.12,92.57) v3(123.38,91.4) v3(123.38,90.84) v3(123.38,90.29) v3(123.75,84.82) v3(123.75,84.17) v3(124.52,95.11) v3(124.52,94.5) v3(125.02,88.44) v3(125.29,90.88) v3(125.26,89.35) v3(125.41,95.16) v3(126.15,91.81) v3(126.5,85.47) v3(126.5,84.82) v3(126.5,84.18) v3(126.78,95.17) v3(126.81,91.81) v3(127.44,90.97) v3(127.41,84.82) v3(127.44,81.79) v3(128.74,91.85) v3(129.24,82.87) v3(129.4,89.29) v3(131.07,84.19) v3(131.98,84.82) v3(131.98,82.87) v3(132.01,86.88) v3(132.88,86.09) v3(133.55,87.86) v3(134.73,84.17) v3(135.72,85.1) v3(140.35,86.68) v4(23.18,101.72) v4(23.18,100.7) v4(23.18,99.69) v4(25.21,89.14) v4(25.21,88.26) v4(25.21,87.37) v4(26.1,88.26) v4(26.1,87.37) v4(34.58,89.78) v4(35.5,89.78) v4(36.39,89.78) v4(36.39,88.89) v4(37.28,89.78) v4(37.28,88.89) v4(61.53,102.73) v4(61.53,101.84) v4(61.53,100.96) v4(62.42,102.73) v4(62.42,101.84) v4(62.42,100.96) v4(63.31,102.73) v4(63.31,101.84) v4(63.31,100.96) v4(65.97,75.05) v4(66.61,74.28) v4(66.92,102.17) v4(66.92,101.28) v4(66.94,100.36) v4(66.94,99.47) v4(67.24,73.52) v4(67.81,102.17) v4(67.81,101.28) v4(67.83,100.36) v4(67.83,99.47) v4(67.88,72.63) v4(68.79,101.22) v4(68.72,100.36) v4(68.72,99.47) v4(68.82,102.16) v4(82.87,97.83) v4(83.23,124.58) v4(83.5,127.53) v4(83.81,97.83) v4(84.69,97.83) v4(85.38,88.23) v4(85.58,97.83) v4(85.66,60.06) v4(85.66,59.17) v4(85.66,58.28) v4(86.03,87.49) v4(86.47,97.83) v4(86.49,88.23) v4(86.55,60.06) v4(86.55,59.17) v4(86.55,58.28) v4(86.94,87.49) v4(87.36,97.83) v4(87.67,121.76) v4(88.23,97.83) v4(89.09,97.83) v4(89.55,134.99) v4(89.95,135.8) v4(89.98,97.83) v4(89.98,88.22) v4(90.75,121.63) v4(100.24,141.42) v4(108.65,127.63) v4(108.65,126.36) v4(109.54,127.63) v4(109.54,126.36) v4(114.64,126.71) v4(116.77,121.53) v4(116.77,120.64) v4(118.3,121.53) v4(118.3,120.64) v4(119.19,121.53) v4(119.19,120.64) v4(119.31,129.15) v4(119.31,128.26) v4(119.31,127.37) v4(120.2,129.15) v4(120.2,128.26) v4(120.2,127.37) v4(121.09,129.15) v4(121.09,128.26) v4(121.09,127.37) v4(121.98,129.15) v4(121.98,128.26) v4(121.98,127.37) v4(123.89,129.83) v4(123.89,128.94) v4(124.78,129.83) v4(124.78,128.94) v4(139.13,115.84) v4(139.43,116.65) v4(140.02,115.84) v4(140.3,116.68) v4(151.45,30.85) v4(151.88,38.19) v4(151.88,37.3) v4(151.88,36.41) v4(151.88,35.52) v4(152.74,38.19) v4(152.74,37.3) v4(152.74,36.41) v4(152.74,35.52) v4(154.27,133.41) v4(159.34,44.17) v4(164.27,110.73) v4(164.9,110.09) v4(169.1,79.44) v4(169.1,78.58) v4(173.8,101.97) v4(173.8,101.08) v4(185.9,53.84) v4(185.9,52.95) v4(185.86,52.06) v4(186.54,65.94) v4(186.54,65.08) v4(186.76,53.71) v4(186.76,52.82) v4(186.75,51.93) v4(187.29,67.25) v4(187.29,66.38) v4(187.31,65.47) v4(187.31,64.59) v4(188.07,66.88) v4(188.1,65.86) v4(188.1,64.99) v4(199.43,30.14) v4(199.71,29.28) v4(208.21,37.45) v4(209.15,37.45) v4(210.18,37.45) v4(214.46,28.33) v4(215.35,28.33) v4(217.23,37.45) v4(218.12,37.45) v4(219.26,37.45) v4(220.15,37.45) v4(221.75,37.45) v4(222.64,37.45) v4(223.38,38.6) v4(224.27,38.6) v4(225.16,38.6) v4(230.77,29.96) v8(16.19,113.73) v8(16.19,112.92) v8(16.19,112.11) v8(16.19,111.29) v8(16.19,110.48) v8(16.19,109.67) v8(17.01,113.73) v8(17.01,112.92) v8(17.01,112.11) v8(17.01,111.29) v8(17.01,110.48) v8(17.01,109.67) v8(17.82,113.73) v8(17.82,112.92) v8(17.82,112.11) v8(17.82,111.29) v8(17.82,110.48) v8(17.82,109.67) v8(18.63,113.73) v8(18.63,112.92) v8(18.63,112.11) v8(18.63,111.29) v8(18.63,110.48) v8(18.63,109.67) v8(18.76,132.27) v8(18.76,131.46) v8(18.76,130.65) v8(18.76,129.84) v8(19.57,131.46) v8(19.57,130.65) v8(19.57,129.84) v8(20.38,132.27) v8(20.38,131.46) v8(20.38,130.65) v8(20.38,129.84) v8(21.2,132.27) v8(21.2,131.46) v8(21.2,130.65) v8(21.2,129.84) v8(22.01,132.27) v8(22.01,131.46) v8(22.01,130.65) v8(22.01,129.84) v8(22.82,132.27) v8(22.82,129.84) v8(35.31,114.47) v8(35.31,113.66) v8(35.31,112.84) v8(35.31,112.03) v8(36.13,114.47) v8(36.13,113.66) v8(36.13,112.84) v8(36.13,112.03) v8(36.94,114.47) v8(36.94,113.66) v8(36.94,112.84) v8(36.94,112.03) v8(37.75,114.47) v8(37.75,113.66) v8(37.75,112.84) v8(37.75,112.03) v8(38.57,114.47) v8(38.57,113.66) v8(38.57,112.84) v8(38.57,112.03) v8(39.38,114.47) v8(39.38,113.66) v8(39.38,112.84) v8(39.38,112.03) v8(77.28,21.12) v8(77.28,21.12) v8(78.09,21.12) v8(78.09,21.12) v8(78.9,21.12) v8(78.9,21.12) v8(79.72,21.12) v8(79.72,21.12) v8(80.53,21.12) v8(80.53,21.12) v8(81.34,21.12) v8(81.34,21.12) v8(82.15,21.12) v8(82.15,21.12) v8(82.97,21.12) v8(82.97,21.12) v8(83.81,124.93) v8(83.78,21.12) v8(83.78,21.12) v8(84.59,21.12) v8(84.59,21.12) v8(85.38,124.6) v8(85.41,21.12) v8(85.41,21.12) v8(86.28,130.66) v8(86.28,129.36) v8(86.22,21.12) v8(86.22,21.12) v8(86.93,128.06) v8(87.03,21.12) v8(87.03,21.12) v8(87.84,21.12) v8(87.84,21.12) v8(88.23,127.41) v8(88.66,21.12) v8(88.66,21.12) v8(89.47,21.12) v8(89.47,21.12) v8(90.18,126.11) v8(90.28,21.12) v8(90.28,21.12) v8(91.1,21.12) v8(91.1,21.12) v8(91.91,21.12) v8(91.91,21.12) v8(92.72,21.12) v8(92.72,21.12) v8(93.53,21.12) v8(93.53,21.12) v8(94.35,21.12) v8(94.35,21.12) v8(95.16,21.12) v8(95.16,21.12) v8(95.97,21.12) v8(95.97,21.12) v8(96.78,21.12) v8(96.78,21.12) v8(97.6,21.12) v8(97.6,21.12) v8(98.41,21.12) v8(98.41,21.12) v8(99.22,21.12) v8(99.22,21.12) v8(100.04,21.12) v8(100.04,21.12) v8(100.85,21.12) v8(100.85,21.12) v8(100.95,145.38) v8(100.95,144.57) v8(100.95,143.88) v8(101.66,21.12) v8(101.66,21.12) v8(101.74,145.38) v8(101.74,144.57) v8(101.74,143.88) v8(102.47,21.12) v8(102.47,21.12) v8(102.55,145.38) v8(102.55,144.57) v8(102.55,143.88) v8(103.29,21.12) v8(103.29,21.12) v8(103.37,145.38) v8(103.37,144.57) v8(103.37,143.88) v8(104.1,21.12) v8(104.1,21.12) v8(104.18,145.38) v8(104.18,144.57) v8(104.18,143.88) v8(104.99,145.38) v8(104.99,144.57) v8(104.99,143.88) v8(104.91,21.12) v8(104.91,21.12) v8(105.4,147.26) v8(105.4,146.45) v8(105.4,145.64) v8(105.8,145.38) v8(105.8,144.57) v8(105.8,143.88) v8(105.73,21.12) v8(105.73,21.12) v8(106.21,147.26) v8(106.21,146.45) v8(106.21,145.64) v8(106.54,21.12) v8(106.54,21.12) v8(106.62,145.38) v8(106.62,144.57) v8(106.62,143.88) v8(107.03,147.26) v8(107.03,146.45) v8(107.03,145.64) v8(107.35,21.12) v8(107.35,21.12) v8(107.84,147.26) v8(107.84,146.45) v8(107.84,145.64) v8(108.16,21.12) v8(108.16,21.12) v8(108.65,147.26) v8(108.65,146.45) v8(108.65,145.64) v8(108.98,21.12) v8(108.98,21.12) v8(109.79,21.12) v8(109.79,21.12) v8(110.6,21.12) v8(110.6,21.12) v8(111.42,21.12) v8(111.42,21.12) v8(112.23,21.12) v8(112.23,21.12) v8(113.04,21.12) v8(113.04,21.12) v8(113.85,21.12) v8(113.85,21.12) v8(114.67,21.12) v8(114.67,21.12) v8(115.48,21.12) v8(115.48,21.12) v8(116.29,21.12) v8(116.29,21.12) v8(117.1,21.12) v8(117.1,21.12) v8(117.92,21.12) v8(117.92,21.12) v8(118.73,21.12) v8(118.73,21.12) v8(119.54,21.12) v8(119.54,21.12) v8(120.36,21.12) v8(120.36,21.12) v8(121.17,21.12) v8(121.17,21.12) v8(121.98,21.12) v8(121.98,21.12) v8(122.79,21.12) v8(122.79,21.12) v8(123.61,21.12) v8(123.61,21.12) v8(124.42,21.12) v8(124.42,21.12) v8(125.23,21.12) v8(125.23,21.12) v8(126.05,21.12) v8(126.05,21.12) v8(126.86,21.12) v8(126.86,21.12) v8(127.67,21.12) v8(127.67,21.12) v8(128.48,21.12) v8(128.48,21.12) v8(129.3,21.12) v8(129.3,21.12) v8(130.11,21.12) v8(130.11,21.12) v8(130.92,21.12) v8(130.92,21.12) v8(131.74,21.12) v8(131.74,21.12) v8(132.55,21.12) v8(132.55,21.12) v8(133.36,21.12) v8(133.36,21.12) v8(134.17,21.12) v8(134.17,21.12) v8(134.99,21.12) v8(134.99,21.12) v8(135.8,21.12) v8(135.8,21.12) v8(136.61,21.12) v8(136.61,21.12) v8(137.42,21.12) v8(137.42,21.12) v8(138.24,21.12) v8(138.24,21.12) v8(139.05,21.12) v8(139.05,21.12) v8(139.86,21.12) v8(139.86,21.12) v8(140.68,21.12) v8(140.68,21.12) v8(141.49,21.12) v8(141.49,21.12) v8(142.3,21.12) v8(142.3,21.12) v8(143.11,21.12) v8(143.11,21.12) v8(143.93,21.12) v8(143.93,21.12) v8(144.74,21.12) v8(144.74,21.12) v8(145.55,21.12) v8(145.55,21.12) v8(146.37,21.12) v8(146.37,21.12) v8(147.18,21.12) v8(147.18,21.12) v8(147.99,21.12) v8(147.99,21.12) v8(148.8,21.12) v8(148.8,21.12) v8(149.62,21.12) v8(149.62,21.12) v8(150.43,21.12) v8(150.43,21.12) v8(151.24,21.12) v8(151.24,21.12) v8(152.06,21.12) v8(152.06,21.12) v8(152.87,21.12) v8(152.87,21.12) v8(153.68,21.12) v8(153.68,21.12) v8(154.49,21.12) v8(154.49,21.12) v8(155.31,21.12) v8(155.31,21.12) v8(156.12,21.12) v8(156.12,21.12) v8(156.93,21.12) v8(156.93,21.12) v8(157.74,21.12) v8(157.74,21.12) v8(158.56,21.12) v8(158.56,21.12) v8(159.37,21.12) v8(159.37,21.12) v8(160.18,21.12) v8(160.18,21.12) v8(161,21.12) v8(161,21.12) v8(161.81,21.12) v8(161.81,21.12) v8(162.62,21.12) v8(162.62,21.12) v8(163.43,21.12) v8(163.43,21.12) v8(164.25,21.12) v8(164.25,21.12) v8(165.06,21.12) v8(165.06,21.12) v8(165.87,21.12) v8(165.87,21.12) v8(166.69,21.12) v8(166.69,21.12) v8(167.5,21.12) v8(167.5,21.12) v8(168.31,21.12) v8(168.31,21.12) v8(169.12,21.12) v8(169.12,21.12) v8(169.94,21.12) v8(169.94,21.12) v8(170.75,21.12) v8(170.75,21.12) v8(171.56,21.12) v8(171.56,21.12) v8(184.9,118.14) v8(184.9,117.33) v8(184.9,116.52) v8(184.9,115.71) v8(184.9,114.89) v8(184.9,114.08) v8(184.9,113.27) v8(184.9,112.45) v8(184.9,111.64) v8(184.9,110.83) v8(185.72,118.14) v8(185.72,117.33) v8(185.72,116.52) v8(185.72,115.71) v8(185.72,114.89) v8(185.72,114.08) v8(185.72,113.27) v8(185.72,112.45) v8(185.72,111.64) v8(185.72,110.83) v8(186.53,118.14) v8(186.53,117.33) v8(186.53,116.52) v8(186.53,115.71) v8(186.53,114.89) v8(186.53,114.08) v8(186.53,113.27) v8(186.53,112.45) v8(186.53,111.64) v8(186.53,110.83) v8(187.34,118.14) v8(187.34,117.33) v8(187.34,116.52) v8(187.34,115.71) v8(187.34,114.89) v8(187.34,114.08) v8(187.34,113.27) v8(187.34,112.45) v8(187.34,111.64) v8(187.34,110.83) v8(188.15,118.14) v8(188.15,117.33) v8(188.15,116.52) v8(188.15,115.71) v8(188.15,114.89) v8(188.15,114.08) v8(188.15,113.27) v8(188.15,112.45) v8(188.15,111.64) v8(188.15,110.83) v8(266.97,25.34) v8(266.97,24.53) v8(266.97,23.71) v8(266.97,22.9) v8(266.97,22.09) v8(266.97,21.28) v8(266.97,19.65) v8(266.97,18.02) v8(266.97,17.21) v8(266.97,16.4) v8(266.97,15.59) v8(267.78,25.34) v8(267.78,24.53) v8(267.78,23.71) v8(267.78,22.9) v8(267.78,22.09) v8(267.78,21.28) v8(267.78,20.46) v8(267.78,19.65) v8(267.78,18.84) v8(267.78,18.02) v8(267.78,17.21) v8(267.78,16.4) v8(267.78,15.59) v8(268.59,25.34) v8(268.59,24.53) v8(268.59,23.71) v8(268.59,22.9) v8(268.59,22.09) v8(268.59,21.28) v8(268.59,20.46) v8(268.59,19.65) v8(268.59,18.84) v8(268.59,18.02) v8(268.59,17.21) v8(268.59,16.4) v8(268.59,15.59) v8(269.41,25.34) v8(269.41,24.53) v8(269.41,23.71) v8(269.41,22.9) v8(269.41,22.09) v8(269.41,21.28) v8(269.41,20.46) v8(269.41,19.65) v8(269.41,18.84) v8(269.41,18.02) v8(269.41,17.21) v8(269.41,16.4) v8(269.41,15.59) v8(270.22,25.34) v8(270.22,24.53) v8(270.22,23.71) v8(270.22,22.9) v8(270.22,22.09) v8(270.22,21.28) v8(270.22,20.46) v8(270.22,19.65) v8(270.22,18.84) v8(270.22,18.02) v8(270.22,17.21) v8(270.22,16.4) v8(270.22,15.59) v8(271.03,24.53) v8(271.03,23.71) v8(271.03,22.9) v8(271.03,22.09) v8(271.03,21.28) v8(271.03,20.46) v8(271.03,19.65) v8(271.03,18.84) v8(271.03,18.02) v8(271.03,17.21) v8(271.03,16.4) v8(271.84,24.53) v8(271.84,23.71) v8(271.84,22.9) v8(271.84,22.09) v8(271.84,21.28) v8(271.84,20.46) v8(271.84,19.65) v8(271.84,18.84) v8(271.84,18.02) v8(271.84,17.21) v8(271.84,16.4) v8(272.66,25.34) v8(272.66,24.53) v8(272.66,23.71) v8(272.66,22.9) v8(272.66,22.09) v8(272.66,21.28) v8(272.66,20.46) v8(272.66,19.65) v8(272.66,18.84) v8(272.66,18.02) v8(272.66,17.21) v8(272.66,16.4) v8(272.66,15.59)
