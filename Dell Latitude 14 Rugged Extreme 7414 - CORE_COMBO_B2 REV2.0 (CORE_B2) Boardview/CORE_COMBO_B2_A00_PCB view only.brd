# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_ALW_DSW: length 163.9
  TOP w0.254: 160.7,81.64 161.05,81.29 161.65,81.29 162.42,80.52 162.42,78.7 v1(161.55,77.84) 161.1,77.84 160.03,78.91 JAPS1.3 ; 160.7,81.64 160.84,81.78 160.84,82.4 161.45,83.01 162.38,83.01 167.7,88.33 167.7,95.18 169.12,96.6 169.12,99.06 166.75,101.43 166.75,102.68 165.82,103.61 165.72,103.61 164.8,104.54 164.5,104.54 ; 160.7,81.64 159.97,80.91 JAPS1.7 ; v2(134.3,74.54) 134.3,75.08 RC618.2 135.18,75.05 137.35,75.05 137.91,74.49 v1(137.91,73.95) ; 164.5,104.54 164.48,104.54 162.77,102.83 162.77,101.69 163.95,100.52 163.95,99.38 163.36,98.79 159.9,98.79 158.35,97.24 157.22,97.24 C9655.1 C9654.1 155.76,97.21 155.76,98.29 156.35,98.87 RC443.2 ; 164.5,104.54 164.55,104.59 164.55,106.9 163.42,108.03 v1(162.81,108.03) ; v1(140.65,120.36) 140.65,122.36 140.22,122.8 140.22,122.8 139.71,123.31 R176.1
  IN1 w0.203: v3(128.66,87.64) 128.65,87.71 128.23,88.13 126.97,88.13 126.1,89 126.1,89.59 126.67,90.16 127.28,90.16 v3(128.09,90.97)
  IN1 w0.254: v1(140.65,120.36) 140.65,119.32 141.44,118.53 152.96,118.53 159.62,111.87 159.62,108.8 161.05,107.38 162.17,107.38 v1(162.81,108.03)
  IN1 w0.508: v1(161.55,77.84) 161.9,77.5 161.9,76.05 160.06,74.21 v1(160.06,73.52)
  IN2 w0.508: v1(137.91,73.95) 137.91,73.22 138.62,72.51 144.56,72.51 145.81,73.75 148.59,73.75 149.25,74.41 152,74.41 152.89,73.52 v1(160.06,73.52)
  IN4 w0.203: v3(128.66,87.64) 128.65,87.53 128.26,87.14 128.26,86.84 128.76,86.33 128.76,82.11 132.78,78.09 135.08,78.09 136.42,76.75 136.42,75.44 v1(137.91,73.95)
  BOTTOM w0.203: UC1.AJ17 128.42,87.88 v3(128.66,87.64)
  BOTTOM w0.254: UC1.AD17 128.09,90.89 v3(128.09,90.97) 127.77,90.65 UC1.AD18 ; RP4808.4 136.49,74.24 136.46,74.21 ; 136.96,74.18 136.99,74.2 RP4808.6 ; R9536.1 135.37,74.73 135.44,74.8 RP4808.2 135.89,74.19 135.86,74.17 ; 137.57,74.25 137.57,74.78 RP4808.8 ; C9958.1 138.63,74.73 138.24,74.34 138.24,74.28 v1(137.91,73.95)
+3.3V_ALW_PCH: length 629.3
  TOP w0.203: v1(145.22,89.52) 145.22,89.53 144.78,89.98 140.5,89.98 139.76,90.72 137.3,90.72 RC428.1 136.13,91.2 RC425.1 RC426.1 ; v3(127.44,93.49) 127.13,93.17 C9637.1 126.67,92.24 125.93,92.24 C9634.1 125.72,91.54 125.72,89.32 125.72,89.17 125.44,88.89 125.44,88.27 125.31,88.14 v3(125.31,87.87) 125.31,87.82 125.94,87.19 128.81,87.19 129.44,87.81 129.44,88.4 RC445.1 130.14,88.53 RC424.1
  TOP w0.254: RC400.1 185.76,122.34 188.86,122.34 189.37,121.83 189.37,120.66 188.83,120.13 v1(186.85,120.13) ; UC3.5 153.59,81.92 153.35,82.16 v1(153.35,82.16) ; v1(138.49,68.44) 138.49,68.7 138.1,69.09 134.67,69.09 134.54,69.22 131.67,69.22 131.38,68.92 131.38,68.4 RC433.1 ; JAPS1.1 159.76,77.91 159.89,77.78 v1(159.89,77.27) ; 158.91,87.08 160.34,87.08 160.59,86.83 v1(160.59,85.84) ; 158.91,87.08 158.84,87.08 158.68,86.93 158.68,85.21 158.43,84.95 R9560.1 157.08,85.59 156.27,85.59 155.61,86.25 v1(155.61,86.35) ; 158.91,87.08 158.25,87.75 RC471.1 ; v1(144.96,95.03) 145.3,94.69 148.62,94.69 148.96,95.03 149.99,95.03 150.43,94.6 v1(150.43,94.55) ; RC429.1 RC610.2 v1(153.48,89.14) ; RP10.2 131.67,111.8 ; v1(271.71,36.06) 270.57,36.06 270.06,36.56 R9675.2 ; v1(132.19,112.28) 132.27,112.2 RP10.4 ; RP10.6 132.77,111.77 ; v1(137.12,70.63) 135.36,70.63 134.25,71.74 133.64,71.74 RC488.2 RC70.2 132.17,71.77 132.57,72.17 RC98.2 ; v1(153.48,86.48) 153.1,86.86 R9562.1 ; RP10.8 133.37,111.8
  TOP w0.508: RC427.1 139.51,98.08 141.62,98.08 142.14,97.56 142.77,97.56 143.04,97.83 ; 143.04,97.83 143.53,97.35 143.53,96.46 v1(144.96,95.03) ; 143.04,97.83 143.04,99.6 141.29,101.36 141.29,103.6 140.89,104 v3(140.68,104)
  TOP w0.762: v4(187.67,103.57) 187.67,103.32 184.14,99.78 v4(182.97,99.78)
  IN1 w0.254: v4(187.67,103.57) 188.33,102.91 188.33,94.73 189.32,93.74 v1(189.37,93.74) ; v1(145.22,89.52) 145.22,89.73 147.09,91.59 147.09,92.02 148.79,93.73 149.4,93.73 149.79,93.33 v1(149.79,93.1) 150.43,93.74 v1(150.43,94.55) ; v1(137.12,70.63) 137.12,70.19 138.49,68.82 v1(138.49,68.44) 138.93,68.44 141.75,65.62 143.06,65.62 143.88,66.43 146.54,66.43 148.22,68.11 155.63,68.11 157.4,69.87 157.4,73.19 159.4,75.19 159.4,76.83 159.84,77.27 v1(159.89,77.27) ; v1(153.48,89.14) 152.97,88.63 152.97,86.98 v1(153.48,86.48) 153,85.99 153,82.28 153.12,82.16 v1(153.35,82.16)
  IN1 w0.508: v1(191.37,151.09) 196.91,145.56 200.32,145.56 200.8,146.04 v1(201.86,146.04) ; v1(146.97,114.03) 146.97,114.04 146.79,114.04 146.62,113.87 146.62,111.65 145.58,110.61 v1(141.31,110.61) 138.87,110.61 136.1,107.84 v1(136.1,107.18)
  IN2 w0.254: v1(192.7,69.98) 192.7,69.87 193.4,69.18 194.48,69.18 196.25,67.41 196.25,65.88 196.09,65.71 196.09,64.69 197.37,63.41 200.21,63.41 200.65,63.84 206.16,63.84 207.31,65 213.56,65 218.14,69.57 239.6,69.57 240.2,68.97 242.32,68.97 242.76,69.41 v1(242.76,69.46)
  IN2 w0.508: v1(132.19,112.28) 131.51,112.97 131.51,114.13 130.84,114.8 129.5,114.8 126.43,117.87 121.6,117.87 120.13,119.34 103.95,119.34 102.07,117.46 102.07,116.77 100.73,115.43 99.94,115.43 99.55,115.05 99.55,113.2 98.61,112.26 89.77,112.26 88.71,111.19 88.25,111.19 85.58,108.52 84.26,108.52 83.58,109.21 83.58,109.46 82.51,110.53 80.66,110.53 80.07,111.11 80.07,112.03 79.94,112.15 79.94,113.91 80.22,114.19 80.22,115.91 82.41,118.1 82.41,122.24 81.6,123.05 81.6,124.98 81.18,125.4 v1(81.18,126.38) ; v1(134.17,112.29) 134.82,112.94 137.22,112.94 138.78,114.49 142.2,114.49 143.14,115.43 145.57,115.43 v1(146.97,114.03) 146.97,111.32 147.26,111.03 148.9,111.03 149.26,111.39 151.08,111.39 151.43,111.04 154.77,111.04 156.12,109.69 158.99,109.69 161.36,107.32 164.26,107.32 165.13,106.44 168.86,106.44 170.42,104.88 177.01,104.88 178.75,103.14 180.26,103.14 181.81,101.59 181.81,100.94 v4(182.97,99.78) ; v1(136.1,107.18) 136.74,106.54 138.14,106.54 v3(140.68,104)
  IN2 w0.762: v4(190.69,114.8) 189.16,114.8 186.85,117.11 v1(186.85,120.13) 188.66,121.93 188.66,128.84 190.16,130.34 190.16,134.96 190.79,135.6 190.79,138.44 193.61,141.26 193.61,141.42 ; v4(201.86,145.28) 198.66,142.08 196.99,142.08 196.25,141.34
  IN3 w0.254: v1(144.96,95.03) 144.26,95.03 v1(142.81,93.59) ; v1(153.48,89.14) 152.21,90.41 152.21,92.22 151.32,93.1 v1(149.79,93.1)
  IN3 w0.508: v1(186.85,120.13) 186.85,120.17 186.38,120.64 184.85,120.64 183.2,118.99 181.9,118.99 181.32,119.57 161.4,119.57 v1(160.31,120.66)
  IN4 w0.254: v1(189.37,93.74) 189.65,93.74 189.95,93.43 189.95,91.05 191.3,89.7 191.3,86.4 189.65,84.75 189.65,73.04 v1(192.7,69.98) ; v1(144.96,95.03) 144.63,95.37 133.46,95.37 133.15,95.68 131.2,95.68 130.85,95.34 129.3,95.34 129,95.63 127.89,95.63 127.44,95.18 v3(127.44,93.49)
  IN4 w0.508: v1(134.17,112.29) 134.16,112.28 v1(132.19,112.28)
  BOTTOM w0.152: v1(145.22,89.52) 144.79,89.95 143.98,89.95 143.9,89.88 142.58,89.88 RC609.2
  BOTTOM w0.203: UC1.AJ21 125.64,87.87 v3(125.31,87.87)
  BOTTOM w0.254: v3(127.44,93.49) 127.43,93.49 127.12,93.18 UC1.V19 ; RC461.1 v1(153.48,86.48) 154.42,86.48 RC460.1 ; RC37.2 RC347.2 149.67,95.82 150.05,95.44 RC622.2 150.96,95.17 150.56,94.76 150.56,94.76 150.43,94.63 v1(150.43,94.55) ; RC608.2 153.22,82.03 153.35,82.16 ; RC343.2 153.86,80.84 153.86,81.65 153.35,82.16 ; v1(271.71,36.06) 270.85,36.92 270.85,42.38 269.03,44.2 269.03,49 272.43,52.39 272.43,58.82 267.02,64.22 252.28,64.22 252.13,64.07 245.96,64.07 243.27,66.76 243.27,68.62 242.76,69.13 v1(242.76,69.46) ; v1(160.59,85.84) 160.59,84.49 160.9,84.18 160.9,83.67 162.14,82.43 162.14,78.93 161.56,78.35 160.89,78.35 159.89,77.35 v1(159.89,77.27) ; v1(153.48,89.14) 153.15,89.14 RC408.2 ; RC460.1 154.75,85.54 154.75,83.6 R9563.1 ; RC460.1 155.56,86.35 v1(155.61,86.35) ; RC481.2 134.99,111.44 134.17,112.26 v1(134.17,112.29) ; 153.35,82.16 v1(153.35,82.16) ; RC467.2 141.49,110.43 v1(141.31,110.61) ; RC186.2 RC192.2 RC350.2 142.73,93.51 v1(142.81,93.59) ; RC30.2 RC28.2 v1(144.96,95.03) ; v1(149.79,93.1) 149.79,93.18 149.39,93.59 148.5,93.59 RC36.2
  BOTTOM w0.406: RC133.2 v1(81.18,126.38)
  BOTTOM w0.457: v1(191.37,151.09) 191.37,150.71 RC342.2 ; v1(160.31,120.66) 160.87,120.66 161.15,120.94 R9571.1
  BOTTOM w0.762: v4(190.69,114.8) 189.95,114.06 189.95,112.48 190.89,111.54 190.89,108.34 190.41,107.86 189.85,107.86 189.16,107.18 v2(189.16,105.55) 189.16,104.79 187.95,103.57 v4(187.67,103.57)
+3.3V_ALW_U38: length 93.3
  TOP w0.254: C356.1 226.49,59.63 226.81,59.63 227.56,58.88 U38.A52 ; R461.1 221.55,60.08 v1(221.55,60.31) ; 240.73,65.01 240.45,65.29 v1(240.45,65.77) ; v1(230.72,50.41) 230.13,49.82 230.13,49.28 C354.1 ; R336.1 245.32,52.08 v1(245.55,52.08) ; v1(230.85,52.82) 230.87,52.82 231,52.69 U38.B3
  TOP w0.279: U38.B35 238.69,61.91 240.17,61.91 240.47,62.22 240.47,62.85 v1(240.6,62.98) ; U38.A26 240.91,57.38 C351.1 ; U38.A11 235.25,50.12 235.67,49.7 236.18,49.7 237.12,48.76 237.82,48.76 238.05,48.53 238.42,48.53 v1(238.44,48.5) 238.44,48.45 239.03,47.87 240.36,47.87 C355.1 ; U38.A41 233.75,63.18 C349.1 232.54,63.95 232.41,64.07 232.41,65.46 232.59,65.63 v1(232.94,65.63)
  TOP w0.508: C351.1 v1(241.55,58.71) ; v1(226.43,60.39) 226.3,60.52 225.75,60.52 C356.1
  IN1 w0.254: v1(230.72,50.41) 231.62,49.51 237.44,49.51 v1(238.44,48.5) ; v1(221.55,60.31) 221.68,60.19 226.22,60.19 v1(226.43,60.39)
  IN2 w0.254: v1(232.94,65.63) 233.65,64.92 240.09,64.92 240.45,65.28 v1(240.45,65.77) ; v1(230.85,52.82) 230.72,52.69 v1(230.72,50.41)
  IN2 w0.508: v1(240.6,62.98) 240.6,62.37 ; 240.6,62.37 241.55,61.42 v1(241.55,58.71) ; 240.6,62.37 240.04,61.81 239.36,61.81 239.17,61.62 228.37,61.62 228.07,61.92 227.23,61.92 226.43,61.12 v1(226.43,60.39)
  IN3 w0.254: v1(245.55,52.08) 244.84,51.37 244.84,50.28 244.48,49.92 243.82,49.92 242.43,48.53 241.22,48.53 240.76,48.98 238.92,48.98 v1(238.44,48.5)
  BOTTOM w0.254: v1(245.55,52.08) 245.4,52.08 244.89,52.59 244.89,52.76 v2(244.56,53.09) 243.77,53.88 243.77,58.54 243.52,58.79 243.05,58.79 242.64,59.2 242.03,59.2 v1(241.55,58.71)
+3.3V_ALWP: length 2.7
  TOP w0.508: 200.75,57.44 200.75,59.09 201.34,59.68 v2(201.53,59.68)
+3.3V_CAM: length 2.5
  BOTTOM w0.254: JEDP1.42 37.03,100.76 v1(36.82,100.55) 36.53,100.83 JEDP1.43
  vias: v2(36.71,101.33)
+3.3V_CAM_C: length 1.9
  BOTTOM w0.406: JRCAM1.2 v1(205.51,149.04) ; JRCAM1.1 204.91,149.11 v1(204.84,149.04)
  vias: v2(206.79,149.92)
+3.3V_CAM_Q: length 4.9
  TOP w0.508: Q216.3 35.08,106.49 35.41,106.16 PJP803.2 33.64,104.92 v2(33.36,105.19)
+3.3V_CAM_QC:
  vias: v2(208.81,146.75)
+3.3V_FPM: length 39.3
  TOP w0.432: v1(167.19,34.23) 166.33,35.09 R9694.1
  TOP w0.508: 185.3,25.69 184.67,26.33 181.16,26.33 179.18,28.31 177.61,28.31 v2(177.15,28.77) 176.11,29.81 v1(176.11,30.04)
  IN2 w0.508: v1(176.11,30.04) 174.1,30.04 173.57,29.5 170.44,29.5 v1(169.78,28.84)
  IN4 w0.508: v1(167.19,34.23) 166.66,34.76 164.65,34.76 162.9,33.01 160.89,33.01 160.49,32.6 160.49,31.84 161.1,31.23 165.59,31.23 167.98,28.84 v1(169.78,28.84)
+3.3V_FPM_EN: length 20.1
  TOP w0.254: v1(181.93,22.26) 182.05,22.26 182.43,22.64 182.43,24.55 182.6,24.71 PU7402.3 ; PU7401.6 195.14,23.39 195.36,23.61 PR7405.1 195.69,23.2 v1(195.41,22.92)
  IN3 w0.254: v1(181.93,22.26) 182.51,22.26 184.44,24.19 194.14,24.19 v1(195.41,22.92)
+3.3V_FPM_FB: length 3
  TOP w0.254: PU7401.8 193.92,24.69 193.44,24.21 v1(193.44,23.1)
  BOTTOM w0.254: v1(193.44,23.1) 193.47,23.13 PR7403.2
+3.3V_FPM_VIN: length 1.2
  TOP w0.254: PC7407.2 v2(186.14,26.3)
+3.3V_HDA: length 4.1
  TOP w0.203: RC445.2 128.23,88.05 127.31,88.05 127.18,88.18 127.18,88.35 C9960.1 126.8,88.58 126.6,88.39 126.6,87.81 v3(126.79,87.62)
  BOTTOM w0.254: UC1.AJ19 126.79,87.73 v3(126.79,87.62)
+3.3V_HDD: length 110.1
  TOP w0.254: RN4130.1 RN4142.1 RN4131.1 RN4129.1 RN4128.1 ; v1(164.65,64.12) 164.6,64.17 C9555.1 163.6,64.29 163.16,64.73 163.13,64.73 161.91,64.73 160.95,63.77 RN4136.1 RN4137.1 RN4143.1 RN4138.1 RN4144.1 161.45,59.04 162.57,59.04 v1(163.09,58.52)
  TOP w0.381: 166.2,52.57 167.65,51.12 167.65,48.93 168.24,48.35 C9553.1 169.78,48.35 v1(169.96,48.17) 169.91,48.17 169.77,48.03 169.76,48.03 169.56,47.83 169.42,47.83 169.08,47.49 169.07,46.83 170.09,45.81 172.25,45.81 173.72,47.28 RN4109.1 RN4122.1 ; 166.2,52.57 v1(164.53,52.57) 164.53,52.95 164.27,53.2 C9552.1 163.68,52.73 163.51,52.57 161.53,52.57 160.92,51.96 RN4115.1 RN4116.1 RN4123.1 RN4117.1 RN4124.1 160.34,47.54 160.34,47 156.27,42.94 155.23,42.94 ; 166.2,52.57 168.08,54.45 172.02,54.45 172.2,54.27 ; RN4130.1 173.72,58.26 172.2,56.73 ; 172.2,54.27 173.06,53.4 173.34,53.4 173.72,53.02 RN25.1 RN4108.1 RN4110.1 ; 172.2,54.27 172.2,56.73 ; C9555.1 164.3,64.87 165.28,64.87 168.01,62.14 C9554.1 168.57,61.53 169.17,60.92 169.17,59.98 v1(169.23,59.93) 169.15,59.86 169.1,59.86 168.57,59.32 168.57,58.38 169.56,57.39 171.54,57.39 172.2,56.73
  IN2 w0.254: v1(163.09,58.52) 162.32,59.3 158.2,59.3 158.02,59.12 152.63,59.12 v1(152.59,59.08)
  BOTTOM w0.254: v1(169.23,59.93) 169.15,60 U6206.12 ; v1(164.65,64.12) 165.45,63.32 U6206.24 ; U6205.24 165.47,52.13 165.03,52.57 v1(164.53,52.57) ; R124.1 152.84,59.37 152.59,59.12 v1(152.59,59.08) ; U6205.12 169.31,48.9 169.96,48.25 v1(169.96,48.17)
  BOTTOM w0.508: v1(164.65,64.12) 164.4,64.38 v2(164.4,65.14)
  BOTTOM w2.286: 151.95,46.32 151.95,48.63 153.5,50.18 153.5,55.39
  vias: v4(152.33,44.23) v4(152.89,43.55)
+3.3V_LAN: length 197.6
  TOP w0.203: R178.2 140.92,127.97 139.32,127.97 v1(139.2,127.85) ; R713.2 139.39,124.46 v1(139.39,124.82)
  TOP w0.254: R172.1 143.11,138.01 143.06,138.06 v1(143.06,138.07) ; v1(160.67,94.62) 161.28,95.24 166.81,95.24 168.74,97.17 168.74,98.9 166.36,101.29 166.36,102.54 165.66,103.23 165.24,103.23 v1(164.93,103.54) ; v1(143.9,138.07) 144.13,137.84 R171.1
  TOP w0.356: C198.2 161.82,138.63 160.94,137.76 U24.5 160.49,137.76 160.21,138.04 160.21,138.58 v1(160.46,138.84)
  TOP w0.508: C198.2 163.83,138.63 165.38,140.18 JLAN1.A2 ; C426.1 183.89,136.45 183.75,136.31 C9923.1 179.97,136.31 178.93,137.35 178.3,137.35 JLAN1.B1 ; C426.1 v1(184.47,137.66) ; C426.1 184.98,136.96 U22.3
  IN1 w0.254: v1(150.16,127.47) 153.72,127.47 157.67,123.52 157.67,118.94 165.5,111.1 165.5,108.66 164.93,108.09 v1(164.93,103.54) ; v1(139.39,124.82) 139.39,125.98 139.76,126.35 139.76,127.62 139.53,127.85 v1(139.2,127.85)
  IN1 w0.762: v1(155.05,132.78) 155.58,133.31 155.58,135.44 158.98,138.84 v1(160.46,138.84) 161.1,138.2 161.1,136.64 159.7,135.24 159.7,131.37 161.04,130.03 161.04,128.44 v1(161.22,128.26)
  IN2 w0.254: v1(139.2,127.85) 140.05,128.7 148.93,128.7 v1(150.16,127.47) ; v1(160.67,94.62) 156,94.62 155.85,94.77 152.5,94.77 151.57,93.84 149.41,93.84 149.16,93.59 v1(149.16,93.1)
  IN2 w0.508: v1(184.47,137.66) 185.64,136.48 185.64,135.71 186.21,135.14 186.21,134.12 185.99,133.9 185.99,125.81 182.24,122.06 178.6,122.06 177.82,121.29 177.82,120.98 177.35,120.51 167.14,120.51 165.74,121.91 163.39,121.91 161.83,123.47 161.83,124.6 161.22,125.2 v1(161.22,128.26) ; v1(143.06,138.07) v1(143.9,138.07) 144.25,138.42 150.59,138.42 151.48,139.31 156.14,139.31 157.29,138.16 159.79,138.16 v1(160.46,138.84)
  IN3 w0.508: v1(155.05,132.78) 150.16,127.89 v1(150.16,127.47)
  BOTTOM w0.254: RC349.2 RC348.2 148.98,92.93 v1(149.16,93.1)
  BOTTOM w0.508: v2(184.47,138.37) v1(184.47,137.66)
+3.3V_LAN_OUT: length 3.8
  TOP w0.203: U21.5 144.95,130.05 v1(144.71,130.29) 144.55,130.13 U21.4 ; v1(147.64,130.67) 147.71,130.74 U21.15
  TOP w0.254: U21.19 147.87,132.34 v1(147.64,132.58)
  vias: v1(153.86,135.24) v1(154.52,135.29) v2(147.25,129.73)
+3.3V_LCD_VDD: length 22.1
  TOP w0.254: v1(52.83,95.94) 53.17,95.6 53.17,92.52 50.53,89.88 49.73,89.88 v1(49.48,89.62)
  BOTTOM w0.254: v1(49.48,89.62) 49.48,87.38 49.69,87.16 R9683.2 50.33,86.86 52.92,86.86 53.41,87.35 U6223.3 ; 54.53,100.7 JEDP1.7 ; 55.03,100.7 JEDP1.6
  BOTTOM w0.508: 54.16,96.87 54.16,96.46 53.64,95.94 v1(52.83,95.94) 51.78,94.88 51.27,94.88 51.06,95.1 U9.6
  vias: v2(55.48,96.64)
+3.3V_M: length 244.8
  TOP w0.254: R9676.2 v1(271.71,36.78)
  TOP w0.508: v1(183.08,119.75) v2(183.08,117.74) 183.08,113.41 182.38,112.71 182.38,110.25 183.81,108.82 184.04,108.82 184.26,108.6 184.26,106.54 185.04,105.77 v1(186.9,105.77)
  IN1 w0.254: v1(187.54,95.62) 187.54,94.89 189.29,93.13 v1(189.37,93.13)
  IN1 w0.508: v1(186.9,105.77) 186.83,105.69 186.83,96.2 187.41,95.62 v1(187.54,95.62)
  IN2 w0.254: v1(192.02,69.95) 191.98,69.91 191.98,69.13 192.36,68.76 194.37,68.76 195.87,67.25 195.87,66.1 195.71,65.94 195.71,64.53 197.21,63.03 200.46,63.03 200.89,63.45 206.4,63.45 207.55,64.61 213.73,64.61 218.31,69.19 239.25,69.19 239.85,68.59 242.48,68.59 242.86,68.97 242.96,68.97 243.42,69.43 v1(243.42,69.46)
  IN2 w0.508: v1(188.05,138.8) 188.05,139.97 190.43,142.36 193.41,142.36 194.6,143.55 197.75,143.55 v1(198.18,143.12)
  IN3 w0.508: v1(188.05,138.8) 188.05,137.96 186.5,136.41 186.5,134.23 185.99,133.72 185.99,127.17 186.36,126.8 186.36,124.18 185.99,123.81 185.99,123.23 183.08,120.32 v1(183.08,119.75) 182.15,119.75 181.68,120.22 162.26,120.22 159.38,123.1 158.23,123.1 v1(158.2,123.08) ; v1(187.54,95.62) 184.24,95.62 183.28,96.57 v1(182.88,96.57)
  IN4 w0.254: v1(189.37,93.13) 189.19,93.13 188.91,92.85 188.91,91.53 190.92,89.52 190.92,86.58 189.27,84.93 189.27,72.71 v1(192.02,69.95)
  BOTTOM w0.254: v1(271.71,36.78) 271.23,37.26 271.23,46.24 272.81,47.82 272.81,58.98 267.18,64.61 251.08,64.61 251,64.52 246.06,64.52 243.65,66.94 243.65,69.23 v1(243.42,69.46)
  BOTTOM w0.508: R9535.1 v1(198.18,143.12) ; v1(158.2,123.08) 158.34,123.22 159.84,123.22 159.85,123.2 R9593.1
+3.3V_M_TCM: length 26.8
  TOP w0.254: R9675.1 R9676.1 v1(271.71,37.64) C9955.1 ; C9953.1 268.78,45.72 268.7,45.8 C9956.1 269.39,47.13 272.4,47.13 272.77,46.76 272.77,46.19 v1(272.29,45.71)
  TOP w0.279: C9953.1 268.36,45.28 267.78,44.69 267.78,44.25 267.48,43.95 267.48,43.46 267.68,43.27 U26.25 ; U26.20 270.57,44.31 271.41,45.15 C9954.1 272.25,45.67 v1(272.29,45.71) ; C9955.1 273.03,38.12 273.03,39.57 272.83,39.77 U26.9
  BOTTOM w0.254: v1(271.71,37.64) 271.91,37.83 271.91,40.97 v2(271.85,41.02) 271.71,41.16 271.71,45.14 v1(272.29,45.71)
+3.3V_M_TPM: length 45.5
  TOP w0.432: R9532.1 190.26,147.63 189.83,148.06 Q4199.2
  TOP w0.508: Q4199.2 188.88,148.54 v1(188.56,148.54) ; v1(184.72,144.77) 185.35,144.13 v2(185.35,143.24) 185.35,143.14 186.02,142.48 v1(187.39,142.48)
  IN2 w0.508: v1(188.56,148.54) 190.55,148.54 191.45,149.44 193.89,149.44 197.17,146.17 v1(197.8,146.17)
  IN3 w0.508: v1(191.29,140.21) 191.29,141 190.71,141.57 187.74,141.57 187.39,141.92 v1(187.39,142.48) ; v1(188.56,148.54) 188.56,147.93 185.4,144.77 v1(184.72,144.77)
  BOTTOM w0.279: U25.22 189.56,142.69 188.96,142.1 187.87,142.1 187.45,141.68 C9564.1 ; U25.14 193.09,144.78 193.61,144.26 C9566.1
  BOTTOM w0.432: 196.66,146.17 196.65,146.16 196,146.16 R9523.2 ; R9527.1 v1(184.72,144.77)
  BOTTOM w0.508: C9566.1 194.31,143.75 194.3,143.74 C9565.1 194.3,142.58 194.65,142.23 196.71,142.23 197.19,142.71 197.19,145.12 ; v1(191.29,140.21) 191.43,140.35 R9526.1 ; C9564.1 187.21,141.71 187.21,142.3 v1(187.39,142.48)
+3.3V_PGPPB: length 3.9
  TOP w0.203: v2(131.71,90.18) C9638.1 131.19,89.08 v3(131,88.89) 130.74,89.14 RC424.2
  BOTTOM w0.254: v3(131,88.89) 130.67,88.89 130.67,88.89 UC1.AG15
+3.3V_PGPPC: length 8.4
  TOP w0.203: v3(129.39,91.85) 129.78,91.47 129.78,90.22 C9639.1 130.33,90.54 130.62,90.54 130.74,90.66 130.74,91.2 130.95,91.42 134.16,91.42 134.33,91.58 RC425.2
  BOTTOM w0.254: v3(129.39,91.85) 129.39,91.92 UC1.Y16
+3.3V_PGPPD: length 5.7
  TOP w0.203: v3(130.21,91.91) 130.41,91.71 133.34,91.71 v2(133.59,91.96) 133.67,92.04 134.45,92.04 RC426.2
  BOTTOM w0.254: v3(130.21,91.91) 130.2,91.92 130.04,91.92 UC1.Y15
+3.3V_PGPPE: length 12.4
  TOP w0.254: RC427.2 137.98,98.29 137.54,97.84 C9640.1 136.66,96.39 v2(136.38,96.39) 135.62,95.63 135.62,95.31 135.04,94.73 130.15,94.73 129.88,94.46 129.88,93.98 129.4,93.5 v3(129.4,93.49)
  BOTTOM w0.254: v3(129.4,93.49) 129.4,93.59 UC1.T16
+3.3V_RTC_LDO: length 213.7
  TOP w0.508: v1(78.29,25.41) 76.88,25.41 76.52,25.77 76.52,26.62 75.67,27.47 75.05,27.47 74.6,27.92 RTCD1.2
  IN2 w0.457: v1(217.36,66.41) 216.22,66.41 213.91,64.1 207.82,64.1 206.67,62.95 201.19,62.95 200.58,62.35 197.17,62.35 196.76,61.94 195.92,61.94 193.1,64.76 193.1,65.7 192.52,66.28 191.04,66.28 v1(189.95,67.37)
  IN2 w0.508: v1(202.27,29.33) 202.27,30.19 200.77,31.69 173.42,31.69 172.88,31.14 159.6,31.14 158.75,30.29 152.17,30.29 150.18,28.3 v1(150.18,26.91)
  IN4 w0.508: v1(78.29,25.41) 79.31,25.41 79.63,25.08 116.9,25.08 117.46,25.64 119.14,25.64 119.7,25.08 147.84,25.08 149.67,26.91 v1(150.18,26.91)
  BOTTOM w0.508: v1(202.27,29.33) 205.5,32.55 v2(205.5,33.72) 205.5,42.18 206.61,43.3 209.64,43.3 211.41,45.07 211.41,52.97 212.05,53.61 212.05,56.22 213.04,57.21 213.04,61.78 214.49,63.23 215.96,63.23 216.54,63.81 216.54,65.59 v1(217.36,66.41)
+3.3V_RTCPRIM: length 32.1
  TOP w0.254: v1(137.86,68.44) 137.64,68.66 C9642.1 C9643.1 RC433.2
  IN4 w0.254: v1(137.86,68.44) 137.86,68.92 136.38,70.4 136.38,74.84 136.05,75.17 136.05,76.57 135.04,77.59 132.65,77.59 127.88,82.35 127.88,87.42 128.03,87.57 128.03,87.61 v3(128.03,87.62)
  BOTTOM w0.203: UC1.AK17 128.42,87.24 v3(128.03,87.62)
  BOTTOM w0.254: v2(137.86,67.68) v1(137.86,68.44)
+3.3V_RUN: length 701.5
  TOP w0.254: v1(156.25,86.35) 157.34,86.35 RC472.1 ; v1(249.97,61.1) 249.95,61.08 R9421.1 ; RC621.2 178.62,49.39 179,49.01 179,45.69 178.65,45.33 174.66,45.33 173.85,44.51 173.85,44.13 v1(173.92,44.06) ; v1(260.18,40.64) 258.82,40.64 257.82,39.64 257.49,39.64 257.34,39.48 RP4804.10 ; v1(268.64,26.1) R9431.2 R3703.2 ; 19.62,122.16 19.62,121.02 20.13,120.51 QZ22.2 21.83,120.51 22.67,119.67 v2(22.67,119.32) v1(22.67,118.45) ; 19.62,122.16 18.1,122.16 17.97,122.04 v1(17.33,122.04) 17.08,122.29 16.19,122.29 15.89,121.99 R460.2 R475.2 ; 19.62,122.16 19.6,122.18 19.6,122.91 ; v1(152.59,99.89) 152.85,99.63 QC1.5 ; Q122.2 20.13,123.43 19.6,122.91 ; 153.73,92.19 153.73,92.2 RP8.6 ; 153.73,92.19 153.73,91.81 153.52,91.59 RP8.8 153.09,91.29 152.76,90.96 149.65,90.96 149.03,91.58 v1(149.03,91.68) ; 153.73,92.19 153.73,92.7 ; QC1.2 152.85,96.12 v1(152.84,96.13) ; v1(246.31,43.68) 245.98,44.01 243.06,44.01 242.83,44.23 R35.1 ; RC477.2 v1(153.48,87.75) RC478.2 ; C9450.1 257.94,31.42 258.39,31.88 U6202.26 ; v1(68.21,121.15) 68.57,120.79 68.57,120.69 PR5811.2 ; 153.73,92.7 153.73,93.17 153.6,93.3 RP8.2 ; 153.73,92.7 153.73,92.7 RP8.4 ; 19.6,122.91 19.14,122.91 18.62,123.43 Q122.5 ; R408.1 v1(245.41,56.88) ; v1(84.52,109.13) 84.52,108.33 86.24,106.6 86.24,104.64 86.65,104.23 v1(86.65,104) ; R376.1 245.3,54.98 v1(245.81,54.47) 246.04,54.24 246.04,51.14 R362.1 ; RC47.1 RC190.1 157.5,80.6 RC51.1 157.19,80.25 RC50.1 RC585.1 157.57,78.19 RC59.1 157.14,77.31 156.78,76.95 RC407.1 156.02,77.41 155.51,77.41 154.87,78.05 153.43,78.05 v1(153.4,78.07)
  TOP w0.279: C9449.1 269.17,31.87 269.16,31.88 U6202.55 ; v1(266.89,38.34) 266.56,38.34 266.33,38.11 266.33,37.48 266.22,37.37 U6202.4 ; U6202.62 269.22,35.38 270.06,34.53 C9448.1 ; U6202.33 260.22,27.48 260.09,27.36 C9445.1 ; U6202.10 263.22,38.28
  TOP w0.305: RD71.1 122.03,26.05 122.03,27.32 v1(121.8,27.55) ; v1(141.41,74.79) 140.4,74.79 140.09,75.1 138.92,75.1 138.67,75.35 ; 138.67,75.35 138.24,75.35 138.03,75.56 JDEG2.1 ; 138.67,75.35 139.03,75.71 JDEG2.3
  TOP w0.381: RD69.1 146.95,28.49 v1(146.36,29.08) 146.36,29.14 147,29.78 RC319.1 147.76,30.6 RD70.1 ; v1(103.8,115.15) 103.8,115.35 RC149.2 ; v1(102.32,113.35) 102.37,113.35 102.45,113.27 RC147.2
  TOP w0.432: R419.2 262.95,44.96 v1(262.7,44.7) ; R9403.1 v1(263.97,44.7) ; R9400.2 v1(265.75,44.69) ; R9395.2 R3702.2 ; R9589.1 v1(264.86,44.7) ; v1(253.68,44.7) R9406.1 R9404.1 ; R9461.2 v1(268.72,56.5) ; RD63.1 v1(148.78,34.79) ; RD62.1 v1(146.11,34.91)
  TOP w0.457: R9671.1 144.98,62.35 v1(145.35,62.35)
  TOP w0.508: C9437.1 261.72,41.64 261.21,41.14 v1(260.67,41.14) ; C9437.1 261.72,42.74 262.32,43.33 OCS4801.4 ; C9437.1 261.94,41.73 OCS4801.1 ; R3702.2 261.05,25.59 v1(261.3,25.34) ; v1(256.98,34.91) 257.06,34.84 R9428.2 R9429.2 R9430.2 257.06,31.6 C9450.1 ; 263.22,38.28 263.41,38.47 C3701.1 C9447.1 C9451.1 261.12,39.4 260.79,39.4 R3701.1 v1(260.18,40.64) ; RP4806.5 v1(265.97,23.36) ; v1(181.19,121.43) 181.42,121.65 C3053.1 182.97,121.65 183.72,120.9 183.72,118.49 184.57,117.64 184.57,116.47 183.83,115.74 v4(183.83,114.16) ; v1(259.88,24.75) 260.09,24.97 C9446.1 C9445.1 ; v1(211.25,140.77) 211.25,140.78 211.45,140.98 211.45,141.47 ; v1(173.92,44.06) 173.92,43.75 174.46,43.22 181.86,43.22 v1(187.19,48.55) ; C9449.1 270.13,32.31 270.44,32.63 v1(271.21,32.63) ; v1(41.34,100.45) 41.34,100.65 40.65,101.33 ; C9911.1 C9512.1 40.65,101.33 ; v1(254.06,41.34) 254.29,41.34 254.6,41.03 RP4804.5 ; 40.65,101.33 38.23,101.33 C64.1 38.23,101.65 38.64,102.07 38.64,104.06 38.54,104.17 38.54,108 38.03,108.51 Q216.2 36.83,109.31 C440.1 37.67,109.84 37.92,110.09 v1(37.92,110.61) ; C3603.1 211.45,141.47 ; 211.45,141.47 Q3601.2 ; v1(263.23,25.54) 263.23,25.54 RP4806.10 ; R9427.2 v1(261.43,23.43) ; v1(126.3,36.92) 125.79,37.43 RD64.1 ; C9448.1 270.25,33.71 270.52,33.44 v1(271.21,33.44) ; v1(238.69,63.28) 238.97,63.28 239.2,63.51 R360.1 ; 144.21,37.63 144.21,36.95 143.95,36.69 v1(142.63,36.69)
  IN1 w0.254: v1(141.41,74.79) 141.41,75.2 143.44,77.23 148.5,77.23 149.46,78.19 153.28,78.19 v1(153.4,78.07)
  IN1 w0.508: v1(41.08,110.58) 40.45,111.21 38.52,111.21 v1(37.92,110.61) ; v1(81.84,115.41) 81.84,115.81 81.09,116.56 77.64,116.56 76.1,118.1 68.37,118.1 v1(67.35,117.08)
  IN1 w1.016: v4(183.83,114.16) 182.57,112.9 182.57,111.13 183.98,109.72 183.98,108.12
  IN2 w0.508: v1(161.2,33.77) 160.51,33.77 158.67,31.93 151.64,31.93 v1(148.78,34.79) 148.04,34.05 146.76,34.05 146.11,34.7 v1(146.11,34.91) 145.63,34.43 144.53,34.43 142.63,36.33 v1(142.63,36.69) 141.62,37.7 127.08,37.7 v1(126.3,36.92) ; v1(88.83,117.34) 88.83,116.96 88.38,116.5 86.8,116.5 86.24,115.94 85.15,115.94 83.91,114.69 v1(83.91,113.17) 83.91,112.59 84.52,111.98 v1(84.52,109.13) ; v1(143.81,29.24) 144.05,28.99 146.28,28.99 v1(146.36,29.08) ; v1(37.92,110.61) 37.34,111.19 27.51,111.19 22.34,116.36 22.34,118.12 v1(22.67,118.45) ; v1(181.19,121.43) 182.64,121.43 187.4,126.19 187.4,134.88 186.37,135.9 186.37,138.85 185.84,139.38 185.84,146.65 v1(185.3,147.18) 186.02,147.89 194.04,147.89 194.68,147.26 v1(194.68,146.34) 195.97,146.34 197.09,145.23 200.04,145.23 204.51,149.7 209.23,149.7 211.25,147.68 v1(211.25,140.77) ; v1(126.43,140.78) 126.43,140.45 126.05,140.07 126.05,139.44 126.97,138.52 134.43,138.52 143.27,129.68 153.98,129.68 158.79,124.86 158.79,124.84 159.87,123.76 159.89,123.76 159.91,123.74 159.91,122.67 162.59,119.99 164.95,119.99 166.53,118.41 170.09,118.41 170.62,117.88 173.8,117.88 174.48,118.56 180.49,118.56 182.64,116.4 182.66,116.4 183.83,115.23 v4(183.83,114.16) ; v1(102.32,113.35) 102.59,113.62 102.59,115.69 103.08,116.18 103.08,117.04 104.37,118.33 119.67,118.33 121.19,116.8 125.8,116.8 129.3,113.31 129.3,111.54 130.18,110.66 131.02,110.66 131.66,111.29 132.6,111.29 133.31,112 133.31,112.92 133.92,113.53 v1(133.92,114.16) ; v1(51.42,114.42) 51.42,114.85 52.39,115.82 53.17,115.82 53.32,115.96 58.17,115.96 58.9,115.23 60.85,115.23 61.53,115.91 v1(61.53,116.45)
  IN3 w0.254: v1(153.48,87.75) 152.84,87.75 149.03,91.55 v1(149.03,91.68)
  IN3 w0.508: v1(183.65,108.21) 183.68,108.24 183.68,108.95 182.84,109.79 176.77,109.79 174.03,112.54 172.81,112.54 171.77,111.49 171.77,111.1 165.65,104.99 164.45,104.99 162.19,102.73 v1(162.19,101.99) ; v1(146.11,34.91) 146.11,29.33 v1(146.36,29.08) ; 99.32,115.18 99.83,115.69 101.43,115.69 102.56,114.56 102.56,113.58 v1(102.32,113.35) ; 96.61,114.92 93.71,114.92 91.83,116.8 89.37,116.8 v1(88.83,117.34)
  IN4 w0.305: v1(143.81,29.24) 125.5,29.24 125.16,29.58 123.2,29.58 121.8,28.18 v1(121.8,27.55)
  BOTTOM w0.203: RC137.2 RC193.2 149.72,91.17 RC468.2
  BOTTOM w0.254: v1(103.8,115.15) 103.03,115.15 102.56,114.67 102.56,113.58 v1(102.32,113.35) ; R9677.1 R9678.1 87.03,104.38 v1(86.65,104) ; v1(198.28,50.05) 198.82,49.52 198.82,48.86 198.53,48.58 197.29,48.58 195.63,46.92 195.63,45.91 194.68,44.96 R2672.1 ; v1(153.5,84.52) 153.86,84.52 RC140.2 ; v1(153.5,84.52) 153.36,84.66 RP9.8 ; v1(153.5,84.52) 153.5,84.51 153.5,84.03 ; 153.5,83.56 153.5,83.56 153.5,84.03 ; 153.5,83.56 RP9.4 ; 153.5,83.56 153.5,83.11 153.35,82.96 RP9.2 ; JEDP1.33 41.53,100.64 v1(41.34,100.45) ; RC462.1 v1(153.48,85.59) ; RC314.2 RC466.2 RC11.2 ; RC314.2 RC346.2 140.8,110 140.8,110.83 141.13,111.16 141.13,112.71 141.3,112.88 141.41,112.88 ; RC314.2 139.71,110.15 RC353.2 ; RC479.2 155.69,95.55 155.51,95.37 154.32,95.37 154.06,95.62 153.35,95.62 v1(152.84,96.13) ; RC620.1 143.37,110.73 143.37,111.93 142.41,112.88 141.41,112.88 ; 141.41,112.88 141.13,113.16 141.13,113.83 140.88,114.08 140.5,114.08 140.17,113.75 140.17,113.45 139.99,113.27 RC228.2 139.58,113.27 139.28,113.58 139.28,113.63 139.2,113.7 139.2,114.08 138.69,114.59 137.74,114.59 137.35,114.98 137.35,115.69 137.09,115.94 135.41,115.94 UC8.5 134.27,115.4 133.92,115.05 v1(133.92,114.16) 133.79,114.03 133.79,112.68 133.59,112.47 133.59,110.61 RC476.2 ; v1(156.25,86.35) 156.25,86.75 156.02,86.98 RC463.1 ; 153.5,84.03 153.13,84.03 153.1,84.06 RP9.6 ; v1(152.84,96.13) 152.69,96.28 R9679.1 R9680.1 152.69,98.4 152.33,98.76 ; v1(152.84,96.13) 152.11,96.13 151.47,95.49 151.47,95.14 150.94,94.6 150.94,92.62 150.53,92.22 149.59,92.22 149.05,91.68 v1(149.03,91.68) 148.83,91.68 RC468.2 ; v1(153.48,87.75) 153.6,87.87 RC199.1 ; R126.1 187.82,45.68 187.82,47.11 187.72,47.21 R123.1 187.47,47.74 187.19,48.01 v1(187.19,48.55) 187.65,49.01 R122.1 ; v1(153.4,78.07) 153.13,78.35 RC344.2 RC345.2 ; RC475.2 RC27.2 153.18,81.14 v1(153.34,80.99) ; v1(17.33,122.04) 18.07,121.3 18.07,120.22 18.96,119.33 18.96,118.75 18.48,118.28 R473.2
  BOTTOM w0.305: 126.7,143.1 JGFX1.21 126.7,140.98 126.5,140.78 v1(126.43,140.78) 126.43,140.85 126.2,141.08 JGFX1.23 126.2,143.22
  BOTTOM w0.432: R9534.1 v1(185.3,147.18)
  BOTTOM w0.457: v1(194.68,146.34) 194.04,146.98 R9524.2 ; RC358.2 83.91,113.75 v1(83.91,113.17)
  BOTTOM w0.508: v1(173.92,44.06) 173.92,43.45 174.27,43.1 C9207.1 174.27,41.56 173.69,40.98 JSEC1.19 ; v1(51.42,114.42) 51.42,115.2 50.84,115.79 48.25,115.79 47.41,114.95 41.59,114.95 41.08,114.44 v1(41.08,110.58) ; 61.34,114.16 CC41.1 61.34,115.99 61.53,116.18 v1(61.53,116.45) ; 126.24,143.57 126.1,143.57 123.19,146.48 C9442.1
  BOTTOM w0.762: C634.1 189.86,55.42 190.76,54.52 197.96,54.52 197.99,54.55 198.13,54.55 199.83,56.25 v4(199.83,58.4)
  vias: v1(152.39,100.47) v1(153.05,100.29) v1(180.06,100.94) v1(180.06,100.33) v1(183.65,107.59) v1(269.71,52.57) v4(161.22,36.36) v4(162.09,36.36) v4(209.12,62.05) v4(209.12,61.19) v4(209.99,62.05) v4(209.99,61.19)
+3.3V_RUN_AUDIO: length 27.9
  TOP w0.216: v1(45.25,123.71) 45.21,123.67 U17.9 ; v1(45.25,121.37) 45.14,121.27 U17.3
  TOP w0.254: R9631.2 46.29,116.82 v1(46.29,116.19) ; R9635.2 38.47,128.05 37.83,128.69 v1(37.83,129.11)
  IN1 w0.381: v1(46.82,128.36) 44.89,130.29 39.01,130.29 v1(37.83,129.11)
  IN2 w0.508: v1(46.29,116.19) 46.14,116.35 46.14,120.48 v1(45.25,121.37)
  BOTTOM w0.254: R9634.2 46.21,126.4 ; v1(37.83,129.11) 37.64,129.11 RC317.2 36.76,128.23 R9452.2
  BOTTOM w0.508: R9629.2 42.84,116.96 44.17,115.62 45.72,115.62 v1(46.29,116.19)
  vias: v2(48.12,127.24)
+3.3V_RUN_DIMM1: length 14.5
  TOP w0.508: v1(146.76,48.25) 145.86,47.35 CD24.1 144.58,47.35 144,46.77 144,42.61 143.17,41.77 v2(143.17,40.32) 143.17,39.2 CD25.1 RC318.2
  BOTTOM w0.305: JDIMM1.255 v1(146.76,48.25)
+3.3V_RUN_DIMM2: length 7.6
  TOP w0.508: CD132.1 146.62,32.56 146.62,32.26 v1(146.77,32.12) ; CD132.1 145.72,32.94 145.07,33.59 v2(145.07,34.1) ; CD132.1 145.73,32.44 CD133.1 RC319.2
  BOTTOM w0.305: JDIMM2.255 v1(146.77,32.12)
+3.3V_RUN_FFS: length 5.2
  BOTTOM w0.254: 192.97,48.51 U15.9 U15.2 189.88,48.51 189.77,48.61 189.77,48.83 189.95,49.01 U15.3 ; 192.97,48.01 U15.10
  vias: v2(195.06,50.15)
+3.3V_RUN_VDDA: length 0.9
  TOP w0.254: v8(90.83,127.41) 90.83,127.41 U6.C10 ; U6.H12 v8(87.58,126.76)
  vias: v2(87.11,131.18) v8(85.63,130.66) v8(87.58,130.66)
+3.3V_RUN_VDDIO: length 4.6
  TOP w0.254: U6.B6 91.16,130.33 v8(90.83,130.66) 91.16,130.98 U6.B5 ; U6.C4 v8(90.18,131.96) U6.C3 ; U6.C11 90.51,127.08 v8(90.18,126.76) U6.C12 ; U6.K11 v8(85.63,126.76) 85.96,126.43 U6.K12
  BOTTOM w0.406: v8(90.83,130.66) 90.9,130.66 91.48,131.23 C28.1
  vias: v2(82.24,126.45) v8(85.63,132.61) v8(86.28,132.61)
+3.3V_RUN_VMM: length 54.2
  TOP w0.254: v1(95.59,118.12) 95.77,118.3 95.77,124.42 R44.2 94.91,125.29 94.91,130.42 94.98,130.49 R9594.2
  TOP w0.305: R9594.2 R9637.2 R55.2 R9636.2 R9570.2 R9539.2 94.98,135.73 95.18,135.93 v1(95.44,135.93)
  TOP w0.406: R74.2 80.93,132.83 v1(80.71,132.83)
  TOP w0.508: v1(81.59,137.15) 81.59,138.01 81.49,138.11 81.49,143.47 81.16,143.8 R65.2 80.71,144.39 80.33,144.77 79.69,144.77 79.44,144.51 U7.8 76.9,144.51 76.2,145.21 C34.1 R64.2
  IN1 w0.508: v1(81.59,137.15) 81.59,137.96 82.05,138.42 90.29,138.42 91.94,136.77 94.6,136.77 v1(95.44,135.93)
  IN3 w0.254: v1(95.59,118.12) 94.87,118.12 94.15,117.4 92.58,117.4 v1(92.57,117.41)
  vias: v2(80.96,136.23)
+3.3V_SPI: length 93.4
  TOP w0.254: v2(159.52,110.4) 159.95,110.4 160.11,110.25 v1(160.11,110.12)
  IN1 w0.203: v3(130.03,87.62) 129.55,87.62 128.66,88.51 127,88.51 126.39,89.12 126.39,89.47 126.7,89.78 128.59,89.78 129.35,90.54 135.8,90.54 137.96,92.7 139.21,92.7 141.08,94.57 141.08,96.18 143.44,98.54 147.69,98.54 151.12,101.97 v1(152.33,101.97)
  IN2 w0.254: v1(160.08,103.98) 160.2,103.98 160.61,104.38 160.61,104.78 160.3,105.09 153.89,105.09 151.85,103.06 151.85,102.45 v1(152.33,101.97)
  IN3 w0.254: v1(160.08,103.98) 160.48,103.98 160.61,104.1 160.61,107.21 160.11,107.71 v1(160.11,110.12)
  BOTTOM w0.254: UC1.AJ16 129.5,87.62 v3(130.03,87.62)
  BOTTOM w0.432: C9560.1 R2.1
  BOTTOM w0.508: R9593.2 160.34,121.6 R9571.2 160.2,121.64 C9559.1 159.37,121.45 159.62,121.2 159.62,120.45 159.39,120.21 JSPI1.8 U1.8 159.39,115.31 159,114.92 ; 159,114.92 154.22,114.92 153.26,115.88 153.26,118.75 152.84,119.18 C9560.1 151.15,119.18 150.56,118.58 U2.8 150.56,116.29 149.44,115.18 145.7,115.18 145.5,115.38 R1.1 ; 159,114.92 160.11,113.81 v1(160.11,110.12)
+3.3V_SUS: length 49.4
  TOP w0.254: 181.93,51.34 181.62,51.64 QC2808.2 ; 181.93,51.34 181.62,51.03 QC2808.5 ; 181.93,51.34 182.3,51.34 v1(182.9,51.94) ; R731.1 R732.1 182.97,56.58 183.42,56.12 183.42,55.26 v1(183.35,55.18)
  TOP w0.508: 205.65,61.81 205.17,61.33 204.33,61.33 203.62,60.62 203.62,59.55 202.47,58.41 v1(201.41,58.41)
  IN2 w0.254: v1(188.24,52.72) 188.24,52.55 187,51.32 185.74,51.32 185.09,51.97 185.09,53.28 183.35,55.03 v1(183.35,55.18)
  IN3 w0.254: v1(182.9,51.94) 182.84,52 182.84,54.56 183.35,55.07 v1(183.35,55.18)
  BOTTOM w0.254: JEPC1.29 187.63,55.56 C633.1 188.13,55.79 JEPC1.30
  BOTTOM w0.381: v1(201.41,58.41) 201.39,58.4 v2(201.39,57.27) 201.39,56.16 199.06,53.82 194.82,53.82 194.82,53.82 194.76,53.82 194.14,53.2 191.65,53.2 190.28,51.83 189.13,51.83 v1(188.24,52.72) 188.67,53.15 188.67,54.97 188.21,55.42 C633.1
+3.3V_TP: length 26.8
  TOP w0.254: R404.1 151.62,59.78 150.74,59.78 v1(150.71,59.81)
  TOP w0.279: 142.05,62.72 141.39,62.72 141.1,62.43 JTP1.5
  TOP w0.381: v1(145.98,58.38) 145.48,58.89 145.48,59.81 143.89,61.39 R9671.2 C374.1 142.7,62.72 142.05,62.72
  TOP w0.406: R405.1 152.08,64.55 152.08,65.09 v1(151.78,65.39)
  IN2 w0.381: v1(145.98,58.38) 146.04,58.32 150.58,58.32 151.23,58.97 151.23,59.43 150.85,59.81 v1(150.71,59.81)
  BOTTOM w0.508: v1(150.71,59.81) 150.71,64.33 v1(151.78,65.39) ; v1(145.98,58.38) 145.78,58.59 v2(145.78,59.25)
+3.3V_USBHUB: length 16.5
  TOP w0.356: v1(188.53,136.06) 189.09,135.5 189.09,134.61 189.34,134.35 QC2807.2
  IN4 w0.508: v1(188.53,136.06) 188.53,135.5 187.89,134.86 v1(185.6,134.86)
  BOTTOM w0.279: v1(183.35,127.58) 183.1,127.83 U92.36 ; v1(185.6,134.86) U92.15 ; v1(188.66,131.18) U92.23 ; v1(183.1,134.74) U92.10 ; v1(181.54,131.05) 181.67,131.18 U92.5 ; U92.29 v1(186.6,127.57)
  BOTTOM w0.432: v1(190.05,127.88) 190.05,128.33 R2721.1 ; R2725.2 R2726.2 R2727.2 188.66,136.18 v1(188.53,136.06) ; v1(189.7,125.92) R2722.2 R2724.2
  vias: v2(187.74,129.88)
+3.3V_VTR: length 7.3
  TOP w0.254: C346.1 241.01,55.77 240.85,55.61 240.35,55.61 240.11,55.38 U38.A22
  TOP w0.508: R336.2 243.27,52.57 242.89,52.95 242.4,52.95 242.4,52.95 242.38,52.97 242.38,52.97 242.02,53.33 242.02,53.33 v2(241.85,53.5) 241.85,53.95 241.6,54.2 C352.1 C346.1
+3.3V_VTR_ADC: length 9.3
  TOP w0.254: v2(222.21,60.59) 222.87,59.93 R461.2 222.87,59.45 223.14,59.18 C347.1 223.66,58.09 225.42,58.09 225.55,57.96 C353.1 226.06,57.01 226.88,57.01 227.29,56.6 227.29,56.45 227.86,55.88 U38.A58
+3.3V_WLAN: length 39.2
  TOP w0.254: 29.14,136.26 28.54,135.65 28.54,134.87 28.97,134.43 R227.1 28.97,133.39 29.1,133.26 Q22.2 ; Q22.5 29.1,129.45 29.31,129.24 R229.1 30.16,128.64 v1(30.41,128.89)
  IN1 w1.016: 33.08,115.31 33.97,114.42 41.02,114.42 45.71,119.11 52.97,119.11
  IN2 w0.762: v4(30.03,136.39) 30.03,129.27 v1(30.41,128.89)
  BOTTOM w0.305: 30.79,136.27 JWLAN1.4 ; 30.78,136.77 JWLAN1.2
  vias: v1(29.27,136.51) v1(29.84,119.14) v1(30.47,119.14) v1(32.83,115.94) v1(33.07,116.5) v1(53.83,119.11) v2(52.64,119.62) v4(32.31,116.49) v4(54.57,119.14)
+3.3V_WWAN: length 76.9
  TOP w0.254: v1(27.14,128.64) R226.1 26.18,128.87 Q30.5
  IN2 w0.254: v1(27.14,128.64) 27.14,127.5 28.53,126.1 28.53,122.95 27.62,122.04 27.62,115.15 28.79,113.98 40.09,113.98 44.05,110.03 50.07,110.03 51.7,111.66 54.66,111.66 v1(55.1,112.1)
  BOTTOM w0.254: RI31.1 98.44,122.47 ; 96,130.39 98.64,130.39 98.87,130.62 R216.2 ; 58.99,118.35 58.99,116.99 55.1,113.11 v1(55.1,112.1)
  BOTTOM w0.432: R217.2 96.55,133.47
  BOTTOM w0.457: R9453.2 94.27,115.05 94.6,114.72 94.6,112.87 v2(95.2,112.27)
  BOTTOM w0.508: v2(95.2,112.27) 94.96,112.04 C9539.2 C9542.1 94.07,111.05 93.76,111.37 92.59,111.37 92.34,111.62 JPSEN1.1 ; C253.1 95.78,120.3 94.37,118.89 94.37,117.64 94.02,117.29 R9453.2
  vias: v4(60.89,125.41) v4(61.35,126.15) v4(61.86,125.44) v4(92.7,139.18) v4(93.58,139.18) v4(94.47,139.18)
+3.3VALW: length 12.1
  TOP w0.254: v1(130.11,123.33) 130.49,123.71 PR5501.2
  IN1 w0.254: v1(130.11,123.33) 130.11,125.53 129.86,125.79 129.86,129.09 130.16,129.4 131.84,129.4 132.36,128.88 v1(134.87,128.88)
+3V/5V_PWR_SRC: length 11.3
  IN4 w0.635: v1(190.69,59.09) 190.69,58.42 191.3,57.81 195.88,57.81 197.47,59.4 198.47,59.4 198.48,59.4 199.85,60.77 v4(199.85,60.77)
  vias: v2(183.37,68.09)
+5V_ALW: length 520.7
  TOP w0.191: v1(207.43,57.87) 207.43,58.61 207.33,58.71 U46.4
  TOP w0.197: v1(187.41,91.47) 187.32,91.56 U6217.4
  TOP w0.221: PU5801.10 68.58,111.85 68.45,111.98 v1(68.45,112.21) 68.71,112.21 68.75,112.25 PU5801.9
  TOP w0.254: PU1.5 252.54,37.63 252.26,37.35 250.43,37.35 v1(250.25,37.53) 249.87,37.15 PR5108.1 ; PR5812.1 73.16,124.4 71.6,125.96 68.88,125.96 v4(68.39,126.45) ; R9462.1 27.11,95.24 27.11,96.64 ; U43.4 v1(187.59,97.52)
  TOP w0.381: U6221.3 88.83,111.42 v1(88.38,111.88) ; v1(122.64,66.92) 122.55,67.01 121.97,67.01 121.55,67.42 U6222.3
  TOP w0.432: C3079.1 175,53.59 C9926.1
  TOP w0.508: v1(190,137.61) 189.7,137.91 U22.5 ; v1(172.65,36.28) 173.21,36.84 173.21,45 174.18,45.96 176.9,45.96 177.38,46.44 v1(178.04,46.44) ; PU5203.8 215.73,41.59 215.49,41.35 214.17,41.35 213.43,42.09 209.75,42.09 208.44,43.4 208.44,44.41 ; v1(174.08,54.38) 174.3,54.6 C3079.1 ; PR5404.1 80.09,53.45 79.97,53.33 79.94,53.33 79.46,52.85 79.46,48.48 80.38,47.56 v1(80.38,47.28) 80.38,44.41 81.65,43.14 81.65,42.03 79.63,40.01 R28.1 ; v3(95.59,80.3) 92.16,80.3 89.85,82.61 v1(83.63,82.61) ; v1(267.15,12.86) Q16.2 ; v1(259.62,9.28) 259.62,8.67 259.6,8.65 259.6,8.62 259.41,8.43 C1187.1
  IN1 w0.356: v1(68.45,112.21) 68.45,112.75 68.96,113.26 71.11,113.26 74.12,110.25 76.41,110.25 77.55,111.39 79.11,111.39 80.12,112.41 82.22,112.41 82.76,111.88 v1(88.38,111.88)
  IN1 w0.508: v1(60.77,128.26) 58.46,130.57 v1(53.65,130.57) 53.65,130.57 v1(53.03,130.57) ; v1(68.45,112.21) 69.03,112.21 70.13,111.11 70.13,107.44 69.56,106.87 69.56,106.36 70.75,105.17 72.55,105.17 75.37,102.35 75.37,101.21 77.48,99.1 77.48,91.73 83.63,85.59 v1(83.63,82.61) 83.63,79.56 79.9,75.83 79.9,65.62 82.15,63.36 82.15,49.57 81.14,48.56 81.14,48.04 v1(80.38,47.28)
  IN1 w1.524: 190.46,79.36 190.46,69 191.2,68.26 191.2,66.03
  IN2 w0.254: 63.82,122.67 62.32,124.17 57.44,124.17 v1(56.33,123.05)
  IN2 w0.381: v1(122.64,66.92) 122.31,67.25 112.84,67.25 111.64,68.44 107.17,68.44 103.64,71.97 101.2,71.97 98.11,75.07 98.11,75.22 97.19,76.14 96.71,76.14 95.44,77.41 95.44,80.15 v3(95.59,80.3)
  IN2 w0.508: v1(53.03,130.57) 53.65,130.57 v1(53.65,130.57) 58.46,130.57 v1(60.77,128.26) ; v1(198.13,46.37) 197.83,46.37 194.68,43.23 181.26,43.23 v1(178.04,46.44)
  IN2 w0.635: v1(68.45,112.21) 67.42,113.23 67.42,115.37 66.81,115.98 66.25,115.98 66.25,115.98 64.38,115.98 63.02,117.33 63.02,119.97 63.82,120.77 63.82,122.67 63.94,122.67 66.23,124.96 66.89,124.96 v4(68.39,126.45)
  IN3 w0.508: v1(266.84,35.8) 266.61,35.57 259.8,35.57 257.36,38.01 250.73,38.01 v1(250.25,37.53) ; v1(267.15,12.86) 267.15,9.51 266.17,8.52 260.39,8.52 v1(259.62,9.28)
  IN4 w0.508: v1(267.15,12.86) 267.15,27.71 268.1,28.65 268.1,33.2 266.84,34.46 v1(266.84,35.8) ; v1(174.08,54.38) 179.08,49.39 179.08,47.03 178.5,46.44 v1(178.04,46.44) ; v1(56.33,123.05) 56.33,123.3 54.34,125.29 54.34,128.28 53.65,128.97 v1(53.65,130.57)
  BOTTOM w0.178: v1(53.03,129.42) 53.01,129.4 U18.4 ; v1(56.33,123.05) 56.45,122.93 U51.4
  BOTTOM w0.254: v1(201.26,46.39) 201.26,45.05 200.02,43.81 U32.4 ; U32.1 197.94,44.43 197.93,44.44 ; U32.2 198.44,44.31 198.31,44.44 ; v1(46.37,93.59) 46.37,92.04 47.51,90.89 R9691.1
  BOTTOM w0.305: JIOR1.6 178.79,104.73 ; JIOR1.9 178.79,103.23 ; 177.68,106.73 176.76,106.73 v4(176.62,106.87) ; 177.68,106.73 JIOR1.2 ; 177.68,106.73 178.79,106.73 ; 178.79,105.73 JIOR1.4 176.9,105.73 ; JIOR1.1 177.68,107.23 ; 177.68,107.23 178.79,107.23 ; 177.68,107.23 176.92,107.23 ; JIOR1.8 178.79,103.73 ; 178.88,102.73 178.88,102.73 JIOR1.10 ; 176.9,106.23 JIOR1.3 178.79,106.23 ; JIOR1.5 178.8,105.23 ; JIOR1.7 178.79,104.23
  BOTTOM w0.406: JRCAM1.7 208.51,149.47 208.34,149.3 v1(208.34,149.09) ; v1(208.98,149.09) 209.11,149.22 JRCAM1.8
  BOTTOM w0.508: v4(190.26,80.79) 189.47,80 183.83,80 182.61,78.78 182.61,77.38 182.21,76.98 179.18,76.98 176.41,74.2 176.41,72.19 174.16,69.94 170.9,69.94 170.34,70.51 PJP5601.2 ; v1(250.25,37.53) 250.53,37.81 250.53,40.5 250.24,40.79 250.24,43.29 249.35,44.17 249.35,46.09 249.56,46.3 249.56,50.02 249.92,50.38 249.92,54.33 250.02,54.43 250.02,57.93 249.46,58.48 249.46,59.68 247.53,61.61 247.31,61.61 245.12,63.79 245.12,64.16 240.61,68.67 239.71,68.67 239.18,69.2 218.35,69.2 217.33,68.19 217.33,67.32 215.9,65.89 215.9,64.39 215.38,63.87 214.01,63.87 209.28,59.14 ; v1(172.65,36.28) 172.65,35.87 C9922.1 173.47,35.46 173.47,36.54 173.19,36.82 JSEC1.18
  BOTTOM w1.524: 203.74,62.83 204.05,63.13 206.67,63.13 207.58,62.22 207.58,59.55 ; 207.58,56.6 207.58,50.46 207.94,50.1 207.94,48.32
  vias: v1(20.62,92.95) v1(21.26,92.95) v1(24.7,97.78) v1(25.33,97.79) v1(25.97,97.79) v1(139.76,136.65) v1(140.4,136.65) v1(179.89,107.66) v1(180.43,106.41) v1(198.74,46.37) v1(199.35,46.37) v1(203.52,61.96) v1(207.63,46.5) v1(208.22,147.56) v1(208.85,147.56) v4(175.7,106.87) v4(179.89,106.92) v4(179.89,105.91) v4(190.26,83.43) v4(190.26,82.54) v4(190.26,81.65) v4(191.15,83.43) v4(191.15,82.54) v4(191.15,81.65) v4(191.15,80.76) v4(202.78,61.84) v4(208.37,46.5)
+5V_ALW2: length 94
  TOP w0.508: v1(204.81,61.96) 203.74,63.03 202.37,63.03 201.66,63.74 200.66,63.74 PC5304.1
  IN2 w0.508: v1(172.5,44.59) 172.86,44.59 173.19,44.26 173.19,43.52 176.04,40.67 190.24,40.67 190.52,40.39 202.16,40.39 204.56,42.79 212.13,42.79 212.89,42.03 217.43,42.03 v1(218.32,42.91)
  IN4 w0.508: v1(218.24,62.51) 217.13,63.62 208.21,63.62 206.56,61.96 v1(204.81,61.96)
  BOTTOM w0.508: v1(218.32,42.91) v2(217.41,43.83) 217.41,53.23 217.18,53.46 217.18,61.14 218.24,62.19 v1(218.24,62.51) ; v1(172.5,44.59) 172.65,44.59 173.1,44.15 C9920.1 173.14,42.75 R9574.1
+5V_ALW2_R: length 5.7
  BOTTOM w0.254: R9574.2 172.17,41.82 171.64,42.36 171.64,44.08 171.36,44.36 171.36,44.97 v2(171.13,45.2)
  BOTTOM w0.508: JSEC1.17 172.69,41.15 172.27,41.57 R9574.2
+5V_ALWP:
  vias: v2(180.99,70.35) v2(186.4,77.94) v4(184.52,78.88) v4(184.52,77.99) v4(184.52,77.1) v4(184.52,76.21) v4(185.41,78.88) v4(185.41,77.99) v4(185.41,77.1) v4(185.41,76.21)
+5V_GPS: length 19
  BOTTOM w0.508: JGPS1.4 161.09,116.15 160.51,116.73 160.51,118.5 160.59,118.58 160.59,118.65 161.67,119.73 161.74,119.73 162.41,120.4 C9918.1 162.41,123.66 162.2,123.86 160.36,123.86 160.02,124.2 PJP5806.1 161.74,125.09 161.89,125.24 v2(161.89,127.27)
+5V_GPS_Q: length 4.9
  BOTTOM w0.508: Q3604.3 157.56,125.08 158.58,126.1 PJP5806.2 v2(160.01,127.22)
+5V_HDD: length 42.5
  IN3 w0.254: v1(187.39,44.32) 182.68,44.32 182.67,44.33 182.49,44.33 177.24,49.57 175.37,49.57 174.94,50 172.91,50 170.85,52.06 168.36,52.06 167.47,52.95 164.91,52.95 v1(163.94,53.91)
  BOTTOM w0.254: v1(187.39,44.32) 187.39,43.13 187.83,42.69 R125.2 ; v1(163.94,53.91) v2(163.94,55.23) 163.94,56.63 163.35,57.23 163.02,57.23 162.49,57.75 162.49,58.87 161.55,59.81 159.62,59.81 157.8,61.63 156.65,61.63
+5V_HDMI_DDC_SCL: length 4.5
  TOP w0.254: D65.2 17.18,125.57 R472.1 17.16,125.09 17.16,124.68 v2(16.72,124.24) 15.89,123.41 R471.2
+5V_HDMI_DDC_SDA: length 6.6
  TOP w0.254: R470.2 19.82,124.8 19.65,124.63 v1(19.26,124.63)
  BOTTOM w0.254: v1(19.26,124.63) 19.59,124.96 19.59,125.62 18.48,126.74 D64.2 v2(17.18,128.31)
+5V_ODD: length 6.4
  BOTTOM w0.254: JODD1.12 200.12,32.95 v2(200.44,32.63) 200.27,32.45 JODD1.11
  BOTTOM w1.524: 198.11,37.05 198.11,38.88
+5V_RUN: length 466.1
  TOP w0.165: PU5901.2 110.88,125.03 110.55,124.7 v1(110.42,124.7) 109.82,124.7 109.04,123.92 106.74,123.92 PC5901.1
  TOP w0.203: PU5903.2 63.28,92.51
  TOP w0.254: R355.1 R357.1 236.54,67.93 v1(236.28,68.19) ; v1(119.7,143.17) 119.7,142.99 118.73,142.02 R9396.2 113.19,141.64 109.92,138.37 v1(109.92,137.02) ; PC5915.1 123.3,127.95 123.63,127.62 v1(123.63,127.37) 123.88,127.12 PU5902.6 ; v4(75.17,91.12) 74.53,90.49 74.53,89.67 74.19,89.32 69.02,89.32 68.34,88.63 66.1,88.63 64.93,89.8 64.93,90.26 PC5925.1 64.53,91.15 64.15,91.53 64.15,92.11 63.75,92.51 63.28,92.51 ; C9855.1 134.44,142.33 130.34,142.33 129.6,141.59 129.6,140.17 v1(129.55,140.12) 129.4,139.97 U6203.26 ; v1(236.66,66.03) 236.54,65.9 R356.1 R385.1
  TOP w0.305: C375.1 145.38,51.14 145.61,51.38 JKB1.5
  TOP w0.381: v1(19.05,125.34) R472.2 18.28,126.36 18.66,126.74 D65.1 19.78,126.32 v1(20.03,126.07) ; v1(39.25,110.61) 39.25,110.2 39.61,109.85 C61.1 40.51,108.85 40.86,108.51 Q1.2 41.98,107.83 42.4,107.4 R94.2
  TOP w0.406: v1(174.71,116.07) 174.71,113.67 177.22,111.16 178.44,111.16 179.5,110.1 180.08,110.1 C9905.1
  TOP w0.508: v4(145.04,51.96) 144.91,51.82 C375.1 ; C9905.1 180.67,108.61 C9927.1 180.73,108.29 181.11,107.91 v1(183.04,107.91) ; 97.7,144.46 98.56,144.46 101.1,141.92 101.1,140.32 101.59,139.83 101.59,134.18 v1(101.92,133.85)
  TOP w1.016: FANF1.2 76.16,79.72 75.04,80.84 75.04,85.46 75.86,86.27 75.86,90.44 v4(75.17,91.12)
  IN1 w0.381: v4(64.53,117.46) 64.08,117.02 64.08,115.49 61.39,112.81 v1(61.39,110.04)
  IN1 w0.508: v1(236.66,66.03) 236.66,65.81 235.65,64.8 233.83,64.8 233.61,65.01 231.34,65.01 230.74,64.41 228.16,64.41 225.74,61.99 218.65,61.99 213.36,56.69 206.89,56.69 v4(205.03,58.56)
  IN1 w0.762: v4(145.04,51.96) 145.27,51.73 145.99,51.73 146.42,52.17 146.42,55.42 145.48,56.37 145.48,56.99 144.59,57.87 144.59,63.84 146.14,65.39 146.67,65.39 147.74,66.46 149.92,66.46 v4(150.18,66.21)
  IN2 w0.254: v1(129.55,140.12) 129.2,140.12 126.84,142.48 120.39,142.48 v1(119.7,143.17) ; 97.6,129.92 97.6,128.36 98.74,127.22 101.64,127.22 102.86,126 106.13,126 106.15,126.02 106.16,126.02 106.67,126.53 107.61,126.53 108.77,125.38 109.75,125.38 v1(110.42,124.7)
  IN2 w0.508: v1(61.39,110.04) 61.23,109.88 59.99,109.88 59.75,110.12 57.76,110.12 57.23,110.65 51.95,110.65 50.43,109.14 40.72,109.14 v1(39.25,110.61) 39.25,110.88 38.19,111.95 28.31,111.95 26.76,113.5 26.76,121.07 23.81,124.02 20.83,124.02 19.52,125.34 v1(19.05,125.34)
  IN2 w1.016: 96.43,137.02 90.8,137.02 90.21,137.61 85.04,137.61 81.57,134.14 81.57,131.94 76.87,127.24 71.18,127.24 67.75,123.81 66.74,123.81 64.78,121.86 64.78,118.94 65.72,119.88 69.99,119.88 71.49,118.38 71.49,111.65 72.48,110.66 72.48,108.42 72.05,107.99 72.05,99.02 76.08,94.98 76.08,91.58 75.63,91.12 v4(75.17,91.12)
  IN3 w0.254: v1(123.63,127.37) 123.28,127.72 v1(123.28,130.52)
  IN3 w0.508: 167.1,33.46 169.48,33.46 ; 165.96,31.67 169.27,31.67
  IN3 w0.762: v4(145.04,51.96) 146.44,50.56 146.44,49.68 146.03,49.27 146.03,47.59 147.35,46.27 148.56,46.27 157.34,37.49 167.49,37.49
  IN4 w0.254: v1(110.42,124.7) 111.06,125.34 115,125.34 116.39,126.73 123.25,126.73 123.63,127.12 v1(123.63,127.37) ; v1(236.66,66.03) 236.66,67.13 236.28,67.51 v1(236.28,68.19)
  BOTTOM w0.254: C9464.1 117.92,146.23 117.92,145.4 119.7,143.62 v1(119.7,143.17)
  BOTTOM w0.305: v1(119.7,143.17) JGFX1.49 ; 190.63,56.31 JEPC1.35 ; v1(183.04,107.91) 181.65,106.52 181.65,103.38 180.5,102.23 JIOR1.11 ; 190.13,56.3 JEPC1.34 ; 191.63,56.32 JEPC1.37 ; 191.13,56.31 JEPC1.36
  BOTTOM w0.381: D65.1 19.78,126.32 v1(20.03,126.07)
  BOTTOM w0.508: HDMIU1.3 18.23,124.25 18.29,124.31 C333.1 18.4,125.2 18.9,125.2 v1(19.05,125.34) ; v2(159.51,130.89) C9462.1 159.51,128.14 158.99,127.63 Q3604.2 157.6,126.92 157.16,126.48 155.89,126.48 155.2,125.79 R9414.2 153.99,125.56 v1(154.69,124.85) ; JSEC1.20 174.19,36.49 v1(174.41,36.27) C208.1
  BOTTOM w1.27: 203.64,47.45 197.76,47.45 196.76,46.45 196.76,42.76 195.84,41.85 195.84,41.39 ; 201.9,30.73 204.02,32.86 204.02,46.34
  BOTTOM w2.032: 204.84,48.92 204.84,57.69
  vias: v1(97.32,144.08) v1(97.95,143.85) v1(201.46,30.14) v4(171.89,114.44) v4(174.18,116.62) v4(182.38,84.9) v4(183.32,85.41) v4(183.32,84.54) v4(197.8,58.4) v4(198.69,58.4) v4(201.46,29.4) v4(204.16,58.56)
+5V_RUN_AUDIO: length 8.9
  BOTTOM w0.508: 48.83,131.81 48.45,132.2 46.04,132.2 45.15,131.31 44.13,131.31 v2(43.88,131.05) 43.11,130.29 43.11,128.07
  vias: v1(48.91,131.51) v1(49.46,130.9) v1(49.54,131.51) v1(50.97,117.51) v1(50.96,116.88)
+5V_RUN_CRT: length 18.1
  TOP w0.254: v1(84.01,140.96) 83.96,140.91 v1(83.96,137.78)
  IN4 w0.508: v1(87.44,146.67) 87.44,145.48 84.01,142.05 v1(84.01,140.96)
  BOTTOM w0.254: R2747.1 84.26,140.7 v1(84.01,140.96) ; v1(83.96,137.78) 83.96,138.66 84.73,139.43 R2748.1
  BOTTOM w0.508: v1(87.44,146.67) 86.88,146.67 v2(86.8,146.6) 86.47,146.6 85.91,146.04 R2740.2 ; R2742.2 92.16,145.38 v1(91.88,145.66)
  vias: v1(93.81,146.6) v1(94.45,146.6)
