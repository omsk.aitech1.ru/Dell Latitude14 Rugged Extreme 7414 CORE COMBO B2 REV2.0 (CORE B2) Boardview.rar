# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_HTX_C_GRX_N2: length 4.3
  TOP w0.121: CU20.1 119.21,139.45 119.21,140.12 v1(119.06,140.27)
  BOTTOM w0.121: v1(119.06,140.27) 119.34,139.99 119.34,139.15 119.2,139.01 JGFX1.52
PEG_HTX_C_GRX_N3: length 5.1
  TOP w0.121: CU22.1 116.42,138.9 116.42,139.77 116.79,140.14 117.18,140.14 117.28,140.24 117.28,140.38 v1(117.2,140.47)
  BOTTOM w0.121: v1(117.2,140.47) 117.81,139.85 117.81,139.13 117.7,139.01 JGFX1.58
PEG_HTX_C_GRX_P0: length 6.3
  TOP w0.121: CU17.1 114.37,139 114.37,139.55 114.62,139.8 114.62,140.24 115.11,140.73 v1(115.71,140.73)
  BOTTOM w0.121: v1(115.71,140.73) 115.89,140.55 116.22,140.55 116.7,140.07 JGFX1.62
PEG_HTX_C_GRX_P1: length 6.4
  TOP w0.121: CU19.1 112.23,138.99 112.23,139.23 113.29,140.29 113.59,140.29 v1(113.98,140.68)
  BOTTOM w0.121: v1(113.98,140.68) 114.29,140.37 114.9,140.37 115.2,140.07 JGFX1.68
PEG_HTX_C_GRX_P2: length 4.3
  TOP w0.121: v1(119.95,140.27) 119.72,140.27 119.44,139.99 119.44,139.35 119.34,139.26 CU21.1
  BOTTOM w0.121: v1(119.95,140.27) 119.56,139.88 119.56,139.14 119.7,139 JGFX1.50
PEG_HTX_C_GRX_P3: length 5.1
  TOP w0.121: CU23.1 116.64,139.01 116.64,139.67 116.89,139.92 117.28,139.92 117.5,140.14 117.53,140.14 v1(117.86,140.47)
  BOTTOM w0.121: v1(117.86,140.47) 117.86,140.13 118.04,139.95 118.04,139.16 118.2,139 JGFX1.56
PEG_HTX_GRX_N0: length 46.1
  TOP w0.121: CU16.2 114.95,137.23 115.35,136.83 115.35,136.62 v1(115.58,136.39)
  BOTTOM w0.076: UC1.B17 128.24,102.21 128.57,102.54 128.57,103.81 128.85,104.08 128.85,104.24 128.9,104.29 128.9,104.4
  BOTTOM w0.121: 128.9,104.4 128.9,108.38 128.36,108.93 128.36,113.82 ; 128.36,113.82 128.36,115.07 127.75,115.69 127.75,131.35 124.26,134.84 121.17,134.84 120.11,135.89 115.73,135.89 115.58,136.04 v1(115.58,136.39) ; 128.36,113.82 v6(128.38,113.82)
PEG_HTX_GRX_N1: length 51.1
  TOP w0.121: v1(113.67,136.36) 113.79,136.48 113.79,136.73 113.6,136.92 112.99,136.92 112.81,137.1 CU18.2
  BOTTOM w0.076: 129.2,104.2 129.2,104.08 128.74,103.63 128.74,102.4 128.53,102.2 128.53,101.99 arc(128.5,101.94) 128.48,101.87 128.48,101.7 arc(128.5,101.61) 128.56,101.53 128.56,101.33 UC1.D16
  BOTTOM w0.121: 128.41,119.3 128.41,116.31 129,115.73 129,109.22 129.53,108.68 129.53,105.21 129.2,104.87 129.2,104.2 ; 128.41,119.3 v6(128.38,119.3) ; 128.41,119.3 128.41,131.57 124.1,135.88 122.18,135.88 121.05,137.01 113.95,137.01 113.67,136.74 v1(113.67,136.36)
PEG_HTX_GRX_N2: length 44.5
  TOP w0.121: CU20.2 118.32,135.94 118.55,135.72 v1(118.55,135.15)
  BOTTOM w0.076: UC1.D17 127.9,101.1 127.9,101.67 127.81,101.93 127.81,102.18 127.84,102.3 127.84,102.49 127.81,102.58 127.81,102.94 128.06,103.18 128.06,105.44 127.81,105.69 127.81,105.74
  BOTTOM w0.121: 122.58,133.76 123.82,133.76 126.66,130.93 126.66,115.68 125.82,114.84 125.82,111.48 127.29,110.01 127.29,108.48 127.81,107.96 127.81,105.74 ; 122.58,133.76 119.39,133.76 118.86,134.29 118.86,134.84 v1(118.55,135.15) ; 122.58,133.76 v6(122.58,133.74)
PEG_HTX_GRX_N3: length 44
  TOP w0.121: v1(117.16,135.19) 117.16,135.77 116.29,136.64 116.29,137 116.08,137.21 CU22.2
  BOTTOM w0.076: 126.96,106 126.96,105.42 126.61,105.08 126.61,102.54 126.89,102.27 UC1.B19
  BOTTOM w0.121: v1(117.16,135.19) 117.39,134.96 117.39,134.06 118.54,132.91 123.4,132.91 125.79,130.52 125.79,116.08 124.9,115.19 124.9,114.44 ; 124.9,114.44 124.9,111.03 126.43,109.5 126.43,108.13 126.96,107.61 126.96,106 ; 124.9,114.44 v6(124.89,114.44)
PEG_HTX_GRX_P0: length 46
  TOP w0.121: CU17.2 114.55,137.05 114.82,137.05 115.13,136.74 115.13,136.59 v1(114.92,136.39)
  BOTTOM w0.076: 128.68,104.4 128.68,104.15 128.41,103.88 128.41,102.88 UC1.A17
  BOTTOM w0.121: 128.14,111.54 128.14,114.98 127.53,115.59 127.53,131.26 124.17,134.61 121.08,134.61 120.02,135.67 115.64,135.67 v1(114.92,136.39) ; 128.14,111.54 128.14,108.84 128.68,108.29 128.68,104.4 ; 128.14,111.54 v6(128.12,111.54)
PEG_HTX_GRX_P1: length 51
  TOP w0.121: CU19.2 112.34,137.12 112.48,137.12 112.99,136.61 v1(112.99,136.36)
  BOTTOM w0.076: 129.42,104.1 129.42,104.07 128.9,103.56 128.9,102.31 128.8,102.21 UC1.C16
  BOTTOM w0.121: v6(128.66,117.02) 128.64,117.02 ; 128.64,117.02 128.64,131.67 124.2,136.11 122.27,136.11 121.14,137.24 113.86,137.24 v1(112.99,136.36) ; 128.64,117.02 128.64,116.41 129.22,115.82 129.22,109.31 129.75,108.78 129.75,105.12 129.42,104.78 129.42,104.1 129.42,104.1
PEG_HTX_GRX_P2: length 44.5
  TOP w0.121: CU21.2 119.34,137.28 119.08,137.02 118.68,137.02 118.55,136.89 118.55,136.04 118.77,135.81 118.77,135.68 118.88,135.57 119.02,135.57 119.21,135.38 v1(119.21,135.15)
  BOTTOM w0.076: UC1.C17 128.06,101.59 128.06,101.7 127.97,101.96 127.97,102.15 128.01,102.27 128.01,102.52 127.97,102.61 127.97,102.87 128.22,103.12 128.22,105.51 128.03,105.7 128.03,105.74
  BOTTOM w0.121: v1(119.21,135.15) 119.09,135.02 119.09,134.38 119.48,133.99 120.71,133.99 ; 128.03,105.74 128.03,108.05 127.51,108.57 127.51,110.1 126.04,111.57 126.04,114.75 126.88,115.58 126.88,131.02 123.91,133.99 120.71,133.99 ; 120.71,133.99 v6(120.71,134)
PEG_HTX_GRX_P3: length 44
  TOP w0.121: CU23.2 117.09,137.21 117.01,137.12 116.66,137.12 116.51,136.97 116.51,136.73 117.38,135.87 117.38,135.66 117.46,135.57 117.72,135.57 117.84,135.44 v1(117.84,135.19)
  BOTTOM w0.076: UC1.A19 126.78,102.82 126.78,105.01 127.18,105.41 127.18,106
  BOTTOM w0.121: 125.12,112.47 125.12,115.1 126.01,115.99 126.01,130.61 123.49,133.13 118.63,133.13 117.61,134.15 117.61,134.96 v1(117.84,135.19) ; 125.12,112.47 v6(125.14,112.47) ; 125.12,112.47 125.12,111.12 126.66,109.59 126.66,108.22 127.18,107.7 127.18,106
PLTRST_5048#: length 154.2
  TOP w0.108: U37.B22 264.56,51.58 264.39,51.75 v1(264.38,51.75)
  IN2 w0.089: v1(264.38,51.75) 262.95,53.18 262.95,56.12 262.57,56.5 262.57,57.62 261.76,58.43 249.68,58.43 249.01,57.76 249.01,57.54 246.81,55.34 245.06,55.34 244.03,56.38 243.01,56.38 242.38,57.01 239.44,57.01 238.31,58.14 236.16,58.14 235.89,57.87 226.02,57.87 223.24,55.09 219.91,55.09 218.13,56.86 212.7,56.86 212.58,56.99 208.8,56.99 206.82,55 194.99,55 194.15,55.84 190.76,55.84 189.35,57.25 188.48,57.25 185.24,60.48 184.08,60.48 177.18,67.39 177.18,82.97 176.24,83.91 176.24,90.02 171.05,95.21 168.92,95.21 168.34,94.63 165.32,94.63 164.14,93.45 161.46,93.45 160.69,94.22 155.97,94.22 155.85,94.34 154.16,94.34 v1(153.76,93.94)
  BOTTOM w0.108: RC587.1 152.96,94.08 v2(153.1,93.94) v1(153.76,93.94)
PLTRST_LAN#: length 66.1
  TOP w0.108: U21.36 143.03,134.99 v1(142.53,135.49)
  IN3 w0.089: v1(155.08,93.94) 155.08,94.27 153.35,96 153.35,97.65 154.49,98.79 154.49,109.28 153.9,109.88 153.9,110.72 155.38,112.21 155.38,118.84 153.05,121.17 153.05,127.09 156.02,130.06 156.4,130.06 156.73,130.06 157.94,131.27 157.94,133.48 157.01,134.4 156.69,134.4 156.69,134.4 147.72,134.4 147.14,134.98 143.04,134.98 v1(142.53,135.49)
  BOTTOM w0.108: RC586.1 153.27,91.68 v2(154.62,93.03) 155.08,93.49 v1(155.08,93.94)
PLTRST_MMI#: length 29.2
  TOP w0.108: v2(178.88,89.47) 178.53,89.82 v1(178.53,90.16)
  IN1 w0.089: v1(153.45,89.98) 153.63,90.16 154.31,90.16 154.45,90.3 157.42,90.3 158.15,89.57 159.85,89.57 v1(160.41,89.02)
  IN3 w0.089: v1(178.53,90.16) 174.86,90.16 173.72,89.02 v1(160.41,89.02)
  BOTTOM w0.108: v1(178.53,90.16) 178.45,90.23 JIOR1.35 ; v1(153.45,89.98) 153.25,89.78 152.78,89.78 RC613.1
PLTRST_TPM#: length 238.8
  TOP w0.108: v1(268.54,47.36) 268.62,47.44 272.52,47.44 273.08,46.89 273.08,45.06 272.46,44.44 271.7,44.44 271.57,44.31 U26.18 ; v1(155.75,82.54) 155.84,82.45 RC612.1 RC611.1
  IN1 w0.089: 183.35,83.07 183.85,83.07 184.81,84.04 184.81,107.47 185.53,108.19 185.53,117.69 v1(184.47,118.76) ; 183.35,83.07 v1(183.32,83.1) ; 183.35,83.07 183.72,82.7 183.72,80.53 180.89,77.69 180.89,66.04 187.12,59.81 187.12,57.14 187.2,57.06 187.9,57.06 190.38,54.58 190.38,52.08 189.54,51.24 189.54,49.63 191.38,47.79 194.02,47.79 194.47,47.34 205.94,47.34 205.97,47.38 227.38,47.38 234.41,40.35 239.78,40.35 240.58,41.15 245.76,41.15 248.58,43.96 248.58,44.77 249.95,46.14 255.23,46.14 257.24,48.15 262.13,48.15 262.7,47.57 264.96,47.57 265.33,47.94 267.96,47.94 v1(268.54,47.36)
  IN3 w0.089: v1(194.35,141.44) 194.3,141.44 191.53,138.66 191.53,120.69 v1(191.24,120.4) ; v1(155.75,82.54) 156.54,82.54 157.91,81.17 158.71,81.17 159.33,81.79 159.33,82.6 159.87,83.14 163.44,83.14 163.93,82.65 168.2,82.65 168.87,83.32 175.77,83.32 175.88,83.43 175.94,83.43 176.34,83.83 182.59,83.83 v1(183.32,83.1)
  BOTTOM w0.108: v1(184.47,118.76) 186.68,118.76 v2(187.01,119.09) 187.89,119.09 188.22,118.76 190.56,118.76 191.24,119.44 v1(191.24,120.4) ; v1(194.35,141.44) 194.07,141.72 C9924.1 192.7,142.66 192.21,142.66 192.06,142.81 U25.17
PLTRST_VMM3320#: length 131.8
  TOP w0.089: U6.A13 91.81,125.59 92.19,125.21 92.19,125.01 91.98,124.8 91.98,124.36
  TOP w0.108: C9906.2 94.73,120.71 v1(93.79,121.65) 93.79,122.34 93.79,122.83 92.71,123.91 92.43,123.91 91.98,124.36 ; v1(154.37,93.94) 154.8,94.37 156.75,94.37 158.05,93.08 159.35,93.08 159.73,93.46 v2(159.73,94.15) 159.73,95.05 161.7,97.02 162.67,97.02 163.44,96.25 166.86,96.25 167.93,97.32 v1(167.93,97.6)
  IN2 w0.089: v1(173.37,111.39) 173.23,111.53 173.23,111.53 172.9,111.53 172.89,111.53 167.05,111.53 164.17,114.41 162.49,114.41 162.48,114.41 158.23,114.41 154.91,117.73 139.71,117.73 139.47,117.97 138.58,118.86 129.25,118.86 126.07,122.04 122.06,122.04 120.44,123.65 115.59,123.65 114.04,122.11 107.01,122.11 106.32,122.8 103.93,122.8 103.69,122.57 99.69,122.57 v1(99.66,122.61)
  IN3 w0.089: v1(173.37,111.39) 173.37,107.25 166.63,100.52 166.63,98.19 167.22,97.6 v1(167.93,97.6)
  IN4 w0.089: v1(93.79,121.65) 95.06,121.65 96.2,122.8 99.46,122.8 v1(99.66,122.61)
  BOTTOM w0.108: RC582.1 153.25,92.83 v1(154.37,93.94)
PM_LANPHY_ENABLE: length 235.5
  TOP w0.108: R180.1 139.38,125.59 138.84,126.13 138.84,126.86 v1(139.2,127.22) ; v1(59.44,125.07) 60.61,123.9 60.61,123.2 58.81,121.41 58.81,118.6 58.11,117.9 58.11,111.62 57.78,111.3 57.78,106.66 v2(58.02,106.41) 57.78,106.17 57.78,105.42 55.39,103.03 55.39,99.45 55.69,99.15 55.69,97.96 v1(56.58,97.07)
  IN2 w0.089: v1(139.2,127.22) 138.8,127.62 138.8,131.98 133.46,137.31 126.49,137.31 125.33,138.47 122.92,138.47 122.03,139.36 121.26,139.36 120.86,139.76 120.86,140.81 119.86,141.82 118.68,141.82 118.39,142.11 108.56,142.11 108.12,141.67 104.78,141.67 101.92,144.53 96.46,144.53 95.39,143.46 95.39,138.82 94.79,138.21 90.82,138.21 90.59,138.44 76.94,138.44 74.15,135.66 74.15,131.45 69.79,127.09 67.52,127.09 64.97,124.53 59.98,124.53 v1(59.44,125.07)
  IN3 w0.089: v3(128.08,77.84) 128.48,77.43 128.48,73.71 126.37,71.6 125.02,71.6 123.81,72.81 109.61,72.81 108.09,71.29 105.16,71.29 104.66,71.79 104.66,73.02 100.8,76.87 100.8,79.19 98.05,81.94 98.05,83.48 96.02,85.51 95.41,85.51 94.63,86.28 91.06,86.28 90.52,86.82 85.86,86.82 74.78,97.9 64.1,97.9 63.77,98.23 57.73,98.23 v1(56.58,97.07)
  BOTTOM w0.076: UC1.AW17 128.1,81.94 127.93,81.76 127.71,81.06 127.71,80.97 127.67,80.87 127.67,80.61 127.71,80.49 127.71,80.31 127.67,80.22 127.67,78.65 128.08,78.24 v3(128.08,77.84)
PME#: length 1.5
  TOP w0.076: v3(131.07,82.89) 131.07,82.21 T7139.1
  BOTTOM w0.076: v3(131.07,82.89) 131.07,82.9 131.37,83.2 UC1.AU11
POA_WAKE#: length 75.3
  TOP w0.108: R346.1 v1(222.44,48.88) ; U38.B68 229.03,52.63 228.25,51.85 228.25,51.2 v1(227.84,50.79)
  IN1 w0.089: v1(222.44,48.88) 223.07,49.52 226.07,49.52 227.34,50.79 v1(227.84,50.79)
  IN3 w0.089: v1(211.9,35.88) 211.47,35.45 210.68,35.45 210.56,35.57 166.9,35.57 v1(166.22,36.24)
  BOTTOM w0.108: v1(222.44,48.88) 220.71,47.16 220.71,46.64 220.71,46.64 220.71,46.3 220.71,46.3 220.71,42.89 213.7,35.88 v2(212.76,35.88) v1(211.9,35.88) ; JSEC1.4 166.19,36.27 v1(166.22,36.24)
POWER_SW#_MB: length 302.8
  TOP w0.108: JAPS1.11 160.42,82.91 v1(161.4,83.89) ; v1(193.26,143.11) 193.18,143.19 D7113.1 192.62,144.39 191.68,145.32 SW5.3 ; v1(225.21,46.55) 225.31,46.55 225.74,46.98 C340.2 226.43,46.98 226.5,47.05 R329.2
  IN1 w0.089: v1(182.79,67.3) 183.91,68.42 183.91,73.47 185.93,75.49 185.93,107.02 187.54,108.62 187.54,109.3 187.99,109.76 187.99,128.23 190.13,130.37 190.13,135.83 190.64,136.34 190.64,140.49 v1(193.26,143.11) ; v1(224.01,59.07) 224.54,59.6 229.43,59.6 230.12,58.91 230.98,58.91 231.11,59.04 236.16,59.04 236.64,59.52 236.88,59.52 237.59,60.23 238.14,60.23 239.02,59.35 242.54,59.35 242.89,59.7 244.01,59.7 244.68,59.02 247.25,59.02 247.58,58.69 254.9,58.69 255.39,58.2 258.6,58.2 259.14,57.66 259.14,57.11 259.77,56.48 261.48,56.48 263.4,58.41 v1(270.95,58.41)
  IN2 w0.089: v1(179.14,87.02) 179.36,86.79 179.36,84.49 180.3,83.55 180.3,69.79 v1(182.79,67.3) 183.02,67.07 183.02,64.58 185.45,62.14 186.48,62.14 189.62,59 189.62,58.89 189.62,58.74 191.27,57.09 194.66,57.09 194.76,56.99 194.76,56.99 195.5,56.25 205.48,56.25 206.53,57.29 206.53,58.57 206.97,59.02 212.42,59.02 213.33,58.11 217.74,58.11 218.83,59.19 223.89,59.19 v1(224.01,59.07)
  IN3 w0.089: v1(161.4,83.89) 161.85,84.34 162.76,84.34 163.37,83.73 175.69,83.73 178.09,86.14 178.09,87.21 178.3,87.42 178.73,87.42 v1(179.14,87.02) ; v1(264.18,9.26) 264.18,13.66 270.66,20.14 270.66,40.21 272.8,42.35 272.8,57.2 v2(271.59,58.41) v1(270.95,58.41)
  BOTTOM w0.108: v2(271.59,58.41) v1(270.95,58.41) ; JIOR1.40 178.45,87.73 179.14,87.04 v1(179.14,87.02) ; v1(225.21,46.55) 224.9,46.85 224.9,48.68 224.91,48.69 224.91,49.03 224.42,49.51 224.42,52.72 225.67,53.97 225.67,55.77 225.3,56.14 225.3,57.78 v1(224.01,59.07) ; JLED1.3 v1(264.18,9.26)
POWER_SW_IN#: length 18.1
  TOP w0.108: U38.B67 229.6,53.13 229.72,53.01 229.72,52.42 228.72,51.42 v1(228.66,51.42) ; v1(222.88,46.55) 222.95,46.61 R327.1 ; C343.1 226.6,48.67 226.6,48.2 R329.1 227.33,47.47 227.33,46.79 227.02,46.48 v1(226.91,46.48)
  IN3 w0.089: v1(222.88,46.55) 223.46,47.12 226.27,47.12 v1(226.91,46.48) 229.06,48.64 229.06,51.02 v1(228.66,51.42)
  BOTTOM w0.108: v2(222.88,47.4) v1(222.88,46.55)
PROC_POPIRCOMP: length 8.6
  TOP w0.254: v3(128.33,83.53) 128.77,83.08 128.77,82.63 129.37,82.03 129.37,80.33 v2(128.92,79.87) 128.53,79.49 128.53,76.9 128.74,76.7 RC88.1
  BOTTOM w0.152: v3(128.33,83.53) 128.46,83.53 UC1.AT16
PROC_SELECT#: length 14.1
  BOTTOM w0.076: UC1.C64 101.76,101.96 101.76,103.04 100.11,104.69
  BOTTOM w0.108: 96.2,110.65 96.2,110.49 95.92,110.21 95.92,106.22 97.45,104.69 100.11,104.69 ; 96.2,110.65 v2(96.22,110.65) ; 96.2,110.65 96.2,110.66 96.35,110.81 R9546.1
PROCHOT#_EC: length 2.6
  TOP w0.108: U38.A46 231.25,62.58 v2(230.64,63.18) 230.5,63.33 230.5,63.45 230.33,63.61 230.33,63.62 RC486.1
PROCHOT_GATE: length 4
  TOP w0.108: U37.A61 254.73,51.33 253.73,50.34 253.73,49.99 253.84,49.88 253.84,49.27 253.43,48.86 R9688.2
PS2_CLK_TS: length 20.3
  TOP w0.108: JTP1.7 142.1,60.87 141.84,60.62 141.29,60.62 140.36,59.69 140.36,59.06 142.1,57.32 145.53,57.32 v2(145.81,57.04) 145.88,56.96 145.88,55.79 146.08,55.59 146.34,55.59 146.5,55.44 146.95,55.44 147.02,55.37 147.04,55.37 148.94,53.46 148.94,53.44 149.03,53.35 149.03,51.45 147.46,49.88 JKB1.2
PS2_DAT_TS: length 19.3
  TOP w0.108: JTP1.6 141.6,60.95 141.48,60.83 141.2,60.83 140.15,59.78 140.15,58.97 142.01,57.11 145.1,57.11 145.63,56.58 145.63,55.69 v2(146.16,55.16) 146.95,55.16 148.73,53.37 148.73,51.48 147.63,50.38 JKB1.3
PS_ID: length 35.5
  TOP w0.108: U38.B24 238.26,55.63 238.24,55.6 237.26,55.6 236.96,55.3 v1(236.96,55.19) ; v1(251.78,39.1) 251.89,38.99 PU1.4
  IN3 w0.089: v1(246.95,38.72) 247.24,38.43 250.21,38.43 250.89,39.1 v1(251.78,39.1)
  BOTTOM w0.108: v2(252.08,40.21) 251.78,39.9 v1(251.78,39.1) ; v1(236.96,55.19) 237.46,55.69 241.13,55.69 242.12,54.7 242.12,53.51 242.49,53.15 243.7,53.15 245.55,51.29 245.55,49.26 245.04,48.76 245.04,45.4 243.52,43.87 243.52,42.62 246.95,39.19 v1(246.95,38.72)
PS_USB20_N4: length 1.7
  BOTTOM w0.102: L42.4 20.34,96.53 20.71,96.15 21.14,96.15 21.24,96.25 U6204.11
PS_USB20_P4: length 1.7
  BOTTOM w0.102: U6204.10 21.25,95.75 21.05,95.95 20.71,95.95 20.44,95.68 L42.1
PSID_DISABLE#: length 35.6
  TOP w0.108: v1(250.96,40.93) 250.75,40.93 249.39,39.56 249.39,37.86 248.98,37.45 PR5109.1 ; U37.A37 262.03,59.32 262.22,59.51 262.22,59.9 v1(261.81,60.31)
  IN3 w0.089: v1(258,42) 257.78,42.22 257.17,42.22 255.87,40.93 v1(250.96,40.93)
  BOTTOM w0.108: v1(261.81,60.31) 261.4,59.9 261.4,51.55 262.22,50.73 262.22,45.79 261.68,45.24 261.68,44.59 260.69,43.6 259.78,43.6 v2(259.17,42.99) 258.18,42 v1(258,42)
PWM1_GT: length 32.3
  TOP w0.203: v1(58.79,91.73) 59.09,91.73 59.47,92.11 PU5903.8
  TOP w0.222: v1(69.12,110.22) 69.56,110.66 69.89,110.66 70.16,110.93 PU5801.12
  TOP w0.254: v1(58.79,91.73) 58.79,91.63 PR5914.2
  IN1 w0.254: v1(69.12,110.22) 68.62,110.73 67.92,110.73 67.45,110.27 67.45,105.9 66.15,104.6 61.64,104.6 60.18,103.15 60.18,98.52 59.29,97.63 59.29,93.86 59.57,93.58 59.57,92.52 v1(58.79,91.73)
  BOTTOM w0.254: v2(69.78,108.95) 69.18,109.56 69.18,110.17 v1(69.12,110.22)
PWM_IA: length 45.2
  TOP w0.203: PU5801.22 74.51,112.25 74.85,111.92 75.21,111.92 v1(75.55,111.57)
  IN1 w0.254: v1(109.1,128.41) 109.1,128.46 108.67,128.89 108.27,128.89 107.81,128.44 107.81,127.6 106.67,126.45 106.67,126.09 105.4,124.83 103.29,124.83 v7(103.08,124.63) 102.55,124.09 101.89,124.09 99.91,122.11 98.82,122.11 98.17,121.46 97.28,121.46 94.3,118.48 94.3,117.8 93.74,117.25 93.27,117.25 90.49,114.47 85.79,114.47 85.37,114.88 77.44,114.88 75.55,112.99 v1(75.55,111.57)
PWM_VSA: length 63.7
  TOP w0.222: PU5801.30 74.68,115.45 v1(74.86,115.64)
  TOP w0.254: v1(74.86,115.64) 74.86,116.62 v2(75.17,116.93) ; PU5902.3 123.88,123.39 v1(123.96,123.31)
  IN2 w0.254: v1(99.71,125.72) 99.71,124.51 100.51,123.71 103.16,123.71 103.69,124.24 106.55,124.24 107.27,123.53 113.81,123.53 116.3,126.02 119.59,126.02 122.41,123.2 123.86,123.2 v1(123.96,123.31)
  IN3 w0.254: v1(74.86,115.64) 74.86,119.3 75.8,120.23 83.63,120.23 83.98,119.88 94.23,119.88 98.16,123.8 98.16,124.38 99.49,125.72 v1(99.71,125.72)
PWR_SRC_ON: length 2.7
  TOP w0.254: Q2.4 46.65,107.94 46.98,107.61 v2(46.98,106.41)
RD1_A_DE0: length 6
  TOP w0.108: v1(169.23,52.57) 170.27,53.61 v2(171.66,53.61) 172.07,53.2 RN4111.1 RN25.2
  BOTTOM w0.108: v1(169.23,52.57) 168.68,52.57 168.57,52.46 U6205.6
RD1_A_DE1: length 6.9
  TOP w0.108: RN4108.2 RN4112.1 171.56,51.04 171,51.04 v1(170.5,51.55) 170.01,52.03 168.87,52.03 v2(168.51,52.39)
  BOTTOM w0.108: v1(170.5,51.55) 170.5,51.15 170.39,51.04 169.73,51.04 169.59,50.9 U6205.8
RD1_A_EQ0: length 5.5
  TOP w0.108: v2(165.49,51.93) 165.24,51.68 v1(164.65,51.68) 164.22,52.11 163,52.11 RN4119.1 RN4115.2
  BOTTOM w0.108: v1(164.65,51.68) 164.65,51.42 165.17,50.9 U6205.23
RD1_A_EQ1: length 5.4
  TOP w0.108: v2(165.59,50.18) 164.99,50.78 v1(164.65,50.78) 164.22,51.22 163,51.22 RN4120.1 RN4116.2
  BOTTOM w0.108: U6205.22 165.03,50.4 v1(164.65,50.78)
RD1_A_EQ2: length 4.5
  TOP w0.108: RN4117.2 RN4121.1 163.03,48.55 164.27,48.55 v7(164.73,48.1)
  BOTTOM w0.108: v7(164.73,48.1) 164.73,48.27 165.36,48.9 U6205.19
RD1_B_DE0: length 6.4
  TOP w0.108: RN4109.2 RN4113.1 172.07,46.85 171.74,46.52 170.3,46.52 v2(170.2,46.61) 169.99,46.83 v1(169.99,47.49)
  BOTTOM w0.108: U6205.13 168.57,47.89 168.97,47.49 v1(169.99,47.49)
RD1_B_DE1: length 4.8
  TOP w0.108: v2(169.2,50.53) v1(169.86,50.53) 170.37,50.03 171.56,50.03 RN4114.1 RN4110.2
  BOTTOM w0.108: v1(169.86,50.53) 169.73,50.4 U6205.9
RD1_B_EQ0: length 4.5
  TOP w0.108: v1(169.86,49.52) 169.86,49.06 v2(170.06,48.86) 170.22,49.01 171.56,49.01 RN4125.1 RN4122.2
  BOTTOM w0.108: U6205.11 169.75,49.4 v1(169.86,49.52)
RD1_B_EQ1: length 5.6
  TOP w0.108: v1(164.78,49.9) 164.35,50.33 163,50.33 RN4126.1 RN4123.2
  BOTTOM w0.108: v2(163.38,49.47) 164.35,49.47 v1(164.78,49.9) 164.78,49.9 U6205.21
RD1_B_EQ2: length 6.6
  TOP w0.108: RN4124.2 RN4127.1 162.57,47.71 162.67,47.61 163.97,47.61 164.17,47.41 166.23,47.41 v2(166.43,47.61) v1(167.09,47.61)
  BOTTOM w0.108: U6205.16 167.07,47.63 v1(167.09,47.61)
RD1_REXT: length 3.9
  TOP w0.108: RN31.2 v2(171.89,49.52) v1(170.5,49.52)
  BOTTOM w0.108: U6205.10 169.61,49.9 169.73,50.03 169.99,50.03 v1(170.5,49.52)
RD2_A_DE0: length 5.8
  TOP w0.108: RN4128.2 RN4132.1 172.07,64.89 171.7,65.25 v2(170.86,65.25) v1(169.86,64.25)
  BOTTOM w0.108: U6206.6 169.22,63.61 v1(169.86,64.25)
RD2_A_DE1: length 8.5
  TOP w0.108: v2(166.94,64.38) 169,64.38 169.56,63.82 170.04,63.82 v1(170.5,63.36) 170.5,63.24 170.92,62.81 171.65,62.81 RN4133.1 RN4129.2
  BOTTOM w0.108: v1(170.5,63.36) 170.09,62.95 170.03,62.95 170.03,62.95 169.83,62.95 169.39,62.51 U6206.8
RD2_A_EQ0: length 6
  TOP w0.108: RN4136.2 RN4139.1 163,63.67 164.22,63.67 v1(164.65,63.23)
  BOTTOM w0.108: U6206.23 165,62.51 164.65,62.85 v1(164.65,63.23) 164.17,63.72 v2(163.36,63.72)
RD2_A_EQ1: length 5.7
  TOP w0.108: RN4137.2 RN4140.1 163,62.78 164.14,62.78 v1(164.68,62.24)
  BOTTOM w0.108: v2(163.33,61.76) 164.2,61.76 v1(164.68,62.24) 164.91,62.01 U6206.22
RD2_A_EQ2: length 5.4
  TOP w0.108: v2(165.47,59.73) 165.26,59.53 v1(164.7,59.53) 164.25,59.98 163.03,59.98 RN4141.1 RN4138.2
  BOTTOM w0.108: U6206.19 165.45,60.28 v1(164.7,59.53)
RD2_B_DE0: length 6.3
  TOP w0.108: RN4130.2 RN4134.1 172.07,58.26 171.89,58.08 v2(170.32,58.08) v1(169.23,59.17)
  BOTTOM w0.108: v1(169.23,59.17) 168.84,59.17 168.55,59.46 U6206.13
RD2_B_DE1: length 6.6
  TOP w0.108: RN4131.2 RN4135.1 171.61,61.76 170.75,61.76 v1(169.99,62.52) v2(168.62,63.89)
  BOTTOM w0.108: U6206.9 169.86,62.01 169.99,62.13 v1(169.99,62.52)
RD2_B_EQ0: length 4.4
  TOP w0.108: v1(169.81,61.3) 169.81,61.13 v2(170.24,60.69) 171.56,60.69 RN4145.1 RN4142.2
  BOTTOM w0.108: U6206.11 169.51,61.01 v1(169.81,61.3)
RD2_B_EQ1: length 5.7
  TOP w0.108: RN4143.2 RN4146.1 163.03,61.79 164.2,61.79 v1(164.65,61.33) 164.87,61.54 164.87,61.8 165.21,62.14 v2(165.21,62.68)
  BOTTOM w0.108: v1(164.65,61.33) 164.78,61.33 164.96,61.51 U6206.21
RD2_B_EQ2: length 6.9
  TOP w0.108: RN4144.2 RN4147.1 163.03,59.09 166.99,59.09 v1(167.07,59.17) v2(167.55,59.65)
  BOTTOM w0.108: v1(167.07,59.17) 167.05,59.18 U6206.16
RD2_REXT: length 4.1
  TOP w0.108: RN4107.1 170.65,61.2 170.42,61.43 v1(170.42,61.48) 169.89,62.01 v2(169,62.01)
  BOTTOM w0.108: U6206.10 169.38,61.51 169.64,61.77 170.13,61.77 v1(170.42,61.48)
RED_CRT: length 28.8
  TOP w0.089: U6.M6 83.63,130.33
  TOP w0.108: v1(72.41,131.51) 72.41,132.15 73.25,132.99 74.02,132.99 74.52,132.5 78.34,132.5 80.67,130.17 82.04,130.17 C9915.1 82.87,130.33 83.63,130.33
  BOTTOM w0.108: v1(72.41,131.51) 72.12,131.8 72.12,137.83 72.45,138.16 v2(72.45,140.45) R2745.2 C10.1 L1.1
RED_CRT_L: length 12.3
  BOTTOM w0.108: L1.2 73.71,146.61 C13.1 v2(75.12,146.61) D66.6 79.89,147.54 79,148.43 79,149.67 79.8,150.47 JCRT1.1
REGCTL_PNP10: length 5.1
  TOP w0.203: U21.7 145.75,128.66 145.35,128.26
  TOP w0.508: L27.1 142.37,126.16 144.03,127.83 144.18,127.83 v2(144.18,127.82) 144.18,127.83 144.92,127.83 145.35,128.26
REM_DIODE1_N: length 151.2
  TOP w0.108: C358.2 240.02,48.68 v1(239.84,48.5) ; U38.B13 v1(236,52.57)
  IN4 w0.089: v1(239.84,48.5) 239.84,48.11 239.77,48.04 239.51,48.04 239.42,47.96 239.42,47.32 240.6,46.14 240.6,42.86 238.54,40.81 233.31,40.81 230.18,43.93 227.26,43.93 225.65,45.54 217.93,45.54 217.26,46.22 217.26,46.9 216.98,47.17 213.65,47.17 212.94,47.89 196.46,47.89 192.8,51.55 190.65,51.55 190.1,51 187.97,51 187.34,50.38 183.07,50.38 180.65,52.8 180.65,56.01 179.03,57.63 179.03,58.89 173.09,64.83 173.09,69.89 168.36,74.62 168.36,80.4 168.63,80.67 168.63,83.77 168.81,83.95 168.81,93.68 164.16,98.33 164.16,100.14 162.6,101.7 162.6,102.25 161.82,103.02 161.82,103.61 v1(161.59,103.85)
  BOTTOM w0.108: v1(236,52.57) v2(236,51.79) 236,51.48 236.77,50.71 236.77,49.77 237.17,49.37 238.82,49.37 239.02,49.16 240.12,49.16 240.22,49.06 240.22,48.88 v1(239.84,48.5) ; Q11.2 155.22,105.72 155.66,106.16 155.84,106.16 C370.1 156.71,105.91 161.52,105.91 161.78,105.65 161.78,104.05 v1(161.59,103.85)
REM_DIODE1_P: length 151.4
  TOP w0.108: v2(162.67,104.32) v1(162.2,103.85) ; v1(236.36,50.53) 236.25,50.65 U38.A13 ; v1(239.2,48.5) 239.15,48.55 C358.1
  IN4 w0.089: v1(162.2,103.85) 162.04,103.69 162.04,103.11 162.81,102.34 162.81,101.79 164.37,100.23 164.37,98.42 169.03,93.77 169.03,83.87 168.84,83.68 168.84,80.58 168.57,80.31 168.57,74.71 173.3,69.98 173.3,64.92 179.24,58.98 179.24,57.72 180.87,56.1 180.87,52.89 183.16,50.59 187.25,50.59 187.88,51.22 190.01,51.22 190.56,51.77 192.89,51.77 196.55,48.1 213.03,48.1 213.74,47.39 217.07,47.39 217.49,46.98 217.49,46.29 218.02,45.76 225.74,45.76 227.31,44.18 230.23,44.18 233.4,41.02 238.45,41.02 240.38,42.95 240.38,46.05 239.2,47.23 v1(239.2,48.5)
  BOTTOM w0.108: Q11.3 153.22,106.67 154.17,107.62 Q11.1 155.01,106.69 155.23,106.46 C370.2 156.72,106.15 161.62,106.15 162.02,105.75 162.02,104.03 v1(162.2,103.85) ; v1(239.2,48.5) 238.57,49.14 237.26,49.14 237.07,49.14 236.53,49.67 236.53,50.36 v1(236.36,50.53)
REM_DIODE2_N: length 188
  TOP w0.108: v1(236.66,52.57) 236.5,52.4 U38.B14 ; v1(240.85,50.41) 241.67,49.59 C359.2
  IN4 w0.089: v1(130.53,140.68) 130.53,139.17 133.46,136.23 135.91,136.23 138.51,133.63 143.21,133.63 144.06,134.49 146.44,134.49 147.16,133.77 147.79,133.77 149.26,132.3 149.87,132.3 159.06,123.11 159.06,122.62 162.28,119.4 162.93,119.4 174.7,107.63 176.6,107.63 177.23,107.01 177.23,102.06 181.89,97.39 181.89,87.87 181.64,87.61 181.64,76.06 177.72,72.14 177.72,65.75 184.73,58.75 184.73,58.28 185.87,57.13 186.28,57.13 189.05,54.36 199.13,54.36 203.09,50.39 217.96,50.39 218.47,49.88 226.05,49.88 226.39,49.54 240.47,49.54 240.85,49.92 v1(240.85,50.41)
  BOTTOM w0.108: v1(236.66,52.57) 237.88,51.35 237.88,50.58 238.14,50.33 239.1,50.33 239.91,51.14 v2(239.96,51.14) 240.12,51.14 v1(240.85,50.41) ; JGFX1.7 130.2,141.01 v1(130.53,140.68)
REM_DIODE2_P: length 187.5
  TOP w0.108: v1(237.2,50.38) 236.96,50.38 236.84,50.51 236.84,50.63 236.75,50.73 U38.A14 ; v1(240.24,50.41) 240.8,49.85 C359.1
  IN4 w0.089: v1(130.97,140.22) 130.74,139.99 130.74,139.26 133.55,136.45 136,136.45 138.6,133.85 143.12,133.85 143.97,134.7 146.53,134.7 147.25,133.99 147.88,133.99 149.35,132.51 149.96,132.51 159.28,123.2 159.28,122.71 162.33,119.66 162.98,119.66 174.79,107.85 176.69,107.85 177.44,107.1 177.44,102.15 182.11,97.48 182.11,87.78 181.86,87.52 181.86,75.97 177.94,72.05 177.94,65.84 184.94,58.84 184.94,58.37 185.96,57.35 186.37,57.35 189.14,54.57 199.22,54.57 203.15,50.64 218.02,50.64 218.56,50.1 226.14,50.1 226.48,49.75 240.36,49.75 240.49,49.88 240.49,50.17 v1(240.24,50.41)
  BOTTOM w0.108: JGFX1.5 130.7,141.1 130.97,140.83 v1(130.97,140.22) ; v1(237.2,50.38) 237.04,50.53 237.04,51.37 237.2,51.52 237.38,51.52 237.65,51.25 237.65,50.49 238.29,49.85 v2(238.39,49.85) 238.64,50.1 239.2,50.1 239.77,50.67 239.98,50.67 v1(240.24,50.41)
REM_DIODE3_N: length 110.6
  TOP w0.108: C9460.2 237.95,49.72 237.95,49.72 238.3,50.07 v1(238.3,50.79) 238.16,50.79 238.02,50.66 238.02,50.21 237.94,50.14 237.76,50.14 237.62,50.28 237.62,50.7 237.25,51.07 U38.A15
  IN3 w0.089: v1(164.45,58.03) 164.72,57.76 165.2,57.76 165.29,57.85 165.29,57.94 165.2,58.03 165.03,58.03 164.91,58.15 164.91,58.28 165.03,58.41 165.62,58.41 165.97,58.05 172.48,58.05 173.15,57.38 175.97,57.38 177.23,56.12 177.23,53.68 178.3,52.61 178.3,52.61 180.75,50.17 184.17,50.17 185.04,51.04 187.06,51.04 187.8,51.79 188.45,51.79 188.91,52.25 188.91,52.77 189.17,53.03 199.38,53.03 202.67,49.74 217.02,49.74 221.17,53.89 228.46,53.89 228.86,53.48 230.8,53.48 231.16,53.84 233.93,53.84 234.39,53.37 234.39,52.32 234.76,51.95 238.24,51.95 238.73,51.46 238.73,51.3 238.65,51.22 238.26,51.22 237.81,51.68 237.55,51.68 237.42,51.55 237.42,51.4 238.03,50.79 v1(238.3,50.79)
  BOTTOM w0.108: 160.79,64.86 v6(160.77,64.86) ; 160.79,64.86 160.79,62.53 162.21,61.11 162.21,59.99 163.53,58.66 163.91,58.66 163.99,58.58 163.99,58.13 164.09,58.03 v1(164.45,58.03) ; 160.79,64.86 160.79,65.32 158.12,67.98 157.9,67.98 C9461.1 157.34,68.08 157.14,68.08 156.78,68.44 156.78,68.61 156.65,68.74 156.42,68.74 156.28,68.6 Q3603.2
REM_DIODE3_P: length 110.3
  TOP w0.108: C9460.1 238.19,49.44 238.19,49.62 238.54,49.97 238.54,50.38 v1(238.95,50.79) ; v1(237.32,52.59) 237.5,52.42 U38.B16
  IN3 w0.089: v1(238.95,50.79) 238.95,51.55 238.33,52.17 234.85,52.17 234.61,52.41 234.61,53.46 234.02,54.05 231.07,54.05 230.71,53.7 228.95,53.7 228.55,54.1 221.08,54.1 216.94,49.96 202.76,49.96 199.47,53.25 189.08,53.25 188.7,52.86 188.7,52.34 188.36,52 187.89,52 187.89,52 187.71,52 186.97,51.26 184.95,51.26 184.08,50.38 180.84,50.38 178.39,52.83 178.39,52.83 177.44,53.77 177.44,56.21 176.06,57.6 173.24,57.6 172.57,58.27 166.06,58.27 165.7,58.64 v1(164.45,58.64)
  BOTTOM w0.108: v1(237.32,52.59) 238.95,50.97 v1(238.95,50.79) ; 161.02,63.11 161.02,65.42 158.22,68.22 158.07,68.22 C9461.2 157.36,68.31 157.24,68.31 156.99,68.56 156.99,68.7 156.74,68.95 156.4,68.95 156.28,69.08 Q3603.1 155.62,69.59 154.67,68.64 Q3603.3 ; 161.02,63.11 161.02,62.62 162.44,61.2 162.44,60.08 163.61,58.92 164.02,58.92 164.3,58.64 v1(164.45,58.64) ; 161.02,63.11 v6(161.05,63.11)
REM_DIODE4_N: length 72.4
  TOP w0.108: U38.A16 237.97,51.26 238.46,51.75 238.71,51.75 239.1,52.13 239.74,52.13 239.82,52.05 239.82,51.89 239.71,51.78 239.71,51.63 239.84,51.5 C361.2 240.7,51.5 241.49,50.71 v1(241.49,50.41)
  BOTTOM w0.108: Q14.2 196.72,23.77 198.26,25.31 199.17,25.31 C373.2 199.83,25.31 200.56,25.31 200.97,25.72 204.11,25.72 v2(204.33,25.93) 204.55,25.72 209.95,25.72 210.1,25.72 211.08,26.71 222.53,26.71 226.77,30.94 226.77,34.21 226.78,34.21 226.78,34.22 228.49,35.94 230.04,35.94 232.05,37.95 236.25,37.95 236.91,38.6 236.91,40.04 237.63,40.76 239.06,40.76 240.35,42.04 240.35,46.21 239.7,46.85 239.7,47.5 241.87,49.67 241.87,49.92 241.82,49.98 241.61,49.98 241.17,49.54 241.01,49.54 240.9,49.65 240.9,49.82 v1(241.49,50.41)
REM_DIODE4_P: length 72.7
  TOP w0.108: v1(242.12,50.41) 240.9,51.64 240.9,51.94 C361.1 239,52.36 238.62,51.98 U38.B17
  BOTTOM w0.108: Q14.1 196.71,21.87 197.66,22.82 Q14.3 197.91,24.61 198.36,25.06 199.22,25.06 C373.1 199.8,25.08 200.66,25.08 201.06,25.48 201.83,25.48 v2(202.08,25.24) 202.33,25.48 209.85,25.48 210.19,25.48 211.18,26.47 222.44,26.47 222.63,26.47 227.01,30.85 227.01,34.11 227.01,34.11 227.01,34.13 228.59,35.7 230.14,35.7 232.15,37.71 236.35,37.71 237.15,38.5 237.15,39.94 237.72,40.52 239.16,40.52 240.58,41.94 240.58,46.3 239.94,46.95 239.94,47.4 242.12,49.59 v1(242.12,50.41)
RES_BIAS: length 3.7
  TOP w0.108: U21.12 147.75,129.08 148.12,128.71 149.26,128.71 R185.2 v2(150.53,128)
RESET_OUT#: length 444.1
  TOP w0.108: U38.B39 236,60.61 v1(236.5,60.11) ; RC594.1 137.79,113.56 137.67,113.43 RC404.1 136.97,113.54 v1(136.97,113.55) ; CC285.2 238.44,67.96 238.31,68.09 R373.2 237.75,68.52 v1(237.42,68.19)
  IN1 w0.089: v1(249.57,25.49) 243.75,25.49 242.91,24.65 229.79,24.65 229.33,24.19 216.16,24.19 212.67,27.67 212.67,28.48 211.77,29.38 209.82,29.38 209.18,28.74 199.11,28.74 197.62,30.23 188.64,30.23 184.67,34.2 175.87,34.2 174.71,35.37 169.54,35.37 166.34,38.57 166.34,40.94 159.86,47.42 159.86,62.57 165.14,67.85 165.14,94.87 164.97,95.04 164.97,100.61 164.5,101.08 164.5,102.09 164.69,102.27 164.69,102.56 165.52,103.4 165.52,105.14 165.98,105.6 165.98,115.88 152.87,128.99 149.92,128.99 148.49,130.42 148.49,133.36 147.36,134.49 142.99,134.49 142.83,134.32 140,134.32 136.31,138.02 136.31,139.2 133.4,142.11 131.57,142.11 131.49,142.2 112.08,142.2 111.59,142.68 108.52,142.68 106.72,140.88 106.72,138.62 105.1,137.01 104.61,137.01 103.15,135.55 101.2,135.55 100.39,134.73 94.94,134.73 93.62,136.04 91.65,136.04 90.11,137.58 85.09,137.58 81.46,133.95 81.46,132.48 80.03,131.05 78.29,131.05 v1(77.63,130.39) 77.63,129.35 78.35,128.63 78.35,125.98 80.25,124.08 81.86,124.08 85.43,120.51 91.5,120.51 93.25,122.26 94.83,122.26 96.59,124.02 96.59,125.96 101.08,130.44 103.79,130.44 105.6,132.25 109.99,132.25 111.07,131.17 113.43,131.17 115.3,133.04 124.3,133.04 127.06,130.27 132.39,130.27 132.68,129.98 135.72,129.98 137.72,127.98 137.72,126.42 137.16,125.86 136.63,125.86 136.01,125.25 136.01,124.41 137.82,122.6 137.82,114.4 v1(136.97,113.55)
  IN4 w0.089: v1(236.5,60.11) 236.1,60.51 236.1,60.89 237.47,62.26 237.47,63.53 238.59,64.65 238.59,67.03 v1(237.42,68.19)
  BOTTOM w0.108: RC378.1 77.65,130.39 v1(77.63,130.39) ; v1(249.57,25.49) 249.26,25.79 v2(249.26,26.61) 249.55,26.89 249.55,34.24 249.1,34.69 249.1,42.34 248.51,42.93 248.51,46.44 248.72,46.65 248.72,50.39 249.06,50.74 249.06,53.25 248.69,53.62 248.69,56.02 247.91,56.79 247.91,58.41 247,59.32 247,60.26 244.1,63.16 244.1,63.62 240.55,67.17 238.44,67.17 v1(237.42,68.19)
RESET_OUT#_R: length 8.7
  BOTTOM w0.108: JXDP1.47 80.3,123.89 79.47,124.71 CC268.1 78.67,125.51 78.4,125.79 78.4,126.61 RC377.2 77.89,127.12 77.89,128.47 RC378.2 78.2,128.97 v2(77.33,128.97)
RI1#: length 148.5
  TOP w0.108: RP4806.9 263.96,26.91 264.33,27.27 264.33,27.7 264.22,27.81 U6202.41 264.22,28.83 v1(264.32,28.94)
  IN1 w0.089: v1(179.14,93.84) 177.82,92.52 177.82,53.2 178.87,52.15 178.87,49.71 183.55,45.03 226,45.03 231.51,39.52 231.51,38.93 233.35,37.08 252.88,37.08 252.96,37 256.07,37 256.24,37.18 257.55,37.18 258.49,36.25 258.49,32.21 259.88,30.82 259.88,29.7 260.66,28.93 262.64,28.93 263.05,29.34 263.92,29.34 v1(264.32,28.94)
  BOTTOM w0.108: v1(179.14,93.84) 178.73,94.25 178.37,94.25 178.35,94.23 JIOR1.27 ; v1(264.32,28.94) 264.32,28.14 v2(264.46,28)
RI2: length 20.5
  TOP w0.108: RP4804.2 256.61,41.09 v1(257.34,41.82) ; U6202.43 265.22,28.63 v1(265.52,28.93)
  BOTTOM w0.108: v1(265.52,28.93) 265.02,28.93 263.96,30 v2(263.96,33.15) 263.96,34.3 262.57,35.69 260.3,35.69 259.33,36.65 259.33,39.82 v1(257.34,41.82)
RI3: length 221.4
  TOP w0.108: v1(125.11,140.76) 125.11,139.39 124.85,139.13 U6203.19 ; v1(256.61,39.44) RP4804.9 256.61,38.01 256.73,37.88 257.26,37.88 259.27,35.88 U6202.18
  IN3 w0.089: v1(249.92,39.44) 250.54,40.06 255.99,40.06 v1(256.61,39.44)
  IN4 w0.089: v1(249.92,39.44) 248.03,39.44 246.68,40.79 246.68,41.83 245.17,43.34 245.17,44.08 244.82,44.43 244.82,49.45 245.1,49.72 245.1,50.54 243.62,52.01 239.73,52.01 239.61,52.13 230.31,52.13 229.38,53.07 224.35,53.07 223.42,54 220.09,54 217.48,56.61 208.84,56.61 208.22,55.99 204.98,55.99 204.47,55.48 189.51,55.48 186.59,58.4 186.59,59.29 178.84,67.04 178.84,71.48 183.14,75.78 183.14,79.43 184.52,80.82 184.52,102.45 182.54,104.43 180.01,104.43 178.55,105.89 178.55,107.26 176.84,108.98 174.94,108.98 163.35,120.56 162.7,120.56 160.18,123.09 160.18,123.68 153.22,130.63 153.22,131.84 150.11,134.96 147.84,134.96 147.19,135.61 143.6,135.61 142.74,134.75 138.98,134.75 136.25,137.48 134.78,137.48 132.45,139.81 132.45,139.94 130.65,141.74 126.08,141.74 v1(125.11,140.76)
  BOTTOM w0.108: v2(256.98,38.82) 256.61,39.2 v1(256.61,39.44)
RI3_T: length 21.2
  TOP w0.108: v1(130.11,147.04) 130.11,147.05 129.27,147.05 128.75,146.53 U6203.4
  IN2 w0.089: JSER1.9 116.61,149.06 122.21,149.06 124.52,146.75 129.82,146.75 v1(130.11,147.04)
  BOTTOM w0.108: v2(130.11,146.37) v1(130.11,147.04)
RING2:
  vias: v1(36.9,124.6) v2(37.27,124.02) v4(36.9,125.37)
RING2_D: length 15.3
  IN2 w2.032: 247.31,107.84 249.21,109.74 256.88,109.74 260.36,113.22 JUAJ1.3
  vias: v1(242.4,107.68) v1(242.45,108.29) v1(242.43,107.07) v1(242.45,106.44) v2(241.84,108.75)
RING2_L: length 30
  IN2 w1.27: 34.81,125.95 35.55,126.68 35.55,129.78 34.35,130.98 34.35,140.2 33.49,141.06 19.8,141.06
  vias: v1(19.42,140.09) v1(34.02,125.49) v2(34.63,123.94) v4(19.85,139.46) v4(34.02,124.73)
ROT_LCK#: length 183
  TOP w0.108: JCSW1.3 125,63.25 125.51,63.76 127.1,63.76 128.87,61.99 132.6,61.99 133.46,61.13 v2(134.4,61.13) 135.06,61.13 135.93,61.99 137.73,61.99 141.14,65.4 142.48,65.4 142.93,65.85 143.6,65.85 144.01,66.27 148.29,66.27 v1(148.83,65.72) ; R9421.2 R9420.1 250.81,58.71 250.59,58.49 248.53,58.49 247.93,57.9 247.93,57.1 248.35,56.69 248.35,53.63 249.2,52.78 249.2,52.3 249.96,51.54 249.96,50.37 251.21,49.12 251.21,48.25 251.28,48.18 251.28,46.5 251.74,46.05 251.74,44.53 252.83,43.44 252.83,42.31 v1(252.54,42.03)
  IN1 w0.089: v1(148.83,65.72) 149.66,65.72 150.75,64.63 153.22,64.63 158.05,59.8 158.05,47.12 159.86,45.31 v1(159.86,45.04)
  IN2 w0.089: v1(159.86,45.04) 161.83,45.04 162.19,45.4 177.37,45.4 v1(177.95,44.82) 178.71,44.82 180.73,42.8 203.48,42.8 204.19,43.52 220.01,43.52 223.45,40.08 228.06,40.08 228.59,40.6 232.28,40.6 233.27,39.61 239.84,39.61 241.74,41.52 252.03,41.52 v1(252.54,42.03)
  BOTTOM w0.108: v1(177.95,44.82) 176.83,45.94 172.3,45.94 172.15,46.09 172.15,46.62 172.27,46.75 JSH1.15
ROT_LCK#_R: length 18.8
  TOP w0.108: v1(259.78,57.04) 259.39,57.04 259.28,57.14 U37.B45 ; v1(247.46,59.45) 248.17,58.74 249.77,58.74 R9420.2
  IN1 w0.089: v1(259.78,57.04) 259.37,57.45 259.37,57.68 258.67,58.38 255.46,58.38 254.97,58.87 248.04,58.87 v1(247.46,59.45)
  BOTTOM w0.108: v2(260.13,56.34) 260.13,56.69 v1(259.78,57.04)
RSVD53: length 11.9
  TOP w0.076: T7141.1 v3(113.85,100.47)
  IN3 w0.076: v3(113.85,100.47) 114.16,100.78 120.04,100.78 120.46,100.36 120.46,97.37 120.28,97.19 v3(119.76,97.19)
  BOTTOM w0.076: UC1.K32 119.64,97.32 v3(119.76,97.19)
RSVD54: length 14.6
  TOP w0.076: v3(108.01,89.02) T7142.1
  IN4 w0.076: v3(108.01,89.02) 108.01,88.4 109.07,87.34 119.67,87.34 v3(120.08,87.75)
  BOTTOM w0.076: v3(120.08,87.75) 119.72,87.39 UC1.AK32
RSVD_TP1: length 6.6
  TOP w0.076: T7115.1 140.02,81.86 v3(139.55,81.39)
  BOTTOM w0.076: UC1.AY4 136.21,80.95 136.21,80.53 136.43,80.31 136.43,79.87 136.69,79.6 137.58,79.6 139,81.01 139.17,81.01 v3(139.55,81.39)
RSVD_TP2: length 4.3
  TOP w0.076: v3(138.99,81.39) 138.35,82.03 T7116.1
  BOTTOM w0.076: v3(138.99,81.39) 138.71,81.11 138.71,80.96 137.51,79.77 137.05,79.77 UC1.BB3
RSVD_TP3: length 10.2
  TOP w0.076: v3(140.34,81.4) 139.98,81.03 137.78,81.03 137.7,81.12 T7114.1
  BOTTOM w0.076: v3(140.34,81.4) 140.34,81.39 139.61,80.66 139.11,80.66 137.72,79.27 136.13,79.27 UC1.BB5
RSVD_TP4: length 2.3
  TOP w0.076: v3(135.98,82) 135.47,82.51 T7112.1
  BOTTOM w0.076: UC1.AU5 135.75,82.63 135.75,82.23 v3(135.98,82)
RSVD_TP5: length 1.7
  TOP w0.076: T7113.1 134.83,83.58 v3(134.73,83.58)
  BOTTOM w0.076: UC1.AT5 134.91,83.58 v3(134.73,83.58)
RSVD_TP6: length 4.5
  BOTTOM w0.076: UC1.BB68 98.98,79.92 98.74,79.68 98.74,79.62 97.62,78.5 97.62,77.94 97.5,77.81 T7108.1
RSVD_TP7: length 7.3
  BOTTOM w0.076: 96.18,74.84 96.18,78.35 96.66,78.83 97.32,78.83 98.33,79.83 UC1.BB69
  BOTTOM w0.108: T7109.1 96.18,74.74 96.18,74.84
RSVD_TP8: length 2.9
  TOP w0.076: v3(130.15,86.69) 129.79,86.33 129.79,84.98 T7110.1
  BOTTOM w0.076: v3(130.15,86.69) 130.15,86.97 UC1.AK13
RSVD_TP9: length 2.7
  TOP w0.076: T7111.1 132.65,87.24 131.46,87.24 v3(131.07,86.86)
  BOTTOM w0.076: UC1.AK12 131.07,87.25 v3(131.07,86.86)
RSVD_TP10: length 4.7
  BOTTOM w0.076: UC1.AW71 97.09,81.72 97.09,81.68 96.64,81.23 96.4,81.23 96.16,80.99 95.26,80.99 93.66,79.39
  BOTTOM w0.108: 93.66,79.39 T7117.1
RSVD_TP11: length 7.6
  BOTTOM w0.076: 93.66,78.83 93.99,78.83 95.03,79.87 95.69,79.87 96.05,80.23 96.4,80.23 97.05,80.87 97.35,80.87 UC1.AW70
  BOTTOM w0.108: 93.66,78.83 92.09,78.83 T7118.1
RSVD_TP12: length 8.6
  BOTTOM w0.076: UC1.BA70 96.53,79.4 95.22,79.4 94.19,78.37 93.66,78.37
  BOTTOM w0.108: 93.66,78.37 91.32,78.37 T7119.1
RSVD_TP13: length 5.5
  BOTTOM w0.076: UC1.BA68 98,80.22 98,79.79 97.24,79.03 96.38,79.03 95.67,78.32 T7120.1
RTS1#: length 156.2
  TOP w0.108: v1(261.99,25.31) 262.32,25.31 262.47,25.46 262.47,26.39 R9395.1 262.23,27.04 262.26,27.04 262.49,27.27 262.49,27.6 262.72,27.82 U6202.38
  IN1 w0.089: v1(261.99,25.31) 261.15,26.15 260.51,26.15 259.12,27.55 257.87,27.55 254.73,30.69 251.58,30.69 251.27,30.38 247.78,30.38 245.58,28.18 241.67,28.18 240.92,28.93 235.63,28.93 233.98,27.27 229.51,27.27 228.28,26.04 219.98,26.04 213.89,32.13 190.45,32.13 188.15,34.43 188.15,38.9 177.79,49.26 177.79,51.7 176.74,52.75 176.74,57.39 176.35,57.78 176.35,76.48 175.98,76.86 175.98,83.55 176.42,84 176.42,94.64 v1(178.53,96.74)
  BOTTOM w0.108: v1(178.53,96.74) 178.52,96.73 JIOR1.22 ; v1(261.99,25.31) 261.99,25.59 v2(261.5,26.07)
RTS2: length 2.4
  TOP w0.108: R9431.1 268.03,27.45 v1(267.9,27.57) 267.72,27.76 U6202.48
  BOTTOM w0.108: v2(268.57,28.23) v1(267.9,27.57)
RTS3: length 228.4
  TOP w0.108: v1(122.47,145.66) 122.25,145.44 U6203.14 ; v1(260.28,33.38) U6202.23 258.77,33.38 258.76,33.39 R9429.1
  IN3 w0.089: v1(260.28,33.38) 256.13,33.38 255.48,34.02 251.55,34.02 v1(250.54,35.03)
  IN4 w0.089: v1(250.54,35.03) 250.92,35.4 250.92,36.58 250.67,36.82 250.67,39.56 250.17,40.06 249.06,40.06 245.64,43.48 245.64,44.46 245.29,44.81 245.29,49.16 245.6,49.47 245.6,50.64 243.8,52.45 239.93,52.45 239.07,53.31 237.06,53.31 236.18,54.19 231.56,54.19 230.86,53.5 224.6,53.5 223.67,54.43 220.27,54.43 217.66,57.04 208.55,57.04 207.93,56.42 204.58,56.42 204.07,55.91 189.69,55.91 187.02,58.58 187.02,59.47 179.27,67.22 179.27,71.3 183.57,75.6 183.57,79.25 184.95,80.63 184.95,102.63 182.72,104.86 180.19,104.86 178.99,106.07 178.99,107.44 177.02,109.41 176.56,109.41 172.07,113.91 170.62,113.91 163.53,120.99 162.88,120.99 160.61,123.27 160.61,123.85 153.83,130.63 153.83,131.97 150.41,135.39 148.17,135.39 147.52,136.04 139.49,136.04 134.26,141.27 134.26,141.55 133.33,142.48 132.83,142.48 131.65,143.66 124.47,143.66 v1(122.47,145.66)
RTS3_T: length 9.9
  TOP w0.108: U6203.9 125.5,145.26 123.81,146.95 121.09,146.95 v2(120.76,147.28) 120.58,147.46 JSER1.7
RUN_ON: length 368.6
  TOP w0.108: UC13.4 250.98,46.41 251.04,46.48 251.04,48.12 251,48.17 251,49.03 249.75,50.28 249.75,51.46 248.99,52.21 248.99,52.49 248.32,53.16 v1(247.8,53.16) ; v1(207.88,58.33) 207.73,58.49 U46.5 ; v1(65.54,142.21) 65.54,142.21 65.54,141.09 PR5719.1 ; R9586.1 242.38,43.73 242.38,44.62 R9685.1 242.38,45.53 242.38,46.42 242.5,46.55 R9585.1 242.89,46.09 242.83,46.04 R9587.2 243.28,45.26 243.96,45.26 244.28,45.58 Q5.2 246.21,45.58 246.37,45.73 246.37,46.52 246.52,46.67 248.02,46.67 248.24,46.9 248.24,47.47 248,47.71 247.26,47.71 247.03,47.94 247.03,50.19 246.57,50.65 246.57,55.43 246.02,55.98 v1(246.02,56.88) ; U45.3 187.41,86.96 v1(187.41,86.97)
  IN1 w0.089: v1(186.03,49.75) 185.63,49.35 185.25,49.35 184.9,49.7 184.9,60.52 179.63,65.79 179.63,78.32 182.05,80.75 182.05,81.78 v1(182.69,82.41)
  IN2 w0.089: v1(177.1,121.43) 176.69,121.02 173.68,121.02 173.59,120.94 167.32,120.94 165.08,123.18 163.13,123.18 162.25,124.05 162.25,124.78 161.65,125.38 161.65,128.43 160.66,129.42 160.66,130.09 159.45,131.3 159.45,135.37 158,136.82 157.11,136.82 156.62,137.31 147.44,137.31 147.44,137.31 147.29,137.31 147.29,137.31 145.64,137.31 145.48,137.15 142.3,137.15 140.78,138.67 139.51,138.67 133.67,144.51 105.09,144.51 104.53,145.07 95.92,145.07 94.85,144.01 86.17,144.01 85.41,144.77 80.07,144.77 79.18,143.88 67.24,143.88 65.57,142.21 v1(65.54,142.21) ; v1(246.02,56.88) 245.25,57.66 241.6,57.66 240.85,58.41 238.94,58.41 238.01,59.34 232.32,59.34 232.28,59.3 232.11,59.3 231.89,59.09 229.56,59.09 228.87,59.77 225.28,59.77 224.18,58.67 223.85,58.67 223.5,59.01 218.9,59.01 217.82,57.93 213.26,57.93 212.35,58.84 211.44,58.84 v1(210.88,58.28) 210.32,58.84 208.39,58.84 v1(207.88,58.33)
  IN3 w0.089: v1(166.83,80.58) 166.84,80.58 166.84,80.58 167.27,80.58 168.41,81.72 174.73,81.72 176.49,83.48 181.62,83.48 v1(182.69,82.41) ; v1(186.03,49.75) 186.03,48.18 186.41,47.79 193.5,47.79 194,47.3 209.2,47.3 v1(209.88,46.62)
  IN4 w0.089: v1(177.1,121.43) 177.1,121.27 177.99,120.38 181.29,120.38 183.32,118.35 183.32,116.45 183.83,115.94 184.47,115.94 187.39,113.02 187.39,108.95 190.56,105.78 v1(190.59,105.78) ; v1(246.02,56.88) 247.18,55.73 247.18,53.93 247.8,53.31 v1(247.8,53.16)
  BOTTOM w0.108: v1(186.03,49.75) 186.12,49.83 R717.1 ; PR5610.1 166.56,74.66 165.57,75.65 165.57,79.31 v1(166.83,80.58) ; v1(210.88,58.28) 210.66,58.06 210.66,47.4 v1(209.88,46.62) ; v1(182.69,82.41) 183.1,82 183.49,82 187.41,85.92 v1(187.41,86.97) 188.02,87.58 188.02,94.19 189.22,95.39 189.56,95.39 189.97,94.99 189.97,93.88 190.57,93.28 190.91,93.28 191.15,93.52 191.15,103.41 v2(190.59,103.98) v1(190.59,105.78)
RUN_ON#: length 3.1
  TOP w0.108: Q5.6 246.68,46.23 246.59,46.15 246.59,45.66 246.68,45.58 Q5.5 247.94,45.58 248.02,45.5 R36.1
RUN_ON_EC: length 30.3
  TOP w0.108: v1(250.26,44.76) 250.33,44.69 UC13.2 ; v1(233.82,52.57) 234,52.39 U38.B9 ; v2(241.93,47.11) 242.58,47.11 R9585.2 242.89,48.4 v1(242.25,49.04)
  IN1 w0.089: v1(242.25,49.04) 240.86,49.04 239.84,50.06 239.84,51.3 239.46,51.67 234.71,51.67 v1(233.82,52.57)
  IN3 w0.089: v1(250.26,44.76) 250.66,45.16 250.66,45.54 250.42,45.78 247.27,45.78 246.81,45.31 241.41,45.31 v1(241.13,45.03)
  IN4 w0.089: v1(241.13,45.03) 242.25,46.15 v1(242.25,49.04)
RUNPWROK: length 286
  TOP w0.108: U38.B26 238.34,56.63 238.13,56.42 237.82,56.42 v1(237.63,56.22) ; v1(62.07,114.57) 61.81,114.83 v2(61.36,114.83) 61.17,114.64 61.17,114.21 v1(60.72,113.75) 60.72,112.95 59.87,112.11 59.49,112.11 v1(59.2,112.4) ; v1(246.95,43.68) 246.24,44.39 244.13,44.39 R35.2 244.08,44.82 244.19,44.93 Q5.3 ; v1(254.09,43.41) 255,44.32 255,45.99 255.15,46.14 CC282.2 255.46,46.6 255.97,47.11 257.35,47.11 258.03,47.79 U37.A4 ; v1(243.27,55.74) 243.52,56 CC284.2 243.98,55.61 244.16,55.44 245.29,55.44 245.5,55.23 245.65,55.23 246.36,54.53 246.36,50.56 246.82,50.1 246.82,47.77 247.29,47.3 v1(247.83,47.3)
  IN1 w0.089: v1(247.83,47.3) 247.83,44.56 v1(246.95,43.68)
  IN2 w0.089: v1(247.83,47.3) 247.25,46.72 244.94,46.72 239.71,41.5 233.6,41.5 227.69,47.41 206.49,47.41 203.27,50.63 196.78,50.63 193.95,47.8 190.76,47.8 190.32,47.35 183.61,47.35 176.24,54.73 176.24,56.14 175.01,57.37 173.24,57.37 170.1,60.51 169.73,60.51 165.54,64.71 158.1,64.71 157.42,65.39 152.43,65.39 150.17,63.13 147.14,63.13 146.01,62 145.79,62 145.61,61.82 144.66,61.82 143.93,62.55 135.26,62.55 133.46,64.35 118.16,64.35 117.53,63.72 107.42,63.72 85.71,85.44 85.71,86.05 81.95,89.82 74.75,89.82 72.81,91.76 72.81,93.29 70.29,95.8 70.29,105.62 64.52,111.39 64,111.39 v1(63.58,111.82)
  IN3 w0.089: v1(254.09,43.41) 253.54,43.96 247.23,43.96 v1(246.95,43.68)
  IN4 w0.089: v1(63.58,111.82) 62.07,113.33 v1(62.07,114.57)
  BOTTOM w0.108: v1(63.58,111.82) 63.37,111.82 63.11,112.08 UC6.4 ; UC6.13 60.67,113.71 v1(60.72,113.75) ; UC6.10 60.3,111.58 59.78,112.1 59.49,112.1 v1(59.2,112.4) ; v1(243.27,55.74) 242.36,56.65 239.85,56.65 239.43,56.22 v1(237.63,56.22) ; v1(62.07,114.57) 62.02,114.52 UC6.1
RXD1: length 145.9
  TOP w0.108: U6202.35 261.22,29.03 v1(260.92,29.33)
  IN1 w0.089: v1(179.14,96.74) 179.14,96.45 179.61,95.98 179.61,82.69 179.46,82.55 179.46,79.99 178.33,78.86 178.33,60.74 180.62,58.45 180.62,48.65 183.77,45.5 226.34,45.5 230.29,41.54 231.03,41.54 232.43,40.14 232.43,39.26 234.15,37.55 249.08,37.55 249.46,37.93 257.47,37.93 259.38,36.01 259.38,31.98 260.4,30.96 260.4,29.85 v1(260.92,29.33)
  BOTTOM w0.108: v1(260.92,29.33) 261.2,29.6 v2(261.87,29.6) ; v1(179.14,96.74) 179.14,96.88 178.79,97.23 JIOR1.21
RXD2: length 3.2
  TOP w0.108: U6202.45 266.22,29.16 v1(266.76,29.71)
  BOTTOM w0.108: v1(266.76,29.71) T6354.1
RXD3: length 242.8
  TOP w0.108: U6202.20 259.05,34.88 257.75,36.18 v1(257.68,36.18) ; v1(123.89,140.76) 123.89,140.13 123.75,139.99 123.75,139.66 122.9,138.81 U6203.16
  IN3 w0.089: v1(257.68,36.18) 257.53,36.03 255.64,36.03 255.46,36.21 v1(252.33,36.21)
  IN4 w0.089: v1(252.33,36.21) 252.18,36.37 252.18,39.69 251.37,40.5 251.37,41.09 251.13,41.33 249.91,41.33 247.82,43.42 247.82,44.04 247.2,44.65 247.2,48.76 247.47,49.02 247.47,50.79 246.43,51.83 246.43,53.19 246.37,53.26 246.37,53.26 246.02,53.6 245.4,53.6 245.02,53.98 241.87,53.98 241.83,53.94 240.14,53.94 239.37,54.71 239.37,55.57 237.7,57.23 233.89,57.23 232.73,56.06 231.09,56.06 230.68,55.65 229.91,55.65 229.78,55.52 226.44,55.52 225.65,56.31 225.65,56.4 224.13,57.92 219.02,57.92 218.68,58.26 213.22,58.26 212.67,58.81 206.34,58.81 205.17,57.64 204.12,57.64 203.55,57.07 190.17,57.07 188.18,59.06 188.18,60 180.43,67.75 180.43,70.4 185.11,75.08 185.69,75.08 186.4,75.8 186.4,79.71 186.15,79.96 186.15,103.3 178.86,110.59 177.02,110.59 174.29,113.32 174.29,114.46 170.76,117.98 168.22,117.98 164.06,122.15 163.36,122.15 161.76,123.75 161.76,124.33 157.41,128.68 157.41,129.62 156.65,130.38 155.86,130.38 155.34,130.9 155.34,131.27 155.66,131.59 155.66,133.34 154.49,134.51 153.12,134.51 150.4,137.23 147.48,137.23 147.2,137.51 145.28,137.51 144.98,137.2 142.25,137.2 141.53,137.92 139.34,137.92 135.42,141.84 135.42,142.03 133.7,143.75 133.19,143.75 132.13,144.82 125.51,144.82 123.8,146.53 119.72,146.53 119.21,146.02 119.21,144.95 121.55,142.61 122.08,142.61 123.89,140.8 v1(123.89,140.76)
  BOTTOM w0.108: v2(258.14,36.65) v1(257.68,36.18)
RXD3_T: length 9.1
  TOP w0.108: v1(124.27,149.47) 124.01,149.21 124.01,148.22 v2(126.02,146.22) 126.8,145.43 U6203.7
  IN2 w0.089: v1(124.27,149.47) 123.14,149.47 JSER1.2
SA_HG: length 8.3
  IN2 w0.762: v4(122.24,124.83) 122.85,124.22 128.92,124.22 v4(129.27,124.58)
  BOTTOM w0.508: v2(122.24,123.99) 122.24,124.83 v4(122.24,124.83)
SA_SW: length 5.8
  IN3 w0.762: v4(122.24,125.97) 122.16,125.97 121.37,125.19 121.37,124.17 122.95,122.59 v4(122.95,121.22)
  vias: v2(124.12,121.07)
SA_VIN:
  vias: v2(128.41,128.16)
SATA_PRX_C_DTX_N0: length 115.7
  IN3 w0.076: v3(126.5,99.67) 126.5,99.68 126.37,99.81 126.23,99.81 126.13,99.71 126.13,98.75 125.53,98.15 124.77,98.15 124.18,97.56 124.18,96.06 123.96,95.84 123.96,89.76 124.74,88.98 125.72,88.98 126.54,88.16 130.22,88.16 130.59,87.8 130.59,87.36 130.69,87.26 130.69,81.82 131.87,80.65 131.89,80.65 132.07,80.47
  IN3 w0.102: 132.07,80.47 132.07,79.38 132.92,78.52 134.43,78.52 136.56,76.39 136.56,73.49 137.7,72.35 140.02,72.35 140.88,71.49 140.88,69.46 143.5,66.84 145.15,66.84 146.82,65.16 147.18,65.16 152.54,59.81 153.84,59.81 156.5,57.14 157.49,57.14 160.46,54.17 162.14,54.17 162.77,54.8 164.48,54.8 165.11,54.17 170.14,54.17 171.31,53 174.96,53 182.82,45.14 183.04,45.14 183.04,45.14 183.23,45.14 183.23,45.14 192.09,45.14 192.34,45.39 192.34,46.18 192.02,46.5 v1(191.96,46.5)
  BOTTOM w0.102: v1(191.96,46.5) 191.96,46.32 192.06,46.22 192.29,46.22 192.39,46.11 192.39,45.78 193.41,44.77 193.41,41.57 ; CS3.1 192.85,40.55 192.85,40.81 192.95,40.91 193.3,40.91 193.41,41.01 193.41,41.57 ; 193.41,41.57 v6(193.38,41.57) ; v3(126.5,99.67) 126.5,99.56 126.72,99.34 UC1.F20
SATA_PRX_C_DTX_P0: length 115.8
  IN3 w0.076: v3(126.5,100.31) 125.96,99.78 125.96,98.82 125.46,98.31 124.7,98.31 124.01,97.63 124.01,96.13 123.8,95.91 123.8,89.69 124.67,88.81 125.65,88.81 126.47,88 130.16,88 130.43,87.73 130.43,87.3 130.53,87.19 130.53,81.75 131.81,80.47
  IN3 w0.102: v1(192.63,46.47) 192.59,46.44 192.59,45.29 192.19,44.88 191.98,44.88 191.98,44.89 183.33,44.89 183.33,44.88 182.93,44.88 182.93,44.89 182.72,44.89 174.86,52.74 171.21,52.74 170.04,53.91 165.01,53.91 164.37,54.55 162.88,54.55 162.24,53.91 160.36,53.91 157.39,56.88 156.4,56.88 153.73,59.55 152.44,59.55 147.08,64.91 146.72,64.91 145.04,66.59 143.39,66.59 140.63,69.35 140.63,71.38 139.91,72.1 137.6,72.1 136.31,73.39 136.31,76.29 134.33,78.27 132.82,78.27 131.81,79.28 131.81,80.47
  BOTTOM w0.102: CS4.1 193.61,40.6 193.61,43.96 ; v1(192.63,46.47) 192.59,46.44 192.59,45.87 193.61,44.85 193.61,43.96 ; 193.61,43.96 v6(193.64,43.96) ; v3(126.5,100.31) 126.82,99.99 UC1.E20
