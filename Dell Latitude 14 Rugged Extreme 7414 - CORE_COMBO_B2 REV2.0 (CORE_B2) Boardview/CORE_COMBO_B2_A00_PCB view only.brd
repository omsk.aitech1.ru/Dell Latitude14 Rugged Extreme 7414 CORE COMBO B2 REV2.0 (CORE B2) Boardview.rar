# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Nets (continued)
DDR_B_ACT#: JDIMM2.114 UC1.AN53
DDR_B_ALERT#: JDIMM2.116 UC1.AN43
DDR_B_BA0: JDIMM2.150 UC1.BB44
DDR_B_BA1: JDIMM2.145 UC1.BA44
DDR_B_BG0: JDIMM2.115 UC1.AP52
DDR_B_BG1: JDIMM2.113 UC1.AN52
DDR_B_CKE0: JDIMM2.109 UC1.AN56
DDR_B_CKE1: JDIMM2.110 UC1.AP55
DDR_B_CKE2: T6209.1 UC1.AN55
DDR_B_CKE3: T6210.1 UC1.AP53
DDR_B_CS#0: JDIMM2.149 UC1.BB42
DDR_B_CS#1: JDIMM2.157 UC1.AY42
DDR_B_CS#2: JDIMM2.162 T6216.1
DDR_B_CS#3: JDIMM2.165 T6215.1
DDR_B_D0: JDIMM2.25 UC1.AF65
DDR_B_D1: JDIMM2.29 UC1.AF64
DDR_B_D2: JDIMM2.41 UC1.AK65
DDR_B_D3: JDIMM2.38 UC1.AK64
DDR_B_D4: JDIMM2.24 UC1.AF66
DDR_B_D5: JDIMM2.28 UC1.AF67
DDR_B_D6: JDIMM2.42 UC1.AK67
DDR_B_D7: JDIMM2.37 UC1.AK66
DDR_B_D8: JDIMM2.7 UC1.AF70
DDR_B_D9: JDIMM2.3 UC1.AF68
DDR_B_D10: JDIMM2.16 UC1.AH71
DDR_B_D11: JDIMM2.20 UC1.AH68
DDR_B_D12: JDIMM2.4 UC1.AF71
DDR_B_D13: JDIMM2.8 UC1.AF69
DDR_B_D14: JDIMM2.17 UC1.AH70
DDR_B_D15: JDIMM2.21 UC1.AH69
DDR_B_D16: JDIMM2.45 UC1.AT66
DDR_B_D17: JDIMM2.49 UC1.AU66
DDR_B_D18: JDIMM2.59 UC1.AP65
DDR_B_D19: JDIMM2.63 UC1.AN65
DDR_B_D20: JDIMM2.46 UC1.AN66
DDR_B_D21: JDIMM2.50 UC1.AP66
DDR_B_D22: JDIMM2.58 UC1.AT65
DDR_B_D23: JDIMM2.62 UC1.AU65
DDR_B_D24: JDIMM2.67 UC1.AT61
DDR_B_D25: JDIMM2.71 UC1.AU61
DDR_B_D26: JDIMM2.83 UC1.AP60
DDR_B_D27: JDIMM2.84 UC1.AN60
DDR_B_D28: JDIMM2.66 UC1.AN61
DDR_B_D29: JDIMM2.70 UC1.AP61
DDR_B_D30: JDIMM2.79 UC1.AT60
DDR_B_D31: JDIMM2.80 UC1.AU60
DDR_B_D32: JDIMM2.170 UC1.AU40
DDR_B_D33: JDIMM2.174 UC1.AT40
DDR_B_D34: JDIMM2.182 UC1.AT37
DDR_B_D35: JDIMM2.186 UC1.AU37
DDR_B_D36: JDIMM2.173 UC1.AR40
DDR_B_D37: JDIMM2.169 UC1.AP40
DDR_B_D38: JDIMM2.183 UC1.AP37
DDR_B_D39: JDIMM2.187 UC1.AR37
DDR_B_D40: JDIMM2.195 UC1.AT33
DDR_B_D41: JDIMM2.191 UC1.AU33
DDR_B_D42: JDIMM2.207 UC1.AU30
DDR_B_D43: JDIMM2.208 UC1.AT30
DDR_B_D44: JDIMM2.194 UC1.AR33
DDR_B_D45: JDIMM2.190 UC1.AP33
DDR_B_D46: JDIMM2.204 UC1.AR30
DDR_B_D47: JDIMM2.203 UC1.AP30
DDR_B_D48: JDIMM2.211 UC1.AU27
DDR_B_D49: JDIMM2.215 UC1.AT27
DDR_B_D50: JDIMM2.228 UC1.AT25
DDR_B_D51: JDIMM2.224 UC1.AU25
DDR_B_D52: JDIMM2.216 UC1.AP27
DDR_B_D53: JDIMM2.212 UC1.AN27
DDR_B_D54: JDIMM2.229 UC1.AN25
DDR_B_D55: JDIMM2.225 UC1.AP25
DDR_B_D56: JDIMM2.237 UC1.AT22
DDR_B_D57: JDIMM2.233 UC1.AU22
DDR_B_D58: JDIMM2.249 UC1.AU21
DDR_B_D59: JDIMM2.245 UC1.AT21
DDR_B_D60: JDIMM2.232 UC1.AN22
DDR_B_D61: JDIMM2.236 UC1.AP22
DDR_B_D62: JDIMM2.246 UC1.AP21
DDR_B_D63: JDIMM2.250 UC1.AN21
DDR_B_DQS0: JDIMM2.34 UC1.AH65
DDR_B_DQS1: JDIMM2.13 UC1.AG70
DDR_B_DQS2: JDIMM2.55 UC1.AR65
DDR_B_DQS3: JDIMM2.76 UC1.AR60
DDR_B_DQS4: JDIMM2.179 UC1.AR38
DDR_B_DQS5: JDIMM2.200 UC1.AR32
DDR_B_DQS6: JDIMM2.221 UC1.AR27
DDR_B_DQS7: JDIMM2.242 UC1.AR21
DDR_B_DQS#0: JDIMM2.32 UC1.AH66
DDR_B_DQS#1: JDIMM2.11 UC1.AG69
DDR_B_DQS#2: JDIMM2.53 UC1.AR66
DDR_B_DQS#3: JDIMM2.74 UC1.AR61
DDR_B_DQS#4: JDIMM2.177 UC1.AT38
DDR_B_DQS#5: JDIMM2.198 UC1.AT32
DDR_B_DQS#6: JDIMM2.219 UC1.AR25
DDR_B_DQS#7: JDIMM2.240 UC1.AR22
DDR_B_MA0: JDIMM2.144 UC1.BA46
DDR_B_MA1: JDIMM2.133 UC1.AY46
DDR_B_MA2: JDIMM2.132 UC1.AY47
DDR_B_MA3: JDIMM2.131 UC1.BB46
DDR_B_MA4: JDIMM2.128 UC1.BA47
DDR_B_MA5: JDIMM2.126 UC1.AY48
DDR_B_MA6: JDIMM2.127 UC1.BA48
DDR_B_MA7: JDIMM2.122 UC1.AP48
DDR_B_MA8: JDIMM2.125 UC1.BB48
DDR_B_MA9: JDIMM2.121 UC1.AP50
DDR_B_MA10: JDIMM2.146 UC1.AW46
DDR_B_MA11: JDIMM2.120 UC1.AN48
DDR_B_MA12: JDIMM2.119 UC1.AN50
DDR_B_MA13: JDIMM2.158 UC1.BA43
DDR_B_MA14: JDIMM2.151 UC1.AY44
DDR_B_MA15: JDIMM2.156 UC1.AY43
DDR_B_MA16: JDIMM2.152 UC1.AW44
DDR_B_ODT0: JDIMM2.155 UC1.BA42
DDR_B_ODT1: JDIMM2.161 UC1.AW42
DDR_B_PARITY: JDIMM2.143 UC1.AP43
DDR_VTT_CTRL: R34.2 U5.2 UC1.AW67
DDR_XDP_WAN_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP1.53 QC1.1 R123.2 U15.1
DDR_XDP_WAN_SMBDAT: JDIMM1.254 JDIMM2.254 JXDP1.51 QC1.4 R122.2 U15.4
DEVICE_DET#: JODD1.9 R2672.2 R9591.2 U37.B18
DGPU_CORE_EN: JGFX1.69 RC305.1 UC1.P4
DGPU_HOLD_RST#: JGFX1.59 RP9.3 UC1.P3
DGPU_PWR_EN: JGFX1.67 RC306.1 RC620.2 UC1.P1
DGPU_PWROK: CC281.2 JGFX1.75 R354.2 RC476.1 U37.A56 UC1.C8
DIMM1_SA0: JDIMM1.256 RD62.2 RD66.1
DIMM1_SA1: JDIMM1.260 RD63.2 RD67.1
DIMM1_SA2: JDIMM1.166 RD64.2 RD68.1
DIMM2_SA0: JDIMM2.256 RD69.2 RD72.1
DIMM2_SA1: JDIMM2.260 RD70.2 RD73.1
DIMM2_SA2: JDIMM2.166 RD71.2 RD74.1
DIS_BAT_PROCHOT#: PR5251.1 U37.B51
DISP_ON: D21.3 JEDP1.15 R96.2
DMIC0: CE2.1 JEDP1.50 R9626.2
DMIC0_L: R9626.1 U17.47
DMIC_CLK0: C139.1 CE1.1 JEDP1.49 R9625.2
DMIC_CLK_L: R9625.1 U17.2
DOCK_DCIN_GC: PQ5211.1 PR5212.1 U38.B23
DOCK_DCIN_GC_R: PQ5202.5 PQ5212.1 PQ5214.6 PR5211.1 PR5212.2
DOCK_DCIN_IS+: JDOCK1.37 PQ5204.3
DOCK_DCIN_IS-: JDOCK1.38 PQ5205.3
DOCK_DET#: C9458.1 JDOCK1.1 R272.2 U37.B41
DOCK_LAN_WAKE#: JDOCK1.7 R9640.2
DOCK_PSID: JDOCK1.2 PT5101.1 PU1.1
DOCK_PWR_BTN#: C342.2 JDOCK1.3 R330.2
DOCK_PWR_SW#: C344.1 R328.1 R330.1 U38.A63
DOCK_SMB_ALERT#: JDOCK1.8 R292.2 U37.A51
DOCK_SMB_CLK: JDOCK1.10 R361.1 U38.B4
DOCK_SMB_DAT: JDOCK1.9 R359.1 U38.A3
DPB_AUX: C9948.2 R47.1 U6.B11
DPB_AUX#: C9949.2 R44.1 U6.A11
DPB_AUX#_C: C9949.1 JDOCK1.26
DPB_AUX_C: C9948.1 JDOCK1.25
DPB_CA_DET: R9544.1 U6.A14
DPB_DOCK_HPD: C9459.1 JDOCK1.11 U6.A6
DPB_LANE_N0: JDOCK1.23 U6.A7
DPB_LANE_N1: JDOCK1.20 U6.A8
DPB_LANE_N2: JDOCK1.17 U6.A9
DPB_LANE_N3: JDOCK1.14 U6.A10
DPB_LANE_P0: JDOCK1.22 U6.B7
DPB_LANE_P1: JDOCK1.19 U6.B8
DPB_LANE_P2: JDOCK1.16 U6.B9
DPB_LANE_P3: JDOCK1.13 U6.B10
DPC_CA_DET: T6302.1 U6.M14
DPC_DOCK_HPD: R268.1 U6.K14
DPC_LANE_N0: T6295.1 U6.E14
DPC_LANE_N1: T6297.1 U6.F14
DPC_LANE_N2: T6299.1 U6.G14
DPC_LANE_N3: T6301.1 U6.H14
DPC_LANE_P0: T6294.1 U6.E13
DPC_LANE_P1: T6296.1 U6.F13
DPC_LANE_P2: T6298.1 U6.G13
DPC_LANE_P3: T6300.1 U6.H13
DSR1#: JIOR1.25 RP4806.4 U6202.37
DSR2: RP4806.6 U6202.47
DSR3: RP4804.7 U6202.22 U6203.17
DSR3_T: JSER1.6 U6203.6
DTR1#: JIOR1.24 R9427.1 U6202.40
DTR2: R9394.1 U6202.50
DTR3: R9430.1 U6202.25 U6203.13
DTR3_T: JSER1.4 U6203.10
EC5048_TX: R406.2 U37.B2
EC_32KHZ_ECE5048: R379.1 U37.B35
EC_32KHZ_ECE5048_R: R379.2 U38.B2
EC_+3.3V_ALW2_R: R367.1 R370.1 U38.A59
EC_FPM_EN: JSEC1.5 U38.B62
ECPC_BD_ID0#: CE22.1 JEPC1.1 R419.1 U37.B15
ECPC_BD_ID1#: JEPC1.38 R9461.1 U37.B33
ECPC_PWR_EN: JEPC1.28 U37.A31
EDP_BIA_PWM: Q4213.2 UC1.R11
EDP_BIA_PWM_Q: D7123.1 Q4213.3
EDP_COMP: RC134.2 UC1.E52
EDP_CPU_AUX: C55.1 UC1.F45
EDP_CPU_AUX#: C54.1 UC1.E45
EDP_CPU_AUX#_C: C54.2 JEDP1.24
EDP_CPU_AUX_C: C55.2 JEDP1.23
EDP_CPU_LANE_N0: C56.1 UC1.C47
EDP_CPU_LANE_N0_C: C56.2 JEDP1.20
EDP_CPU_LANE_N1: C57.1 UC1.D46
EDP_CPU_LANE_N1_C: C57.2 JEDP1.17
EDP_CPU_LANE_P0: C59.1 UC1.C46
EDP_CPU_LANE_P0_C: C59.2 JEDP1.21
EDP_CPU_LANE_P1: C60.1 UC1.C45
EDP_CPU_LANE_P1_C: C60.2 JEDP1.18
EDP_HPD: JEDP1.14 RC158.1 UC1.L10
EMMC_RCOMP: RC21.1 UC1.AT1
EN_1.0V_PRIM_COREP: PC5620.1 PR5621.2 PR5623.1 PU5602.13
EN_1VS_VCCIO: PC5610.1 PR5610.2 PR5612.1 PU5601.13
EN_+1VALWP: PC5514.1 PR5507.2 PR5509.1 PU5501.1
EN_I2S_NB_CODEC#: U17.1 U37.B36
EN_INVPWR: Q4211.2 R371.2 U38.A25
EN_INVPWR_Q: Q4.1 Q4211.3 R9692.2
EN_LCDPWR: Q4210.3 R4104.2 U9.3 U6207.2
EN_LCDPWR_Q: D2.3 Q4210.2
ENVDD_PCH: D2.2 U38.A7 UC1.U13
EPC_SMBCLK: JEPC1.16 QC2808.4 R731.2
EPC_SMBDAT: JEPC1.15 QC2808.1 R732.2
EXPRCRD_STBY_R#: JEPC1.22 R717.2 R734.2
F_CMT0: L2800.15 R9658.2
F_CMT1: L2800.16 R9659.2
F_CMT2: L2800.21 R9660.2
F_CMT3: L2800.22 R9661.2
F_TRLM0: JLAN1.2 L2800.14
F_TRLM1: JLAN1.6 L2800.18
F_TRLM2: JLAN1.5 L2800.20
F_TRLM3: JLAN1.8 L2800.24
F_TRLP0: JLAN1.1 L2800.13
F_TRLP1: JLAN1.3 L2800.17
F_TRLP2: JLAN1.4 L2800.19
F_TRLP3: JLAN1.7 L2800.23
FAN1_PWM: JFAN1.2 R408.2 U38.A24
FAN1_TACH: JFAN1.3 R376.2 U38.B22
FB_+1VALWP: PR5504.1 PR5505.1 PR5508.2 PU5501.4
FCCM_GT: PR5913.1 PU5801.11
FCCM_IA: PR5915.1 PU5801.21
FCCM_VSA: PU5801.29 PU5902.7
FFS_INT1: R9458.1 U15.12
FFS_INT2: Q19.2 RC346.1 U15.11 UC1.J4
FFS_INT2_Q: JSTRG1.4 Q19.3 R125.1
FIVR_EN: RC379.1 RC382.1 RC383.1
FIVR_EN_R: JXDP1.45 RC376.2 RC379.2 RC381.1
FWP#: R393.2 R399.1 U38.B65
GFX_B_DET#: JGFX1.1 R302.2 U37.B59
GP11/DRVDEN1/FDC_PP: T6271.1 U6202.64
GP12/IO_SMI#: T6265.1 U6202.27
GP13/IRQIN1/LED1#: T6266.1 U6202.28
GP21/IRTX2/WDT: T6249.1 U6202.31
GP22/IRMODE/XCS2#: T6256.1 U6202.32
GP23/LED2#/IRQIN2: T6272.1 U6202.5
GPIO_PSID_SELECT: PU1.6 U37.A6
GPP_B23: Q4203.2 RC469.1 RC472.2 UC1.AM7
GPP_B23_G: Q4203.1 RC473.2 RC474.2
GPP_B23_Q: Q4203.3 RC469.2 RC471.2
GPP_C5: RC350.1 UC1.W1
GPS_PWR_EN: Q3605.2 R9415.2 U37.B52
GPU_SMBCLK: JGFX1.14 JHS1.6 JIOR1.33 QC2807.6 QC2808.3 R454.1 U38.B49
GPU_SMBDAT: JGFX1.16 JHS1.7 JIOR1.32 QC2807.3 QC2808.6 R455.1 U38.B48
GPUHOT#: JGFX1.61 T7163.1
GREEN_CRT: C11.1 C9916.1 L2.1 R2746.2 U6.M7
GREEN_CRT_L: C14.1 D66.4 JCRT1.2 L2.2
GT_SW: PJP5905.2 PL5906.1 PR5910.2 PU5903.4
GT_VIN: C9971.1 C9972.1 PC5916.1 PC5917.1 PC5918.1 PC5919.1 PC5920.1 PC5921.1 PC5922.1 PC5931.1 PL5904.1 PU5903.5
H_CATERR#: RC113.2 UC1.D63
H_CPU_SVIDALRT#: RC248.2 UC1.B63
H_CPUPWRGD: CC271.2 RC406.2 UC1.A68
H_CPUPWRGD_R: RC406.1 T7138.1
H_PROCHOT#: PC5843.2 PR5236.2 PR5803.2 PR5806.1 RC117.1 RC405.2 RC486.2
H_PROCHOT#_R: RC117.2 UC1.C65
H_THERMTRIP#: Q12.2 RC80.2 RC172.2 RD4.2 RD61.2
H_THERMTRIP#_R: RC172.1 UC1.C63
H_VCCST_PWRGD_XDP: CC272.1 JXDP1.39 RC372.2 RC373.2
HDD_DET#: JSTRG1.11 RC466.1 UC1.H2
HDD_DEVSLP: R124.2 R9499.1 UC1.J1
HDD_DEVSLP_R: JSTRG1.12 R9499.2
HDD_FALL_INT: R9458.2 RC475.1 UC1.BB11
HDD_LED#: JLED1.7 Q144.2
HDD_LED#_Q: Q25.3 Q144.1
HDD_LED#_R: Q144.3 R438.2
HDMI_CEC: C9527.1 JHDMI1.13 R473.1
HDMI_CLKN: C191.1 L10.1 R466.1 RN4101.3
HDMI_CLKP: C103.1 L10.4 R464.1 RN4101.1
HDMI_HPD_SINK: C9528.1 JHDMI1.19 QZ22.6 R474.1
HDMI_OB: QZ22.3 R462.2 R463.2 R464.2 R465.2 R466.2 R467.2 R468.2 R469.2
HDMI_TX_N0: C209.1 L13.1 R463.1 RN4102.3
HDMI_TX_N1: C270.1 L16.1 R469.1 RN4103.3
HDMI_TX_N2: C272.1 L19.1 R468.1 RN4104.3
HDMI_TX_P0: C199.1 L13.4 R462.1 RN4102.1
HDMI_TX_P1: C269.1 L16.4 R467.1 RN4103.1
HDMI_TX_P2: C271.1 L19.4 R465.1 RN4104.1
HOST_DEB_TX: JDEG1.8 R400.1
HOST_DEBUG_TX: R396.1 R400.2 U38.B44
HOST_SD_WP#: JIOR1.52 RC479.1 UC1.AB3
HS_DET#: JHS1.5 PR5118.1 U37.B58
HS_IND/CFG_SEL1: R2725.1 R2729.2 U92.25
HS_LCDPWR_DIS: Q4210.1 Q4211.1 R9673.2 UC12.4
HSYNC_BUF: R2743.1 U6.M9
HSYNC_BUF_L: C18.1 D4.1 JCRT1.13 L4.2 R2740.1
HSYNC_BUF_R: L4.1 R2743.2
HUB_SRCDET: R9594.1 U6.C2
HUB_USB20_N1: D7120.1 JEDP1.28 U92.1
HUB_USB20_N2: L7103.4 RN4149.1 U92.3
HUB_USB20_N2_R: JEPC1.19 L7103.3 RN4149.2
HUB_USB20_N3: L8.1 RN4100.3 U92.6
HUB_USB20_N3_R: JEDP1.47 L8.2 RN4100.4
HUB_USB20_N4: JGPS1.3 U92.8
HUB_USB20_P1: D7119.1 JEDP1.27 U92.2
HUB_USB20_P2: L7103.1 RN4149.3 U92.4
HUB_USB20_P2_R: JEPC1.18 L7103.2 RN4149.4
HUB_USB20_P3: L8.4 RN4100.1 U92.7
HUB_USB20_P3_R: JEDP1.46 L8.3 RN4100.2
HUB_USB20_P4: JGPS1.2 U92.9
HW_GPS_DISABLE#: D7111.2 R282.2 U37.A35
HW_GPS_DISABLE#_R: D7111.1 JWWAN1.26
I2C0_SCL_VMM: R9637.1 RC616.1 U6.A2
I2C0_SCL_VMM_R: RC616.2 RP8.1 UC1.U6
I2C0_SDA_VMM: R9636.1 RC615.1 U6.A1
I2C0_SDA_VMM_R: RC615.2 RP8.3 UC1.U7
I2C1_SCK_TP: R449.1 RP8.5 UC1.U9
I2C1_SDA_TP: R450.1 RP8.7 UC1.U8
I2S_BCLK: T2706.1 U17.16
I2S_DI#: T2703.1 U17.24
I2S_DO: T2705.1 U17.17
I2S_LRCLK: T2704.1 U17.18
I2S_MCLK: T2707.1 U17.15
I_ADP: PR5228.2 U38.A12
I_BATT: PR5229.2 R381.2
I_BATT_R: R381.1 U38.B61
I_SYS: PR5231.2 PR5824.1 R9689.2
IFDET_SATA#_PCIE: JSTRG1.35 RC11.1 RC617.1 U6205.20 U6206.20 UC1.G4
ILIM_SEL: R9462.2 U6204.4
ILMT_+1VALWP: PR5501.1 PR5506.2 PU5501.3
IMVP_VR_ON: PR5817.1 R9579.2 U6218.2 UC11.4
IMVP_VR_ON_EC: R9579.1 U38.A1 UC11.1
INT_SPK_L+: C125.1 L2702.1 U17.42
INT_SPK_L-: C124.1 L2701.1 U17.43
INT_SPKR_L+: D7122.1 JSPK1.3 L2702.2
INT_SPKR_L-: D7121.1 JSPK1.4 L2701.2
INTRUDER#: R9557.1 UC1.AP16
IO_PME#: T6273.1 U6202.3
IOR_BD_ID0#: JIOR1.37 R9418.2 U37.A7
IOR_BD_ID1#: JIOR1.51 R9500.2 U37.A8
IOR_HUB_EN#: JIOR1.36 R9485.2 U37.B11
IOR_LANPHY_ENABLE: JIOR1.30 R9466.2 U37.A60
IOR_LANWAKEB#: JIOR1.29 R9501.2
IRQ_SERIRQ: RC345.1 U37.B21 U38.A28 U6202.17 UC1.AY11
IRRX2: RP4806.1 U6202.30
ISH_I2C2_SCL: R218.1 UC1.AD12
ISH_I2C2_SCL_R: JWWAN1.40 R216.1 R218.2
ISH_I2C2_SDA: R219.1 UC1.AD11
ISH_I2C2_SDA_R: JWWAN1.42 R217.1 R219.2
ISH_UART0_CTS#: RC606.2 UC1.U4
ISH_UART0_CTS#_R: JWLAN1.62 RC606.1
ISH_UART0_RTS#: RC607.2 UC1.U3
ISH_UART0_RTS#_R: JWLAN1.64 RC607.1
ISH_UART0_RXD: RC604.2 UC1.U1
ISH_UART0_RXD_R: JWLAN1.58 RC604.1
ISH_UART0_TXD: RC605.2 UC1.U2
ISH_UART0_TXD_R: JWLAN1.60 RC605.1
ISUMN_GT: PC5831.1 PC5832.1 PC5839.2 PH5805.2 PJP5906.1 PR5845.2 PR5847.2 PR5853.2
ISUMN_IA: PC5826.2 PC5827.2 PC5830.2 PH5803.1 PJP5902.1 PR5836.1 PR5838.1 PR5839.1
ISUMN_VSA: PC5807.2 PC5809.2 PC5810.2 PH5802.1 PJP5904.1 PR5815.1 PR5818.1 PR5821.1
ISUMP_GT: PC5831.2 PC5832.2 PR5844.1 PR5845.1 PR5911.1 PU5801.7
ISUMP_IA: PC5827.1 PC5830.1 PR5839.2 PR5843.2 PR5903.1 PU5801.19
ISUMP_VSA: PC5807.1 PC5810.1 PR5821.2 PR5823.2 PR5907.1 PU5801.27
ITP_PMODE: JXDP1.46 RC386.2 UC1.E8
JDIMM1_EVENT#: JDIMM1.134 RD61.1
JDIMM2_EVENT#: JDIMM2.134 RD4.1
JTAG_CLK: JDEG1.4 RP2.5 U38.B56
JTAG_RST#: C362.1 JTAG1.1 R380.2 R384.2 U38.B47
JTAG_TDI: JDEG1.2 RP2.1 U38.A51
JTAG_TDO: JDEG1.5 RP2.7 U38.B55
JTAG_TMS: JDEG1.3 RP2.3 U38.A53
KB_DET#: JKB1.1 RC608.1 UC1.BB7
LAN_ACTLED_YEL#: C9505.1 Q32.3 R2803.1
LAN_DISABLE#_R: R180.2 R182.2 R713.1 U21.3 U37.B53
LAN_TEST_EN: R184.2 U21.30
LAN_TX0+: D2800.1 L2800.12 U21.13
LAN_TX0-: D2800.6 L2800.11 U21.14
LAN_TX1+: D2800.3 L2800.8 U21.17
LAN_TX1-: D2800.4 L2800.7 U21.18
LAN_TX2+: D2801.1 L2800.6 U21.20
LAN_TX2-: D2801.6 L2800.5 U21.21
LAN_TX3+: D2801.3 L2800.2 U21.23
LAN_TX3-: D2801.4 L2800.1 U21.24
LAN_WAKE#: R176.2 R9501.1 R9639.1 R9640.1 RP4808.7 U38.B27 UC1.AM15
LANCLK_REQ#_R: R169.2 U21.48
LCD_CBL_DET#: C9912.1 JEDP1.1 RP9.7 UC1.AC3
LCD_T11: U37.A23 U6223.2
LCD_TST: JEDP1.13 R309.2 U37.A36
LCD_VCC_TEST_EN: D2.1 U37.A40
LED_10_GRN#: C9506.1 Q33.3 R9401.2
LED_100_ORG#: C9507.1 Q32.6 R9443.2
LED_DET#: JLED1.1 R478.1 U37.A11
LED_SATA_DIAG_OUT#: D24.2 U37.A10
LED_WWAN_OUT#: JWWAN1.10 Q30.4 R226.2
LID_CL#: JIOR1.39 JLID1.3 R325.2
LID_CL_SIO#: C337.1 R322.2 R325.1 U37.B54
LID_DB_DET#: JLID1.1 R9407.2 U37.A55
LINE1_REF_L: D2700.1 R9442.1
LINE1_REF_R: D2700.2 R2704.1
LOM_ACTLED_YEL#: Q32.4 U21.26
LOM_LAN_WAKE#: R9639.2 U21.2
LOM_SPD10LED_GRN#: Q33.4 U21.25 U24.2
LOM_SPD100LED_ORG#: Q32.1 U21.27 U24.1
LPC_LAD0: JDEG2.2 U26.27 U37.A27 U38.A30 U6202.6 UC1.AY13
LPC_LAD1: JDEG2.4 U26.24 U37.A26 U38.B32 U6202.7 UC1.BA13
LPC_LAD2: JDEG2.6 U26.21 U37.B26 U38.A31 U6202.8 UC1.BB13
LPC_LAD3: JDEG2.8 U26.19 U37.B25 U38.B33 U6202.9 UC1.AY12
LPC_LDRQ1#: RP4807.7 U37.A22
LPC_LFRAME#: JDEG2.10 U26.23 U37.A21 U38.B31 U6202.11 UC1.BA12
LX_1V_PRIM: PL5602.1 PR5615.2 PU5602.2 PU5602.3
LX_1VS_VCCIO: PL5601.1 PR5605.2 PU5601.2 PU5601.3
LX_+1VALWP: PC5502.1 PL5502.1 PR5503.2 PU5501.10
M_CLK_DDR0: JDIMM1.137 UC1.AT53
M_CLK_DDR1: JDIMM1.138 UC1.AT55
M_CLK_DDR2: JDIMM2.137 UC1.AP45
M_CLK_DDR3: JDIMM2.138 UC1.AP46
M_CLK_DDR#0: JDIMM1.139 UC1.AU53
M_CLK_DDR#1: JDIMM1.140 UC1.AU55
M_CLK_DDR#2: JDIMM2.139 UC1.AN45
M_CLK_DDR#3: JDIMM2.140 UC1.AN46
MASK_BASE_LEDS#: JIOR1.31 Q25.2 Q25.5 Q28.2 Q32.2 Q32.5 Q33.5 R310.2 U37.B48
MASK_BAT_LEDS#: Q23.2 Q23.5 R9684.2 U37.A46
MASK_SATA_LED#: Q3602.5 U37.B9
ME_FW_EC: JFWP1.1 RC401.1 U37.A64
ME_FWP: JFWP1.2 RC9.1 RC401.2
ME_RESET#: RC227.2 RC228.1 UC8.2
ME_SUS_PWR_ACK: RC70.1 RC82.1 U38.A8 UC1.AR13
MEC_XTAL1: C364.1 U38.A61 Y4.1
MEC_XTAL2: C365.1 R378.1 Y4.2
MEC_XTAL2_R: R378.2 U38.A62
MEM_SMBCLK: QC1.6 RC28.1 UC1.R7
MEM_SMBDATA: QC1.3 RC30.1 UC1.R8
MIC1_L: C9515.2 U17.19
MIC1_R: C9516.2 U17.20
MIC1_REF: D2700.3 U17.30
MODC_EN: R2677.1 U32.3 U37.B7
MPHYP_PWR_EN: R9569.1 RC169.2 RC407.2 UC1.AM10
MSCLK: JDEG1.6 R395.1 U38.B43
MSDATA: JDEG1.7 R366.2 R398.1 U38.A40
MSM#: T7122.1 UC1.AP56
NB_DCIN_GC: PQ5209.1 PR5220.1 U38.A23
NB_DCIN_GC_R: PQ5210.5 PQ5215.1 PQ5216.3 PR5218.1 PR5220.2
NB_PSID: JDCIN1.1 PC5104.1 PL5103.1
NB_PSID_TS5A63157: PR5105.2 PR5106.2 PU1.3
NRB_BIT: R9562.2 UC1.AR7
ODD_DA#: JODD1.15 RC137.1 UC1.AB12
OPC_RCOMP: RC91.1 UC1.H65
OPCE_RCOMP: RC90.1 UC1.H66
ORIENTATION_DET#: JCSW2.1 R9403.2 U37.B16
ORIENTATION_SW#: JCSW2.3 R9400.1 U37.B17
P_SENSOR_CTRL: C9541.2 C9544.1 JPSEN1.3 R9445.2 R9446.2
P_SENSOR_OUT: C9540.2 C9543.1 JPSEN1.2 Q1701.1 R9454.2
P_SENSOR_OUT#: R9686.2 UC1.AY7
P_SENSOR_OUT_C: JWWAN1.25 Q3607.3 R9444.1
PANEL_BKEN_EC: D21.2 U37.B38
PANEL_BKLEN: Q4216.2 R9697.2 UC1.R12
PANEL_BKLEN_HS#: Q4216.1 U37.A62
PBAT_PRES#: JHS1.4 PR5102.1 PR5104.1 PR5246.2 PU5202.1 U38.A49 UC12.1
PBAT_PRES#_C: JBAT1.7 PD5103.1 PR5104.2
PBAT_PRES#_D: JBAT_PK1.7 JBAT_PK2.5
PBAT_SMBCLK: PR5101.1 R339.2 U38.A56
PBAT_SMBCLK_C: JBAT1.5 PD5101.1 PR5101.2
PBAT_SMBCLK_D: JBAT_PK1.5 JBAT_PK2.7
PBAT_SMBDAT: PR5103.1 R345.2 U38.B59
PBAT_SMBDAT_C: JBAT1.6 PD5102.1 PR5103.2
PBAT_SMBDAT_D: JBAT_PK1.6 JBAT_PK2.6
PBATT+_C: JBAT1.1 JBAT1.2 JBAT1.3 JBAT1.4 PC5101.1 PC5102.1 PL5101.1 PL5102.1
PC_BEEP: C143.2 R353.1
PC_SPKR: C133.2 R9387.1
PCH_ALW_ON: R368.2 R9580.1 U38.A34
PCH_AZ_BITCLK: RC26.2 UC1.AY22
PCH_AZ_CODEC_BITCLK: CC5.2 R149.2 RC26.1 U17.6
PCH_AZ_CODEC_RST#: CC287.2 R153.1 RC25.1 U17.11
PCH_AZ_CODEC_SDIN0: C2750.2 R136.1 UC1.BA21
PCH_AZ_CODEC_SDOUT: R148.2 RC23.1 U17.5
PCH_AZ_CODEC_SYNC: RC24.1 U17.10
PCH_AZ_RST#: RC25.2 UC1.AW22
PCH_AZ_SDIN0_R: R136.2 U17.8
PCH_AZ_SDOUT: RC9.2 RC23.2 UC1.BB22
PCH_AZ_SYNC: RC24.2 UC1.BA22
PCH_BATLOW#: RP4808.3 UC1.AU13
PCH_CL_CLK1: JWLAN1.42 UC1.G3
PCH_CL_DATA1: JWLAN1.40 UC1.G2
PCH_CL_RST1#: CC288.2 R223.2 UC1.G1
PCH_CL_RST1#_R: JWLAN1.38 R223.1
PCH_DPWROK: CC266.1 CC280.2 PR6091.1 RC79.1 RC375.1 U38.A36 UC1.BB20
PCH_JTAG_TCK: JXDP1.55 RC369.2 UC1.B56
PCH_JTAG_TDI: RC366.2 RC600.1 UC1.D59
PCH_JTAG_TDO: RC95.1 RC367.2 UC1.A56
PCH_JTAG_TMS: RC101.2 RC365.2 UC1.C59
PCH_OPIRCOMP: RC89.1 UC1.AU16
PCH_PCIE_WAKE#: R9573.2 RC618.1 U38.B46 UC1.BB15
PCH_PLTRST#: CC275.2 RC582.2 RC586.2 RC587.2 RC590.2 RC612.2 RC613.2 UC1.AN10 UC3.1 UC3.2
PCH_PLTRST#_AND: CE14.1 JEPC1.21 JGFX1.57 JSEC1.21 JWLAN1.52 R2723.1 R9641.1 RC611.2 RI32.1 RI33.2 U6202.13 UC3.4
PCH_PLTRST#_EC: C9491.2 RC590.1 U38.B30
PCH_PLTRST#_SSD: JSTRG1.37 R9641.2
PCH_PLTRST#_USB: C3063.1 R2721.2 R2723.2 U92.26
PCH_PLTRST#_WWAN: JWWAN1.50 RI32.2
PCH_PLTRST#_WWAN1: JWWAN1.67 RI33.1
PCH_PWROK: PR5814.1 RC595.1
PCH_PWROK_R: CC279.2 RC595.2 UC1.BA20
PCH_RSMRST#: CC286.2 R377.2 U38.A45 UC9.1
PCH_RSMRST#_Q: RC373.1 RC374.2 RC375.2 RC591.1 UC9.4
PCH_RSMRST#_R: CC277.2 RC79.2 RC591.2 UC1.AY17
PCH_RTCRST#: CC26.1 CMOS1.1 JAPS1.9 RC57.1 UC1.AM16
PCH_RTCX1: CC91.1 RC341.1 UC1.AM18 YC3.1
PCH_RTCX2: RC340.1 RC341.2 UC1.AM20
PCH_RTCX2_R: CC92.1 RC340.2 YC3.4
PCH_SATA_LED#: Q3602.4 RC314.1 UC1.H1
PCH_SMB_ALERT#: RC347.1 UC1.R10
PCH_SPI_CLK: R9503.2 R9510.2 R9522.2 UC1.AV2
PCH_SPI_CLK_0_R: JSPI1.6 R57.2 R9503.1 U1.6
PCH_SPI_CLK_1_R: R45.2 R9510.1 U2.6
PCH_SPI_CLK_2_R: R9522.1 U25.19
PCH_SPI_CS#0: R9512.1 UC1.AU3
PCH_SPI_CS#0_R: JSPI1.1 R9512.2 U1.1
PCH_SPI_CS#1: R9513.1 UC1.AU2
PCH_SPI_CS#1_R: R9513.2 U2.1
PCH_SPI_CS#2: R9521.2 RC622.1 UC1.AU1
PCH_SPI_CS#2_R: Q4200.1 R9521.1 R9531.2 R9545.1 U25.20
PCH_SPI_CS#2_R1: Q4199.1 R9531.1
PCH_SPI_D0: R9502.2 R9509.2 R9514.2 RC380.1 UC1.AV3
PCH_SPI_D0_0_R: JSPI1.5 R9502.1 U1.5
PCH_SPI_D0_1_R: R9509.1 U2.5
PCH_SPI_D0_2_R: R9514.1 U25.21
PCH_SPI_D1: R9505.1 R9507.1 R9520.2 UC1.AW3
PCH_SPI_D1_0_R: JSPI1.2 R9505.2 U1.2
PCH_SPI_D1_1_R: R9507.2 U2.2
PCH_SPI_D1_2_R: R9520.1 U25.24
PCH_SPI_D2: R1.2 R9506.1 R9508.1 RC368.2 UC1.AW2
PCH_SPI_D2_0_R: JSPI1.3 R9506.2 U1.3
PCH_SPI_D2_1_R: R9508.2 U2.3
PCH_SPI_D3: R2.2 R9504.2 R9511.2 UC1.AU4
PCH_SPI_D3_0_R: JSPI1.7 R9504.1 U1.7
PCH_SPI_D3_1_R: R9511.1 U2.7
PCH_SPI_DO2_XDP: JXDP1.60 RC368.1
PCH_SPI_DO_XDP: RC133.1 RC377.1 RC380.2
PCI_CLK_LPC0: RC64.1 RC65.1 UC1.AW9
PCI_CLK_LPC1: RC58.1 RC66.1 RC619.1 UC1.AY9
PCIE_MCARD1_DET#: JWLAN1.69 T7162.1
PCIE_PRX_C_DTX_N9: C176.1 U21.39
PCIE_PRX_C_DTX_N11: CU47.2 JSTRG1.29
PCIE_PRX_C_DTX_N12: CU50.2 JSTRG1.23
PCIE_PRX_C_DTX_P9: C179.1 U21.38
PCIE_PRX_C_DTX_P11: CU48.2 JSTRG1.28
PCIE_PRX_C_DTX_P12: CU49.2 JSTRG1.22
PCIE_PRX_C_RD_DTX_N11: CU43.2 U6205.4
PCIE_PRX_C_RD_DTX_N12: CU33.2 U6206.4
PCIE_PRX_C_RD_DTX_P11: CU44.2 U6205.5
PCIE_PRX_C_RD_DTX_P12: CU34.2 U6206.5
PCIE_PRX_DTX_N5: JWLAN1.43 UC1.F16
PCIE_PRX_DTX_N6: JEPC1.7 UC1.G18
PCIE_PRX_DTX_N8: T6217.1 UC1.G21
PCIE_PRX_DTX_N9: C176.2 UC1.E22
PCIE_PRX_DTX_N10: JWWAN1.41 UC1.F25
PCIE_PRX_DTX_N11: CU43.1 UC1.E28
PCIE_PRX_DTX_N12: CU33.1 UC1.E30
PCIE_PRX_DTX_P5: JWLAN1.41 UC1.E16
PCIE_PRX_DTX_P6: JEPC1.6 UC1.F18
PCIE_PRX_DTX_P8: T6218.1 UC1.F21
PCIE_PRX_DTX_P9: C179.2 UC1.E23
PCIE_PRX_DTX_P10: JWWAN1.43 UC1.E25
PCIE_PRX_DTX_P11: CU44.1 UC1.E27
PCIE_PRX_DTX_P12: CU34.1 UC1.F30
PCIE_PRX_RD_DTX_N11: CU47.1 U6205.15
PCIE_PRX_RD_DTX_N12: CU50.1 U6206.15
PCIE_PRX_RD_DTX_P11: CU48.1 U6205.14
PCIE_PRX_RD_DTX_P12: CU49.1 U6206.14
PCIE_PTX_C_DRX_N5: C242.2 JWLAN1.37
PCIE_PTX_C_DRX_N6: C647.1 JEPC1.4
PCIE_PTX_C_DRX_N9: C181.1 U21.42
PCIE_PTX_C_DRX_N10: CZ58.1 JWWAN1.47
PCIE_PTX_C_DRX_N11: CU46.2 JSTRG1.31
PCIE_PTX_C_DRX_N12: CU36.2 JSTRG1.25
PCIE_PTX_C_DRX_P5: C243.2 JWLAN1.35
PCIE_PTX_C_DRX_P6: C648.1 JEPC1.3
PCIE_PTX_C_DRX_P9: C178.1 U21.41
PCIE_PTX_C_DRX_P10: CZ59.1 JWWAN1.49
PCIE_PTX_C_DRX_P11: CU45.2 JSTRG1.32
PCIE_PTX_C_DRX_P12: CU35.2 JSTRG1.26
PCIE_PTX_C_RD_DRX_N11: CU42.2 U6205.2
PCIE_PTX_C_RD_DRX_N12: CU32.2 U6206.2
PCIE_PTX_C_RD_DRX_P11: CU41.2 U6205.1
PCIE_PTX_C_RD_DRX_P12: CU31.2 U6206.1
PCIE_PTX_DRX_N5: C242.1 UC1.C19
PCIE_PTX_DRX_N6: C647.2 UC1.D20
PCIE_PTX_DRX_N8: T6219.1 UC1.D21
PCIE_PTX_DRX_N9: C181.2 UC1.B23
PCIE_PTX_DRX_N10: CZ58.2 UC1.D23
PCIE_PTX_DRX_N11: CU42.1 UC1.D24
PCIE_PTX_DRX_N12: CU32.1 UC1.A25
PCIE_PTX_DRX_P5: C243.1 UC1.D19
PCIE_PTX_DRX_P6: C648.2 UC1.C20
PCIE_PTX_DRX_P8: T6220.1 UC1.C21
PCIE_PTX_DRX_P9: C178.2 UC1.A23
PCIE_PTX_DRX_P10: CZ59.2 UC1.C23
PCIE_PTX_DRX_P11: CU41.1 UC1.C24
PCIE_PTX_DRX_P12: CU31.1 UC1.B25
PCIE_PTX_RD_DRX_N11: CU46.1 U6205.17
PCIE_PTX_RD_DRX_N12: CU36.1 U6206.17
PCIE_PTX_RD_DRX_P11: CU45.1 U6205.18
PCIE_PTX_RD_DRX_P12: CU35.1 U6206.18
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JEPC1.13 JWLAN1.55 JWWAN1.54 R9572.2 R9573.1 R9662.1
PCIE_WAKE#_R: R340.2 R9572.1 U37.B10
PECI_EC: R375.2 UC1.A54
PECI_EC_R: C395.2 R375.1 U38.A48
PEG_GTX_C_HRX_N0: JGFX1.40 UC1.H13
PEG_GTX_C_HRX_N1: JGFX1.26 UC1.G11
PEG_GTX_C_HRX_N2: JGFX1.32 UC1.H16
PEG_GTX_C_HRX_N3: JGFX1.22 UC1.G15
PEG_GTX_C_HRX_P0: JGFX1.38 UC1.G13
PEG_GTX_C_HRX_P1: JGFX1.28 UC1.F11
PEG_GTX_C_HRX_P2: JGFX1.34 UC1.G16
PEG_GTX_C_HRX_P3: JGFX1.20 UC1.F15
PEG_HTX_C_GRX_N0: CU16.1 JGFX1.64
PEG_HTX_C_GRX_N1: CU18.1 JGFX1.70
PEG_HTX_C_GRX_N2: CU20.1 JGFX1.52
PEG_HTX_C_GRX_N3: CU22.1 JGFX1.58
PEG_HTX_C_GRX_P0: CU17.1 JGFX1.62
PEG_HTX_C_GRX_P1: CU19.1 JGFX1.68
PEG_HTX_C_GRX_P2: CU21.1 JGFX1.50
PEG_HTX_C_GRX_P3: CU23.1 JGFX1.56
PEG_HTX_GRX_N0: CU16.2 UC1.B17
PEG_HTX_GRX_N1: CU18.2 UC1.D16
PEG_HTX_GRX_N2: CU20.2 UC1.D17
PEG_HTX_GRX_N3: CU22.2 UC1.B19
PEG_HTX_GRX_P0: CU17.2 UC1.A17
PEG_HTX_GRX_P1: CU19.2 UC1.C16
PEG_HTX_GRX_P2: CU21.2 UC1.C17
PEG_HTX_GRX_P3: CU23.2 UC1.A19
PLTRST_5048#: RC587.1 U37.B22
PLTRST_LAN#: RC586.1 U21.36
PLTRST_MMI#: JIOR1.35 RC613.1
PLTRST_TPM#: C9924.1 RC611.1 RC612.1 U25.17 U26.18
PLTRST_VMM3320#: C9906.2 RC582.1 U6.A13
PM_LANPHY_ENABLE: R180.1 UC1.AW17
PME#: T7139.1 UC1.AU11
POA_WAKE#: JSEC1.4 R346.1 U38.B68
POWER_SW#_MB: C340.2 D7113.1 JAPS1.11 JIOR1.40 JLED1.3 R329.2 SW5.3
POWER_SW_IN#: C343.1 R327.1 R329.1 U38.B67
PROC_POPIRCOMP: RC88.1 UC1.AT16
PROC_SELECT#: R9546.1 UC1.C64
PROCHOT#_EC: RC486.1 U38.A46
PROCHOT_GATE: R9688.2 U37.A61
PS2_CLK_TS: JKB1.2 JTP1.7
PS2_DAT_TS: JKB1.3 JTP1.6
PS_ID: PU1.4 U38.B24
PS_USB20_N4: L42.4 RN249.1 U6204.11
PS_USB20_P4: L42.1 RN249.3 U6204.10
PSID_DISABLE#: PR5109.1 U37.A37
PWM1_GT: PR5914.2 PU5801.12 PU5903.8
PWM_IA: PR5916.2 PU5801.22 PU5901.8
PWM_VSA: PU5801.30 PU5902.3
PWR_SRC_ON: C66.2 Q2.4 R97.1 R99.1
RD1_A_DE0: RN25.2 RN4111.1 U6205.6
RD1_A_DE1: RN4108.2 RN4112.1 U6205.8
RD1_A_EQ0: RN4115.2 RN4119.1 U6205.23
RD1_A_EQ1: RN4116.2 RN4120.1 U6205.22
RD1_A_EQ2: RN4117.2 RN4121.1 U6205.19
RD1_B_DE0: RN4109.2 RN4113.1 U6205.13
RD1_B_DE1: RN4110.2 RN4114.1 U6205.9
RD1_B_EQ0: RN4122.2 RN4125.1 U6205.11
RD1_B_EQ1: RN4123.2 RN4126.1 U6205.21
RD1_B_EQ2: RN4124.2 RN4127.1 U6205.16
RD1_REXT: RN31.2 U6205.10
RD2_A_DE0: RN4128.2 RN4132.1 U6206.6
RD2_A_DE1: RN4129.2 RN4133.1 U6206.8
RD2_A_EQ0: RN4136.2 RN4139.1 U6206.23
RD2_A_EQ1: RN4137.2 RN4140.1 U6206.22
RD2_A_EQ2: RN4138.2 RN4141.1 U6206.19
RD2_B_DE0: RN4130.2 RN4134.1 U6206.13
RD2_B_DE1: RN4131.2 RN4135.1 U6206.9
RD2_B_EQ0: RN4142.2 RN4145.1 U6206.11
RD2_B_EQ1: RN4143.2 RN4146.1 U6206.21
RD2_B_EQ2: RN4144.2 RN4147.1 U6206.16
RD2_REXT: RN4107.1 U6206.10
RED_CRT: C10.1 C9915.1 L1.1 R2745.2 U6.M6
RED_CRT_L: C13.1 D66.6 JCRT1.1 L1.2
REGCTL_PNP10: L27.1 U21.7
REM_DIODE1_N: C358.2 C370.1 Q11.2 U38.B13
REM_DIODE1_P: C358.1 C370.2 Q11.1 Q11.3 U38.A13
REM_DIODE2_N: C359.2 JGFX1.7 U38.B14
REM_DIODE2_P: C359.1 JGFX1.5 U38.A14
REM_DIODE3_N: C9460.2 C9461.1 Q3603.2 U38.A15
REM_DIODE3_P: C9460.1 C9461.2 Q3603.1 Q3603.3 U38.B16
REM_DIODE4_N: C361.2 C373.2 Q14.2 U38.A16
REM_DIODE4_P: C361.1 C373.1 Q14.1 Q14.3 U38.B17
RES_BIAS: R185.2 U21.12
RESET_OUT#: CC285.2 R373.2 RC378.1 RC404.1 RC594.1 U38.B39
RESET_OUT#_R: CC268.1 JXDP1.47 RC377.2 RC378.2
RI1#: JIOR1.27 RP4806.9 U6202.41
RI2: RP4804.2 U6202.43
RI3: RP4804.9 U6202.18 U6203.19
RI3_T: JSER1.9 U6203.4
RING2: R9623.2 R9633.1 U17.28
RING2_D: C7109.1 D7101.1 JSIMUAJ2.15 JSIMUAJ2.16 JUAJ1.3
RING2_L: JSIMUAJ1.3 JSIMUAJ1.4 R9633.2
ROT_LCK#: JCSW1.3 JSH1.15 R9420.1 R9421.2
ROT_LCK#_R: R9420.2 U37.B45
RSVD53: T7141.1 UC1.K32
RSVD54: T7142.1 UC1.AK32
RSVD_TP1: T7115.1 UC1.AY4
RSVD_TP2: T7116.1 UC1.BB3
RSVD_TP3: T7114.1 UC1.BB5
RSVD_TP4: T7112.1 UC1.AU5
RSVD_TP5: T7113.1 UC1.AT5
RSVD_TP6: T7108.1 UC1.BB68
RSVD_TP7: T7109.1 UC1.BB69
RSVD_TP8: T7110.1 UC1.AK13
RSVD_TP9: T7111.1 UC1.AK12
RSVD_TP10: T7117.1 UC1.AW71
RSVD_TP11: T7118.1 UC1.AW70
RSVD_TP12: T7119.1 UC1.BA70
RSVD_TP13: T7120.1 UC1.BA68
RTS1#: JIOR1.22 R9395.1 U6202.38
RTS2: R9431.1 U6202.48
RTS3: R9429.1 U6202.23 U6203.14
RTS3_T: JSER1.7 U6203.9
RUN_ON: PR5610.1 PR5719.1 Q5.2 R717.1 R9585.1 R9586.1 R9587.2 R9685.1 U45.3 U46.5 UC13.4
RUN_ON#: Q5.5 Q5.6 R36.1
RUN_ON_EC: R9585.2 U38.B9 UC13.2
RUNPWROK: CC282.2 CC284.2 Q5.3 R35.2 U37.A4 U38.B26 UC6.1 UC6.4 UC6.10 UC6.13
RXD1: JIOR1.21 U6202.35
RXD2: T6354.1 U6202.45
RXD3: U6202.20 U6203.16
RXD3_T: JSER1.2 U6203.7
SA_HG: PQ5902.1 PU5902.1
SA_LG: PQ5902.8 PU5902.5
SA_SW: PC5923.2 PJP5903.2 PL5905.1 PQ5902.9 PR5906.2 PU5902.8
SA_VIN: PC5910.1 PC5911.1 PC5913.1 PL5903.1 PQ5902.2 PQ5902.3 PQ5902.4 PQ5902.10
SATA_PRX_C_DTX_N0: CS3.1 UC1.F20
SATA_PRX_C_DTX_P0: CS4.1 UC1.E20
SATA_PRX_DTX_N0: CS3.2 JODD1.6
SATA_PRX_DTX_P0: CS4.2 JODD1.7
SATA_PTX_C_DRX_N0: CS2.1 UC1.B21
SATA_PTX_C_DRX_P0: CS1.1 UC1.A21
SATA_PTX_DRX_N0: CS2.2 JODD1.4
SATA_PTX_DRX_P0: CS1.2 JODD1.3
SATAGP1: RC467.1 UC1.H3
SD_RCOMP: RC96.2 UC1.AB7
SENS_DET#: JSH1.1 R9408.2 U37.A45
SIM_CLK: JSIM1.3 JSIMUAJ2.1 U6220.5 U6220.6
SIM_DATA: JSIM1.7 JSIMUAJ2.3 U6220.2 U6220.9
SIM_DE: JSIM1.9 JSIMUAJ2.2 R7101.2 R7102.1 U6220.4 U6220.7
SIM_DET: C266.1 JSIMUAJ1.17 JWWAN1.66
SIM_DET#: JSIMUAJ1.13 R9406.2 U37.A2
SIM_GND: C7106.2 C7112.2 H7101.1 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSIM1.18 JSIMUAJ2.6 JSIMUAJ2.7 JSIMUAJ2.8 JSIMUAJ2.19 R7101.1 U6220.3 U6220.8
SIM_RESET: JSIM1.2 JSIMUAJ2.4 U6220.1 U6220.10
SIM_VPP: JSIM1.6 T7101.1
SIO_EXT_SCI#: RC199.2 U38.A33 UC1.AN7
SIO_EXT_SMI#: RC481.1 U38.A6 UC1.A6
SIO_EXT_WAKE#: R316.1 RC609.1 UC1.AD3
SIO_EXT_WAKE#_R: R316.2 U38.B5
SIO_PWRBTN#: CC267.1 R9536.2 RC403.1 U38.B58 UC1.BA15
SIO_PWRBTN#_R: JXDP1.41 RC403.2
SIO_RCIN#: RC344.1 U38.A27 UC1.AW13
SIO_SLP_A#: JAPS1.6 RC473.1 U38.B28 UC1.AN16
SIO_SLP_LAN#: R9674.1 RC487.1 RC488.1 U22.4 UC1.AW15
SIO_SLP_LAN#_R: R9674.2 U38.B37
SIO_SLP_S0#: JAPS1.15 PR5607.2 PR5618.2 R9533.2 R9685.2 RC458.2 UC1.AT11 UC10.2
SIO_SLP_S0#_TPM: R9533.1 R9534.2 U25.29
SIO_SLP_S3#: JAPS1.2 PR5701.1 Q4215.1 R734.1 R9586.2 RC624.1 U38.A35 UC1.AP15 UC10.1 UC11.2 UC13.1
SIO_SLP_S4#: JAPS1.5 PR5407.1 PR5711.1 R418.1 R422.1 U38.B36 UC1.BA16 UC14.2
SIO_SLP_S5#: JAPS1.4 U38.A18 UC1.AY16
SIO_SLP_SUS#: PR5507.1 PR5621.1 PR5706.1 R9567.1 R9581.1 R9584.2 RC474.1 UC1.AN15 UC14.1
SIO_SLP_SUS#_R: R9584.1 U38.B52
SIO_SLP_WLAN#: R9657.1 RC465.1 UC1.BB17
SIO_SLP_WLAN#_R: R9657.2 U37.A14
SKTOCC#: T7140.1 UC1.A65
SLEEVE: Q4209.3 R9624.2 R9632.1 U17.29
SLEEVE_D: C7108.1 D7118.1 JSIMUAJ2.17 JSIMUAJ2.18 JUAJ1.4
SLEEVE_L: JSIMUAJ1.1 JSIMUAJ1.2 R9632.2
SLOT2_CONFIG_0: JWWAN1.21 RP4810.1 U37.B12
SLOT2_CONFIG_1: JWWAN1.69 RP4810.3 U37.A18
SLOT2_CONFIG_2: JWWAN1.75 RP4811.5 U37.A44
SLOT2_CONFIG_3: JWWAN1.1 RP4810.7 U37.B34
SM_RCOMP0: R801.1 UC1.AR18
SM_RCOMP1: R802.1 UC1.AT18
SM_RCOMP2: R803.1 UC1.AU18
SML0_SMBCLK: RC186.1 RC348.1 U21.28 UC1.R9
SML0_SMBDATA: RC192.1 RC349.1 U21.31 UC1.W2
SML1_SMBCLK: RC36.1 U38.B6 UC1.W3
SML1_SMBDATA: RC37.1 U38.A5 UC1.V3
SNSR_HUB_PWREN: C9494.1 JSH1.5 RC610.1 UC1.AP7
SNSR_HUB_RST#: C9495.1 JSH1.4 UC1.AN8
SNUB_3V: PC5315.1 PR5305.2
SNUB_5V: PC5314.1 PR5301.2
SPKR: R9387.2 R9560.2 UC1.AW5
SRTCRST#: CC24.1 ME1.1 RC56.1 UC1.AN18
STRG_WAKE#_R: JSTRG1.38 R9662.2
SUS_STAT#: RC343.1 UC1.BA11
SUSACK#: RC82.2 RC98.1 U38.B7 UC1.AP11
SUSCLK: R9435.1 R9436.1 RC48.1 UC1.BA17
SUSCLK_HDD: JSTRG1.3 R9435.2
SUSCLK_WLAN: JWLAN1.50 R9436.2
SW_DPC_AUX: T6303.1 U6.J13
SW_DPC_AUX#: T6304.1 U6.J14
SYS_CLK: JWWAN1.46 T6353.1
SYS_PRES#_D: JBAT_PK1.8 JBAT_PK2.4
SYS_PWROK_R: CC278.2 RC404.2 RC594.2 UC1.B6
SYS_RESET#: C9887.1 CC276.2 JAPS1.13 RC224.2 RC353.1 UC1.B5
SYS_RESET#_R: RC224.1 RC491.2 UC8.4
SYSTEM_ID: C369.1 R386.2 U38.A10
TDI_XDP: JXDP1.56 RC600.2 UC6.5
TDO_XDP: CC273.1 JXDP1.52 RC95.2 UC6.2
THERMATRIP2#: C371.1 Q12.3 R402.1 U38.B34
THERMATRIP3#: JGFX1.77 R364.1 U38.A2
THSEL_STRAP: R383.1 U38.B29
TMDS_DDC_SCL_R: JHDMI1.15 Q122.6 R471.1
TMDS_DDC_SDA_R: C9525.1 C9526.1 JHDMI1.16 Q122.3 R470.1
TMDSB_CON_CLK: D2301.1 D2301.10 JHDMI1.10 L10.3 RN4101.2
TMDSB_CON_CLK#: D2301.2 D2301.9 JHDMI1.12 L10.2 RN4101.4
TMDSB_CON_N0: D2301.5 D2301.6 JHDMI1.9 L13.2 RN4102.4
TMDSB_CON_N1: D2302.1 D2302.10 JHDMI1.6 L16.2 RN4103.4
TMDSB_CON_N2: D2302.4 D2302.7 JHDMI1.3 L19.2 RN4104.4
TMDSB_CON_P0: D2301.4 D2301.7 JHDMI1.7 L13.3 RN4102.2
TMDSB_CON_P1: D2302.2 D2302.9 JHDMI1.4 L16.3 RN4103.2
TMDSB_CON_P2: D2302.5 D2302.6 JHDMI1.1 L19.3 RN4104.2
TMS_XDP: JXDP1.58 RC101.1 UC6.9
TOUCH_RST_N_GYRO_INT1: C9493.1 JSH1.10 RC621.1 UC1.AP8
TOUCHPAD_INTR#: RC140.1 UC1.BA5
TP_CLK: C380.1 D22.1 JTP1.2 L45.2
TP_CLK_R: C378.1 L45.1 R405.2 R444.2 R449.2
TP_DATA: C379.1 D25.1 JTP1.3 L44.2
TP_DATA_R: C377.1 L44.1 R404.2 R441.2 R450.2
TP_LAN_JTAG_TCK: R172.2 U21.35
TP_LAN_JTAG_TDI: T92.1 U21.32
TP_LAN_JTAG_TDO: T93.1 U21.34
TP_LAN_JTAG_TMS: R171.2 U21.33
TPM_GPIO4: R9545.2 U25.13
TPM_LPM#: Q4199.3 Q4200.3 R9529.2 R9532.2 U25.3
TPM_PIRQ#: R9525.2 UC1.M3
TPM_PIRQ#_R: R9525.1 R9526.2 U25.18
TPM_SERIRQ: R9527.2 R9638.2 U25.27
TRST#_XDP: JXDP1.54 UC6.12
TX_BLANKING: JWWAN1.48 T6340.1
TXD1: JIOR1.20 R3702.1 U6202.36
TXD2: R3703.1 U6202.46
TXD3: R9428.1 U6202.21 U6203.12
TXD3_T: JSER1.3 U6203.11
UART2_RXD: RC461.2 RC463.2 UC1.AD1
UART2_TXD: RC460.2 RC462.2 UC1.AD2
UIM_CLK: C9513.1 JSIMUAJ1.18 JWWAN1.32
UIM_DATA: C9514.1 JSIMUAJ1.16 JWWAN1.34
UIM_RESET: JSIMUAJ1.15 JWWAN1.30
USB2_COMP: RC593.1 UC1.AB6
USB2_ID: RC338.1 UC1.AG3
USB2_VBUSSENSE: RC339.1 UC1.AG4
USB3_PRX_DTX_N1: JIOR1.45 UC1.H8
USB3_PRX_DTX_N2: RI27.2 UC1.J6
USB3_PRX_DTX_N3: L7104.1 RN4151.3 UC1.J10
USB3_PRX_DTX_N4: L40.4 RN246.1 UC1.E10
USB3_PRX_DTX_P1: JIOR1.46 UC1.G8
USB3_PRX_DTX_P2: RI28.2 UC1.H6
USB3_PRX_DTX_P3: L7104.4 RN4151.1 UC1.H10
USB3_PRX_DTX_P4: L40.1 RN246.3 UC1.F10
USB3_PRX_L_DTX_N3: JDOCK1.32 L7104.2 RN4151.4
USB3_PRX_L_DTX_N4: D17.5 D17.6 JUSB1.5 L40.3 RN246.2
USB3_PRX_L_DTX_P3: JDOCK1.31 L7104.3 RN4151.2
USB3_PRX_L_DTX_P4: D17.4 D17.7 JUSB1.6 L40.2 RN246.4
USB3_PRX_R_DTX_N2: JWWAN1.29 RI27.1
USB3_PRX_R_DTX_P2: JWWAN1.31 RI28.1
USB3_PTX_C_DRX_N1: C1103.1 JIOR1.48
USB3_PTX_C_DRX_N2: C9550.1 RI29.2
USB3_PTX_C_DRX_N3: C9548.1 L7105.4 RN4150.1
USB3_PTX_C_DRX_N4: C292.1 L41.4 RN248.1
USB3_PTX_C_DRX_P1: C1104.1 JIOR1.49
USB3_PTX_C_DRX_P2: C9551.1 RI30.2
USB3_PTX_C_DRX_P3: C9549.1 L7105.1 RN4150.3
USB3_PTX_C_DRX_P4: C293.1 L41.1 RN248.3
USB3_PTX_CL_DRX_N3: JDOCK1.28 L7105.3 RN4150.2
USB3_PTX_CL_DRX_N4: D17.2 D17.9 JUSB1.8 L41.3 RN248.2
USB3_PTX_CL_DRX_P3: JDOCK1.29 L7105.2 RN4150.4
USB3_PTX_CL_DRX_P4: D17.1 D17.10 JUSB1.9 L41.2 RN248.4
USB3_PTX_CR_DRX_N2: JWWAN1.35 RI29.1
USB3_PTX_CR_DRX_P2: JWWAN1.37 RI30.1
USB3_PTX_DRX_N1: C1103.2 UC1.C13
USB3_PTX_DRX_N2: C9550.2 UC1.B13
USB3_PTX_DRX_N3: C9548.2 UC1.B15
USB3_PTX_DRX_N4: C292.2 UC1.C15
USB3_PTX_DRX_P1: C1104.2 UC1.D13
USB3_PTX_DRX_P2: C9551.2 UC1.A13
USB3_PTX_DRX_P3: C9549.2 UC1.A15
USB3_PTX_DRX_P4: C293.2 UC1.D15
USB20_N1: JIOR1.42 UC1.AB9
USB20_N2: L57.4 RN483.4 UC1.AD6
USB20_N2_R: JWWAN1.9 L57.3 RN483.3
USB20_N3: L7106.4 RN4152.1 UC1.AH3
USB20_N3_R: JDOCK1.34 L7106.3 RN4152.2
USB20_N4: U6204.2 UC1.AD9
USB20_N4_R: D7108.1 JUSB1.2 L42.3 RN249.2
USB20_N5: L76.4 RN247.1 UC1.AJ1
USB20_N5_R: D69.1 JUSB2.2 L76.3 RN247.2
USB20_N6: JSH1.7 UC1.AF6
USB20_N7: L3602.1 RN4105.3 UC1.AH1
USB20_N7_R: JSEC1.8 L3602.2 RN4105.4
USB20_N8: L3101.4 RN4106.1 UC1.AF8
USB20_N8_R: JWLAN1.5 L3101.3 RN4106.2
USB20_N9: L3601.1 RN3601.2 UC1.AG1
USB20_N9_R: JRCAM1.4 L3601.2 RN3601.1
USB20_N10: L75.4 RN2728.4 UC1.AH7
USB20_N10_R: L75.3 RN2728.3 U92.30
USB20_P1: JIOR1.43 UC1.AB10
USB20_P2: L57.1 RN483.2 UC1.AD7
USB20_P2_R: JWWAN1.7 L57.2 RN483.1
USB20_P3: L7106.1 RN4152.3 UC1.AJ3
USB20_P3_R: JDOCK1.35 L7106.2 RN4152.4
USB20_P4: U6204.3 UC1.AD10
USB20_P4_R: D7109.1 JUSB1.3 L42.2 RN249.4
USB20_P5: L76.1 RN247.3 UC1.AJ2
USB20_P5_R: D67.1 JUSB2.3 L76.2 RN247.4
USB20_P6: JSH1.8 UC1.AF7
USB20_P7: L3602.4 RN4105.1 UC1.AH2
USB20_P7_R: JSEC1.9 L3602.3 RN4105.2
USB20_P8: L3101.1 RN4106.3 UC1.AF9
USB20_P8_R: JWLAN1.3 L3101.2 RN4106.4
USB20_P9: L3601.4 RN3601.4 UC1.AG2
USB20_P9_R: JRCAM1.5 L3601.3 RN3601.3
USB20_P10: L75.1 RN2728.2 UC1.AH8
USB20_P10_R: L75.2 RN2728.1 U92.31
USB_BACK_EN#: R9398.2 U37.B44 US2.4
USB_IOR_PWR_EN#: JIOR1.17 R391.2 U37.A33
USB_MCARD1_DET#: JWLAN1.1 T7161.1
USB_OC0#: RP10.3 U6204.13 UC1.A9
USB_OC1#: JIOR1.18 RP10.1 UC1.C9
USB_OC2#: RP10.7 UC1.D9 US2.5
USB_OC3#: RP10.5 UC1.B9
USB_PWR_SHR_EN#: R9463.2 U37.A59 U6204.6
USB_PWR_SHR_VBUS_EN: R288.2 U37.B50 U6204.5
USH_DET#: D7110.1 R9578.1 R9589.2 U37.A16
USH_DET#_R: D7110.2 JSEC1.26 R9578.2
USH_PWR_STATE#: C9492.2 JSEC1.22 R195.2 U37.A34
USH_SMBCLK: JSEC1.11 R2736.2 U38.A50
USH_SMBDAT: JSEC1.12 R196.2 U38.B53
USX2064_RBIAS: R2720.1 U92.35
USX_SCL: QC2807.1 R2726.1 R2730.2 U92.24
USX_SDA: QC2807.4 R2727.1 R2732.2 U92.22
VCI_IN2#: R347.1 U38.B63
VCORE_VIN: PC5804.2 PR5810.2 PU5801.33
VCT_LAN_R1: R175.1 U21.6
VGA_DET: C9914.1 R74.1 U6.M3
VGA_IREF: R2810.1 U6.M5
VGA_NC: T7121.1 U6.L5
VIB_CTL1: Q3609.1 R9493.2 U37.B14
VIBRATOR: JEDP1.34 Q3609.2
VID0_PRIM_CORE: PR5614.2 PR5617.2 PR5620.1 PU5602.9
VID0_VCCIO: PR5606.2 PR5609.1 PU5601.9
VID1_PRIM_CORE: PR5613.2 PR5616.2 PR5619.1 PU5602.8
VID1_VCCIO: PR5601.2 PR5608.1 PU5601.8
VIDALERT_N: PR5804.1 PR5808.2 RC244.2 RC248.1
VIDSCLK: PR5802.1 PR5807.1 UC1.A63
VIDSOUT: PR5805.2 PR5809.2 RC249.2 UC1.D64
VMM3320_LPM_DIS: R55.1 R9543.1 U6.B2 UC1.BA8
VMM_DPB_CTRLCLK: RP6.1 U6.B12
VMM_DPB_CTRLDAT: RP6.3 U6.A12
VMM_DPC_CTRLCLK: T6305.1 U6.K13
VMM_DPC_CTRLDAT: T6306.1 U6.L14
VMM_EN: R9682.2 U6221.4
VMM_GPIO4: R9538.1 U6.B14
VMM_GPIO5: R9537.1 U6.B13
VMM_GPIO6: R9539.1 U6.C1
VMM_GPIO7: RP6.5 U6.M12
VMM_GPIO8: RP6.7 U6.M13
VMM_GPIO9: R9542.1 U6.L3
VMM_LP_EN: PR6092.1 R9682.1 U6.A5
VMM_SPI_CLK: U6.B3 U7.6
VMM_SPI_CS#: R64.1 U6.A4 U7.1
VMM_SPI_DIN: U6.B4 U7.2
VMM_SPI_DO: U6.A3 U7.5
VMM_SPI_HOLD: R65.1 U7.7
VMM_SPI_WP#: R9570.1 U6.B1 U7.3
VOL_DOWN#: JCSW1.4 R349.2 R360.2
VOL_DOWN#_R: R349.1 U38.B38
VOL_UP#: JCSW1.5 R338.2 R362.2
VOL_UP#_R: R338.1 U38.B8
VRALERT#: RC408.1 RC409.1 UC1.AM11
VSA_SEN+: PC5818.1 PC5819.2 PC5824.2 PR5832.2 RC422.2 UC1.H20
VSA_SEN-: PC5819.1 PC5825.2 PU5801.26 RC423.1 UC1.H21
VSET_5085: C367.1 R394.2 U38.A17
VSYNC_BUF: R2741.1 U6.L9
VSYNC_BUF_L: C17.1 D4.3 JCRT1.14 L5.2 R2742.1
VSYNC_BUF_R: L5.1 R2741.2
WIN8BTN: JEDP1.31 R9417.2 U37.A57
WIN8BTN_VDD: JEDP1.32 R9416.1
WIRELESS_LED#: Q22.3 Q22.6 Q25.1 Q30.3 R432.1 U37.A47
WLAN_DISBL#: U24.4 U37.B68
WLAN_GND: JWLAN1.75 R9648.2
WLAN_LED: JLED1.10 R435.2
WLAN_LED#: JWLAN1.6 Q22.1 R227.2
WLAN_LED_Q: Q16.1 Q25.6
WLAN_LED_R: Q16.3 R435.1
WLAN_WIGIG60GHZ_DIS#: D12.2 R9588.2 U37.A1
WLAN_WIGIG60GHZ_DIS_R: D12.1 JWLAN1.56
WWAN_PWR_EN: JWWAN1.6 RI31.2
WWAN_RADIO_DIS#: D7112.2 R286.2 R9445.1 U37.A53
WWAN_RADIO_DIS#_R: D7112.1 JWWAN1.8
WWAN_WAKE#: JWWAN1.23 R9592.2 U37.B43
XA20/GP16: T6263.1 U6202.29
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC93.1 JXDP1.48 RC358.1 RC491.1 UC8.1
XDP_JTAGX: RC357.1 RC402.2 UC1.A59
XDP_OBS0: JXDP1.21 RC84.2
XDP_OBS0_R: RC84.1 UC1.C55
XDP_OBS1: JXDP1.23 RC371.2
XDP_OBS1_R: RC371.1 UC1.D55
XDP_OBS2_R: T7136.1 UC1.B54
XDP_OBS3_R: T7137.1 UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC389.2 RC390.2
XTAL24_IN: RC40.1 RC44.2 UC1.E37
XTAL24_IN_R: CC7.1 RC40.2 YC2.3
XTAL24_OUT: CC6.1 RC44.1 UC1.E35 YC2.1
XTAL24M_IN: CC89.1 RC309.2 U92.33 Y8.3
XTAL24M_OUT: CC90.1 RC309.1 U92.32 Y8.1
XTALI: C190.1 R98.1 U21.10 X1.3
XTALO: R98.2 R183.2 U21.9
XTALO_R: C189.1 R183.1 X1.1
Z4012: RTCD1.1 RTCR1.2
ZVM#: T7123.1 UC1.AR56
N25881076: C136.1 R149.1
N25881078: C135.1 R148.1
N25881150: C148.2 U18.10
N25881154: R154.2 U18.3 U18.5
N25881176: C147.2 U18.12
N25884648: C402.1 U46.10
N25884728: C391.1 U43.10
N27847262: R2724.1 U92.27
N27847602: R2722.1 U92.28
N27916660: R321.1 U37.B19
N28286535: D23.2 Q3602.3
N28286556: D23.1 D24.1 Q25.4 R428.2
N28399188: C413.1 U32.6
N29376521: QZ22.5 R460.1
N31264629: Q3604.1 Q3605.6 R9414.1
N31379868: JEDP1.12 LE1.1
N32390347: Q1701.3 Q3607.1 R9453.1 R9686.1
N32768769: R9580.2 R9581.2 U43.5
N37704732: PC5801.1 PR5801.2 PU5801.2
N37704841: PC5808.1 PR5822.1
N37704844: PC5805.1 PR5822.2 PU5801.4
N37705143: PR5813.2 PU5801.3
N37705431: PR5817.2 PU5801.40
N37705513: PR5811.1 PR5814.2 PU5801.39
N37705908: PR5806.2 PU5801.38
N37706292: PR5807.2 PU5801.37
N37706345: PR5808.1 PU5801.36
N37706546: PR5809.1 PU5801.35
N37707683: PC5803.2 PR5812.2 PU5801.34
N37708781: PR5816.2 PU5801.32
N37709339: PH5801.2 PR5813.1 PR5833.2
N37709662: PC5806.2 PR5815.2 PU5801.28
N37709683: PC5806.1 PR5818.2
N37711026: PH5802.2 PR5823.1
N37711496: PC5823.2 PR5838.2 PU5801.20
N37711508: PC5823.1 PR5836.2
N37711615: PH5803.2 PR5843.1
N37713439: PH5805.1 PR5844.2
N37714014: PC5834.2 PR5847.1
N37714017: PC5834.1 PR5853.1 PU5801.8
N37718472: PC5813.2 PR5825.2
N37718797: PR5825.1 PR5826.1 PR5827.1 PU5801.5
N37719668: PC5814.2 PR5827.2
N37720303: PH5804.2 PR5834.2 PR5840.1
N37720638: PC5828.1 PR5842.2 PU5801.14
N37720783: PR5840.2 PU5801.15
N37721989: PC5815.2 PR5828.1 PU5801.23
N37722129: PC5812.2 PR5831.1 PU5801.24
N37722505: PC5816.2 PR5831.2
N37723172: PR5829.1 PR5830.1 PR5832.1 PU5801.25
N37723177: PC5817.2 PR5829.2
N37724020: PC5818.2 PR5830.2
N37728002: PC5836.1 PR5846.1
N37728005: PC5835.1 PR5846.2 PU5801.16
N37728791: PC5837.1 PR5849.1
N37729705: PC5838.2 PR5851.2
N37729720: PR5849.2 PR5850.2 PR5851.1 PU5801.17
N37735982: PC5914.1 PR5902.1
N37737217: PJP5901.1 PR5903.2
N37747714: Q3609.3 R9492.2
N37818358: PR5819.2 PU5801.31
N37888482: PC5511.1 PR5503.1
N37888825: PC5512.1 PU5501.5
N37888837: PC5506.1 PR5505.2
N37906286: PR5242.2 PU5201.21
N37906325: PR5245.1 PR5248.2 PU5201.16
N37906747: PC5233.1 PR5235.2
N37906776: PC5226.2 PR5234.1
N37907023: PC5239.1 PR5249.2 PU5201.17
N37913630: PQ5203.2 PQ5213.2 PR5205.2 PR5215.2 PR5222.2
N37913681: PQ5206.1 PQ5207.1 PQ5209.3 PR5206.1
N37917235: PR5260.2 PU5203.5
N37917241: PU5203.6 PU5203.7
N37917251: PR5254.1 PR5256.2 PR5259.2 PR5263.2 PU5203.1
N37917261: PC5240.2 PR5252.1 PR5261.2 PR5263.1 PU5203.3
N37917267: PC5241.2 PR5253.1 PR5258.1 PU5203.2
N37918611: PR5250.2 PR5251.2 PU5202.2
N37918619: PQ5220.5 PU5202.4
N37918714: PQ5220.2 PQ5220.3 PR5262.1
N37918742: PQ5220.6 PR5255.1 PR5257.2
N37925093: PQ5204.1 PQ5205.1 PQ5211.3 PR5207.1 PR5209.1
N37935243: PR5238.1 PU5201.11
N37935252: PR5239.1 PU5201.12
N37935306: PR5236.1 PU5201.10
N37936268: PC5222.2 PR5228.1 PU5201.7
N37936296: PC5224.2 PR5229.1 PU5201.8
N37936306: PR5231.1 PR5232.1 PU5201.9
N39760572: C9562.1 C9563.1 RC342.1 RC623.1 U25.1
N39919248: C76.2 R57.1
N39919254: C85.2 R45.1
N40246279: JFWP1.3 RC400.2
N40499876: RC458.1 U6217.5 UC10.4
N40499957: C9841.1 U6217.10
N40499959: C9843.2 RC456.1 U6217.8 U6217.9
N40617893: PC5109.2 PQ5103.4 PQ5104.3 PR5115.2 PR5116.1
N40617909: PL5103.2 PQ5101.3 PR5107.1
N40617911: PQ5101.1 PQ5102.3 PR5108.2 PR5109.2
N40617913: PQ5102.1 PR5107.2 PR5110.2
N40617923: PQ5101.2 PR5106.1
N40618012: PQ5104.5 PQ5104.6
N40618018: PQ5106.2 PQ5106.3 PR5117.2
N40618025: PQ5105.1 PR5112.2 PR5114.1
N40618028: PQ5106.6 PR5114.2
N40618035: PC5109.1 PQ5105.3
N40619003: PQ5203.1 PR5205.1 PR5208.2
N40619021: PQ5201.4 PR5201.2 PR5203.2
N40619038: PJP5201.2 PQ5206.3
N40619039: PJP5202.2 PQ5207.3
N40619055: PQ5212.3 PR5208.1
N40619057: PQ5213.1 PR5215.1 PR5219.2
N40619062: PQ5215.3 PR5219.1
N40619082: PQ5208.4 PR5210.2 PR5213.2
N40619084: PQ5203.3 PR5203.1
N40619087: PQ5213.3 PR5213.1
N40619103: PQ5214.2 PQ5214.3 PR5216.1
N40619115: PQ5202.6 PR5201.1
N40619122: PQ5202.2 PQ5202.3 PR5204.1
N40619139: PQ5210.6 PR5210.1
N40619145: PQ5210.2 PQ5210.3 PR5214.1
N40639016: JDEG1.1 R388.1
N40639050: JDEG1.9 R397.1 R406.1 R9577.1
N40639272: C7.1 D1.2 FANF1.1 JFAN1.4
N40639416: C363.1 R382.1
N40639448: Q12.1 R403.2
N40942623: PC5909.1 PU5901.7
N40942627: PC5909.2 PR5901.1
N40942629: PR5901.2 PU5901.6
N40943390: PR5915.2 PU5901.1
N40990975: C9840.1 U45.12
N41315003: PD5206.3 PR5230.2
N41332798: C339.1 R324.1
N41518611: Q4209.2 R142.2 R153.2
N41748705: C397.1 U43.12
N41748888: C390.1 U6217.12
N41749169: R418.2 U6217.3
N41749239: R424.2 U43.3
N41808708: PR5824.2 PU5801.1
N41930622: PC5923.1 PR5905.2
N41930626: PR5905.1 PU5902.2
N41930661: PC5924.1 PR5906.1
N41930679: PJP5903.1 PR5907.2
N41934758: PR5913.2 PU5903.1
N41935085: PC5928.1 PR5910.1
N41935105: PJP5905.1 PR5911.2
N41935204: PC5926.1 PU5903.7
N41935208: PC5926.2 PR5909.1
N41935210: PR5909.2 PU5903.6
N42006311: C427.1 U51.10
N42006406: RC464.2 RC465.2 U51.3
N42006453: C409.1 U51.12
N42016762: Q3601.1 R3603.2
N42029378: R3701.2 U6202.14
N42030930: C9453.1 U6203.1
N42030932: C9453.2 U6203.2
N42030938: C9454.1 U6203.3
N42030962: C9455.2 U6203.28
N42030964: C9455.1 U6203.24
N42030974: C9456.1 U6203.27
N42030984: R9396.1 U6203.22 U6203.23
N42702316: PC5611.2 PU5602.7
N42702326: PC5619.2 PR5615.1
N42702402: PR5618.1 PR5622.1 PU5602.14
N42703158: PC5601.2 PU5601.7
N42703168: PC5609.2 PR5605.1
N42703218: PR5607.1 PR5611.1 PU5601.14
N42703282: PR5603.1 PR5604.1 PU5601.5
N42704390: PC5709.1 PR5702.1
N42704539: PC5718.1 PR5707.1
N42707454: PC5728.1 PR5712.1
N42743777: R9647.1 U6221.9
N42775282: PC5318.1 PJP5306.1 PJP5307.1 PU5301.3
N42775605: PR5307.2 PU5301.1
N42775609: PR5308.2 PU5301.5
N42777212: CC67.2 RC83.1
N42777222: CC69.2 RC128.1
N43141708: C2800.1 C2801.1 C2802.1 C2803.1 C9885.1 L2800.3 L2800.4 L2800.9 L2800.10
N43141816: C2805.1 R9658.1 R9659.1 R9660.1 R9661.1
N43143021: JLAN1.A1 R9401.1
N43143023: JLAN1.A3 R9443.1
N43143025: JLAN1.B2 R2803.2
N43152286: Q19.5 Q19.6 R126.2
N43265037: C401.1 U45.10
N43265206: C398.1 U46.12
N43265690: R422.2 U46.3
N43409554: Q4.3 R99.2
N43409569: Q216.1 R2602.2
N43410155: Q1.1 Q17.6 R94.1
N43412177: R9488.1 U6207.3
N43412185: R9489.2 U6207.5 U6207.6
N43555147: R9567.2 R9569.2 U45.5
N43938385: R9483.1 U6204.16
N43939053: R9486.1 U6204.15
N44940275: C9957.2 R9681.1
N45563838: Q217.3 R152.1
N45978292: C9430.1 U9.5
N46095567: PC5730.1 PR5718.1
N46457457: JHS1.8 PR5223.1 PR5264.1
N46458274: Q4215.2 R403.1 R9687.2
N46579745: R9689.1 R9690.2 U38.A57
N46586336: RC624.2 U6222.4 UC14.4
N46649947: R9488.2 R9683.1 U6223.4
N46651989: R9691.2 U6223.5 U6223.6
N46939475: PC7404.2 PR7404.2
N46939509: PC7403.1 PC7405.2 PL7401.2 PR7402.2 PU7402.4 PU7402.6
N46939750: PC7405.1 PR7401.2 PR7402.1 PR7403.1
N46967671: PR7404.1 PU7401.5
N46967970: PR7406.1 PU7401.1
N47034159: PC7406.1 PU7401.7
N47099764: PR7408.1 PU7402.2
N47483770: Q4216.3 R9698.2
N47483795: D21.1 R9697.1 R9698.1

Pads without a net: D4 5; D66 5; D68 2; D2800 5; D2801 5; JAPS1 16 17 18; JBAT1 9; JCRT1 11; JCSW2 7; JDEG2 5 7; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JGFX1 11; JHDMI1 14; JSIM1 4 8; JSPK1 1 2; JWLAN1 8 9 10 11 12 13 14 15 17 19 20 21 22 23 32 34 36 59 61 65 66 67 68 70 71 73; JWWAN1 20 22 24 28 38 44 56 58 68; NOREF#4 1; NOREF#19 1; NOREF#21 1; NOREF#25 1; NOREF#30 1; NOREF#38 1; NOREF#42 1; NOREF#45 1; NOREF#47 1; NOREF#52 1; NOREF#53 1; NOREF#54 1; NOREF#55 1; NOREF#57 1; NOREF#58 1; NOREF#60 1; NOREF#61 1; NOREF#62 1; PU5301 19; PU5401 10; PU5501 2; PU5601 4; PU5602 4; PU5701 2 5; PU5702 2 5; PU5703 2 5; PU5801 13; PU5904 2 5; Q28 3 4 5; Q30 1 2 6; Q33 1 2 6; Q3602 1 2 6; Q3605 3 4 5; RP9 1; RP4804 3 4; RP4806 3; RP4808 1; RP4810 5 6; RP4811 1 2 3 4 7 8; SW5 1 4; U5 1; U6 E10 H3 H11 K2 L2 L10 L11 L12 L13 M1 M2 M10 M11; U9 4; U17 4 44 45; U22 6; U25 2 4 5 6 7 10 11 12 15 25 26 28 30 31; U26 1 2 3 4 5 6 7 8 10 12 13 14 15 17 28 29 30 31; U37 A5 A9 A12 A15 A24 A25 A32 A38 A48 A49 A58 A63 B1 B6 B8 B13 B23 B28 B29 B37 B39 B40 B47 B49 B56 B57 B60 B61 B63 B64 B65 B66; U38 B15; U92 12 13 16 17 18 19 20 21; U6202 12 51 52 53 54 56 57 58 59 60 61; U6203 20 21; U6204 9; U6205 3; U6206 3; U6218 1; UC1 A3 A4 A7 A11 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A69 AB1 AB4 AB13 AB62 AC1 AC2 AC63 AD4 AE62 AE63 AF11 AF12 AF13 AG62 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK62 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AP1 AP3 AP4 AP13 AU56 AU58 AU63 AW1 AW7 AW20 AW48 AW68 AW69 AY1 AY2 AY5 AY20 AY21 B2 B3 B7 B11 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA9 BB2 BB4 BB9 BB57 BB66 C2 C4 C7 C11 C12 C27 C28 C29 C31 C32 C33 C36 C37 C38 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D27 D28 D29 D31 D32 D33 D36 D37 D38 D54 D71 E1 E2 E3 E61 F6 F52 F60 F61 F65 G61 G65 H5 H11 H63 J2 J3 J5 J68 J71 K45 K46 L6 M1 M2 M4 N1 N2 N3 N9 N11 N12 P2 P62 V1 V2 V62 W4 W7 W8 W10 W12; Y8 2 4; YC2 2 4; YC3 2 3

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4841 vias
v2: diameter 0.559, hole 0.279, TOP to BOTTOM, 1072 vias
v3: diameter 0.457, hole 0.254, TOP to BOTTOM, 998 vias
v4: diameter 0.762, hole 0.457, TOP to BOTTOM, 466 vias
v5: diameter 0.66, hole 0.33, TOP to BOTTOM, 60 vias
v6: diameter 0.711, hole 0.356, TOP to BOTTOM, 153 vias
v7: diameter 0.66, hole 0.254, TOP to BOTTOM, 30 vias
v8: diameter 0.406, hole 0.203, TOP to BOTTOM, 675 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 35.7
  TOP w0.108: v2(83.42,36.59) 83.02,36.59 v1(82.81,36.79) 82.74,36.87 R9399.2 81.72,37.15 81.72,36.41 82.56,35.57 82.56,34.35 81.94,33.73 80.49,33.73 80.2,34.02 80.2,34.2 R28.2 79.63,33.33 R32.1 80.51,33.33 80.82,33.02 U5.4
  TOP w0.203: PR5409.1 86.3,56.58 v1(85.82,56.1)
  IN3 w0.203: v1(85.82,56.1) 86.81,55.1 86.81,49.38 83.45,46.01 83.45,37.43 v1(82.81,36.79)
1.2VP_S5: length 2.7
  TOP w0.108: PU5401.8 84.96,55.48 PC5415.1 85.25,56.1 85.12,56.22 84.82,56.22 PR5407.2
3.3V_CAM2_EN#: length 194.2
  TOP w0.108: U37.B32 263.89,56.58 263.77,56.7 v1(263.77,56.99)
  IN1 w0.089: v1(208.72,141.72) 208.72,142.59 207.8,143.52 195.96,143.52 194.67,142.23 194.57,142.23 190.99,138.65 190.99,136.19 190.49,135.68 190.49,130.23 188.35,128.09 188.35,109.61 187.89,109.16 187.89,108.45 186.29,106.85 186.29,75.34 184.36,73.41 184.36,64.5 189.3,59.56 194,59.56 194.61,58.95 202.48,58.95 206.94,54.49 206.94,53.4 209.01,51.33 215.49,51.33 218.58,54.41 218.58,56.46 221.31,59.19 222.98,59.19 223.5,58.67 224.48,58.67 225.23,59.42 229.32,59.42 230,58.73 231.05,58.73 231.14,58.81 236.18,58.81 236.71,59.34 238.27,59.34 238.44,59.17 242.83,59.17 243.15,58.85 247.12,58.85 247.45,58.52 254.82,58.52 255.31,58.03 257.36,58.03 259.08,56.31 263.08,56.31 v1(263.77,56.99)
  BOTTOM w0.108: R3603.1 v1(208.72,141.72) ; v2(264.89,56.43) 264.33,56.43 v1(263.77,56.99)
3.3V_CAM_EN#: length 187.8
  TOP w0.076: RC198.2 131.95,75.95 131.95,78.28 v2(131.3,78.93) 130.24,80 130.24,82.13 129.75,82.61 129.75,83.04 v3(129.24,83.55)
  TOP w0.108: R2602.1 34.12,108.89 34.61,109.38 v1(34.61,109.84)
  IN1 w0.076: 137.02,74.79 136.38,75.43 135.09,75.43 134.48,76.04 133.73,76.04 133.07,76.7 133.07,78.45 132.15,79.37 132.15,79.74 130.52,81.37 129.72,81.37 128.88,82.2 128.88,83.2 v3(129.24,83.55)
  IN1 w0.089: 137.02,74.79 137.45,74.35 139.69,74.35 140.27,73.78 140.27,72.86 141.69,71.44 141.69,70.87 v1(141.29,70.47)
  IN2 w0.089: v1(147.64,62.01) 146.75,61.13 146.75,60.83 146.35,60.44 144.79,60.44 143.56,61.67 134.89,61.67 133.1,63.47 118.52,63.47 117.9,62.85 107.06,62.85 84.78,85.12 84.78,85.7 81.55,88.94 74.39,88.94 71.93,91.39 71.93,92.89 64.66,100.16 64.66,104.48 59.52,109.62 57.66,109.62 57.05,110.23 52.12,110.23 50.61,108.71 35.73,108.71 v1(34.61,109.84)
  BOTTOM w0.076: v3(129.24,83.55) 129.54,83.85 UC1.AT15
  BOTTOM w0.108: v1(147.64,62.01) 148.14,62.52 148.14,69.06 147.61,69.58 144.38,69.58 144,69.97 141.79,69.97 v1(141.29,70.47)
3.3V_HDD_EN: length 28.7
  IN1 w0.076: 141.16,78.92 140.82,78.92 140.4,78.5 138.19,78.5 135.15,81.53 135.15,85.07 v3(134.74,85.49)
  IN1 w0.089: 141.16,78.92 147.32,78.92 147.42,79.02 149.92,81.52 151.12,81.52 151.25,81.65 153.66,81.65 154.52,82.51 154.52,82.53 v1(154.53,82.54)
  BOTTOM w0.076: v3(134.74,85.49) 134.87,85.49 UC1.AN5
  BOTTOM w0.108: R9563.2 154.19,82.88 v1(154.53,82.54) 154.82,82.26 v2(154.82,81.88)
3.3V_TP_EN: length 24.5
  TOP w0.076: 141.16,87.24 141.06,87.14 141.06,86.38 140.56,85.87 140.56,85.11 140.1,84.65 137.09,84.65 135.69,86.05 v3(134.73,86.05)
  TOP w0.108: 141.16,87.24 142.58,88.65 147.83,88.65 147.9,88.58 v2(150.53,88.58) 150.86,88.25 154.54,88.25 RC477.1
  BOTTOM w0.076: v3(134.73,86.05) 134.79,86.05 UC1.AM5
3.3V_TS_EN: length 202.7
  TOP w0.076: 141.16,86.18 140.72,85.74 140.72,85.03 140.17,84.48 137.03,84.48 136.05,85.46 135.36,85.46 v3(134.73,84.82)
  TOP w0.108: Q17.2 46.42,95.56 46.57,95.41 46.57,94.22 v1(46.9,93.89) 47.23,93.56 v2(47.23,93.28) ; RC478.1 150.66,87.75 150.28,88.13 148.06,88.13 147.74,88.44 142.75,88.44 141.28,86.97 141.28,86.3 141.16,86.18
  IN2 w0.089: v1(160.37,61.13) 159.35,61.13 157.73,59.51 152.36,59.51 151.2,60.66 149.48,60.66 149.16,60.35 149.16,59.91 148.37,59.11 147.74,59.11 147.57,59.28 147.23,59.28 146.89,58.94 142.88,58.94 142.37,58.44 136.06,58.44 132.46,62.05 119.39,62.05 118.77,61.42 106.47,61.42 83.27,84.62 83.27,85.2 81.05,87.43 73.89,87.43 70.51,90.8 70.51,91.6 64.64,97.47 52.33,97.47 49.43,94.57 47.58,94.57 v1(46.9,93.89)
  IN3 w0.076: 135.46,81.56 135.47,81.55 ; 134.59,82.42 134.37,82.65 134.37,84.47 v3(134.73,84.82)
  IN3 w0.089: 134.59,82.42 135.46,81.56 ; v1(150.94,73.14) 150.05,74.03 144.51,74.03 142.48,76.06 139.74,76.06 135.47,80.33 135.47,81.55
  BOTTOM w0.076: UC1.AP5 134.86,84.82 v3(134.73,84.82)
  BOTTOM w0.108: v1(150.94,73.14) 150.94,72.84 151.27,72.5 151.27,68.85 151.65,68.47 152.77,68.47 153.83,67.41 155.38,67.41 155.81,66.97 158.3,66.97 159.12,66.16 159.12,62.38 v1(160.37,61.13)
