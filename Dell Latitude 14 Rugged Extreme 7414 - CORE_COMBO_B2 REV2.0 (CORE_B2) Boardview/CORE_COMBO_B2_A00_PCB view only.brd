# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P7_R: length 14.7
  BOTTOM w0.102: RN4105.2 179.75,41.15 180.07,40.83 180.07,40.42 178.5,38.86 168.61,38.86 168.41,39.05 168.41,39.43 168.69,39.71 JSEC1.9
USB20_P8: length 230.5
  IN3 w0.102: v1(141.49,59.55) 140.83,60.21 140.06,60.21 139.9,60.05 106.6,60.05 93.41,73.25 93.41,75.35 88.08,80.68 84.82,80.68 82.84,78.7 77.33,78.7 74.38,81.65 74.38,86.56 70.63,90.31 68.8,90.31 65.85,93.26 56.73,93.26 55.33,91.86 53.5,91.86 51.97,90.34 49.05,90.34 48.14,89.42 42.05,89.42 40.88,90.59 38.9,90.59 38.57,90.92 24.19,90.92 22.39,92.72 22.39,101.49 18.07,105.8 18.07,129.81 18.81,130.54 18.81,134.13 v1(19.16,134.48)
  IN4 w0.102: v1(141.49,59.55) 141.49,59.2 141.62,59.07 142.62,59.07 143.55,59.99 143.55,62.66 147.66,66.77 147.66,69.65 144.13,73.18 144.13,73.51 143.44,74.2 143.44,77.48 141.44,79.48 141.44,81.44 141.02,81.85 140.6,81.85 140,82.45 140,84.07 139.23,84.85 139.23,85.54 136.54,88.23 134.25,88.23 133.95,88.53 133.62,88.53 133.49,88.66 v3(133.49,88.91)
  BOTTOM w0.102: RN4106.3 20.33,134.58 20.03,134.28 19.7,134.28 19.44,134.02 19.04,134.02 18.96,134.1 18.96,134.28 v1(19.16,134.48) ; UC1.AF9 132.94,89.18 132.94,89.01 133.1,88.85 133.43,88.85 v3(133.49,88.91)
USB20_P8_R: length 4.8
  BOTTOM w0.102: JWLAN1.3 24.91,136.52 24.75,136.36 24.53,136.36 23.72,135.55 23.72,134.69 23.32,134.28 22.76,134.28 22.44,134.61 L3101.2
USB20_P9: length 126.6
  TOP w0.102: v1(204.56,145.09) 204.46,144.99 204.46,144.35 v6(204.47,144.34) 204.46,144.32 204.46,143.85 204.68,143.63 205.57,143.63 206.16,143.04 206.54,143.04 206.64,143.14 206.64,144.22 206.55,144.31 L3601.4
  IN3 w0.102: v1(204.56,145.09) 204.46,144.99 204.46,144.33 204.13,144.01 200.72,144.01 198.66,141.95 198.35,141.95 194.13,141.95 190.82,138.63 190.82,135.75 190.56,135.5 190.56,130.57 188.99,128.99 188.99,120 183.78,114.8 183.45,114.8 180.6,111.95 177.2,111.95 172.83,116.32 163.89,116.32 158.76,111.2 158.76,107.81 158.47,107.52 158.47,106.38 157.52,105.42 157.52,97.52 157.77,97.27 157.77,91.55 154.55,88.33 153.12,88.33 151.32,90.13 151.32,91.96 151.06,92.22 148.68,92.22 147.38,90.92 145.1,90.92 143.67,89.5 142.15,89.5 141.55,88.9 140.51,88.9 140.14,89.27 139.45,89.27 139.35,89.17 v3(139.35,88.72)
  BOTTOM w0.076: UC1.AG2 137.41,88.37 137.64,88.37 137.66,88.36 137.86,88.28 138.57,88.28 138.65,88.35 138.85,88.35
  BOTTOM w0.102: v3(139.35,88.72) 138.98,88.35 138.85,88.35
USB20_P9_R: length 10.8
  TOP w0.102: v1(204.38,146.29) 204.68,146.59 205,146.59 v6(205.01,146.58) 205.03,146.59 205.35,146.59 205.65,146.89 205.65,147.68 205.76,147.79 206.38,147.79 206.9,147.27 206.9,147.11 206.57,146.78 RN3601.3
  BOTTOM w0.102: JRCAM1.5 207.31,149.58 207.13,149.4 207.13,146.85 206.8,146.52 204.61,146.52 v1(204.38,146.29)
USB20_P10: length 94
  IN3 w0.102: v3(134.22,87.86) 134.38,88.02 134.38,88.23 134.65,88.5 136.06,88.5 138.5,86.07 140.65,86.07 140.78,86.2 140.78,87.2 142.59,89.02 148.08,89.02 148.96,88.13 151.57,88.13 152.56,87.14 156.32,87.14 157.16,87.98 157.16,90.03 159.47,92.34 159.47,96.5 158.08,97.89 158.08,105.14 158.95,106.01 158.95,107.29 159.24,107.59 159.24,110.69 164.29,115.74 172.71,115.74 177.19,111.26 181.48,111.26 183.7,113.48 186.16,113.48 187.51,114.83 187.51,117.82 188.42,118.73 189.44,118.73 189.63,118.92 189.63,119.58 v1(189.42,119.79)
  BOTTOM w0.102: v3(134.22,87.86) 134.22,87.92 UC1.AH8 ; RN2728.2 189.31,120.57 189.62,120.26 189.62,119.99 v1(189.42,119.79)
USB20_P10_R: length 8.3
  BOTTOM w0.102: 188.07,125.58 v6(188.07,125.54) ; 188.07,125.58 186.9,126.76 186.15,126.76 185.75,127.16 185.75,127.96 185.6,128.11 U92.31 ; 188.07,125.58 188.7,124.95 188.7,124.09 189.6,123.2 189.6,122.9 189.31,122.61 RN2728.1
USB_BACK_EN#: length 205
  TOP w0.108: v1(260.56,60.85) 260.82,61.1 260.82,61.18 R9398.2 260.74,61.96 260.74,62.7 v1(259.83,63.62) ; U37.B44 v1(259.78,57.65)
  IN2 w0.089: v1(259.83,63.62) 259.27,64.17 245.78,64.17 242.84,67.11 221.26,67.11 219.97,65.83 219.97,64.87 219.08,63.98 216.98,63.98 216.66,63.66 215,63.66 214.5,63.16 208.42,63.16 206.6,61.34 204.25,61.34 202.38,59.47 196.61,59.47 195.01,61.08 195.01,61.36 191.61,64.76 191.25,64.76 185.56,70.44 185.56,74.77 188.91,78.12 188.91,84.7 190.96,86.75 190.96,92.7 190.34,93.33 190.34,95.1 190.78,95.55 190.78,104.44 189.89,105.33 189.89,106.25 187.73,108.41 187.73,113.87 184.13,117.47 182.93,117.47 181.04,119.37 166.68,119.37 165.27,120.77 162.92,120.77 160.69,123 160.69,124.12 159.68,125.14 159.68,125.29 159.68,128.1 156.52,131.26 150.05,131.26 v1(149.87,131.08)
  BOTTOM w0.108: v1(259.78,57.65) 260.18,58.04 260.51,58.04 260.97,58.5 260.97,60.44 v1(260.56,60.85) v2(259.97,61.44) ; US2.4 141.97,138.85 142.61,139.48 144.41,139.48 145.22,138.67 145.22,135.58 146.07,134.74 149.9,134.74 150.46,134.18 150.46,131.66 v1(149.87,131.08)
USB_IOR_PWR_EN#: length 168.8
  TOP w0.108: R391.2 257.11,46.52 v1(257.11,46.69) ; v1(264.35,59.68) 264.03,59.36 U37.A33
  IN1 w0.089: v1(183.27,100.7) 184.46,99.51 184.46,84.45 183.82,83.81 182.83,83.81 181.8,82.77 181.8,80.75 179.45,78.4 179.45,65.71 184.7,60.46 184.7,59.93 184.7,59.93 184.7,58.29 183.13,56.72 183.13,56.44 184.06,55.51 184.06,52.95 183.49,52.38 183.49,51.56 183.3,51.37 183.3,50.42 185.74,47.97 190.95,47.97 191.31,47.61 193.95,47.61 194.39,47.16 206.01,47.16 206.05,47.2 227.3,47.2 234.33,40.17 239.86,40.17 240.65,40.97 245.84,40.97 248.75,43.88 248.75,44.69 250.02,45.96 256.38,45.96 v1(257.11,46.69) 257.11,46.98 258.1,47.97 262.05,47.97 262.76,47.26 265.72,47.26 v1(266,47.54)
  BOTTOM w0.108: v1(264.35,59.68) 265.35,58.67 265.35,49.75 v2(265.78,49.31) 265.78,47.75 v1(266,47.54) ; JIOR1.17 178.19,99.23 178.24,99.18 180.8,99.18 182.07,100.45 183.02,100.45 v1(183.27,100.7)
USB_MCARD1_DET#: length 3.4
  TOP w0.108: T7161.1 26.48,137.02 v1(26.99,136.51)
  BOTTOM w0.108: v1(26.99,136.51) 26.48,137.02 JWLAN1.1
USB_OC0#: length 179.3
  TOP w0.108: v1(134.17,106.82) 133.41,107.58 132.8,107.58 132.27,108.11 RP10.3
  IN1 w0.089: v1(134.17,106.82) 133.59,107.4 133.59,112.99 135.14,114.54 136.79,114.54 137.25,115 137.25,122.36 135.44,124.17 135.44,125.48 136.39,126.44 136.54,126.44 136.93,126.44 137.14,126.65 137.14,127.75 135.49,129.41 132.45,129.41 132.15,129.7 126.83,129.7 124.06,132.47 115.54,132.47 113.55,130.49 110.76,130.49 109.57,131.68 105.84,131.68 105.04,130.88 105.04,129.85 103.11,127.93 99.63,127.93 97.22,125.51 97.22,123.84 95.03,121.65 94.68,121.65 92.9,119.88 83.45,119.88 82.08,118.51 79.19,118.51 77.82,119.89 67,119.89 66.58,119.46 66.58,118.82 66.34,118.59 64.29,118.59 62.37,116.66 62.37,115.49 62.27,115.39 60.13,115.39 59.37,114.63 59.37,113.73 58.66,113.02 58.66,108.87 v1(58.48,108.69)
  BOTTOM w0.102: 134.58,106.16 134.58,104.82 133.19,103.43 UC1.A9
  BOTTOM w0.108: 134.58,106.16 134.58,106.41 v1(134.17,106.82) ; U6204.13 22.3,103.12 22.67,103.49 26.5,103.49 28.76,105.76 28.76,107.6 29.86,108.69 50.53,108.69 v2(51.01,109.18) 51.88,110.05 57.12,110.05 v1(58.48,108.69)
USB_OC1#: length 63.6
  TOP w0.108: v1(134.17,106.21) v2(133.23,106.21) 131.67,107.77 RP10.1
  IN2 w0.089: v1(179.13,98.73) 178.81,98.73 177.88,97.8 168.74,97.8 167.45,96.51 163.66,96.51 161.96,98.2 161.82,98.2 158.01,98.2 156.83,97.02 156.12,97.02 155.03,98.11 151.85,98.11 150.45,99.51 143.77,99.51 139.86,103.42 139.86,104.16 138.37,105.65 134.74,105.65 v1(134.17,106.21)
  BOTTOM w0.076: 134.17,106.16 134.17,104.66 132.93,103.42 132.93,101.83 133.19,101.57 UC1.C9
  BOTTOM w0.108: v1(179.13,98.73) JIOR1.18 ; 134.17,106.16 v1(134.17,106.21)
USB_OC2#: length 59.1
  TOP w0.108: v1(134.35,108.01) 134.28,108.01 134.04,108.26 134.04,108.64 133.37,109.31 RP10.7
  IN1 w0.089: v1(141.72,113.42) 141.29,112.99 139.13,112.99 134.35,108.22 v1(134.35,108.01)
  BOTTOM w0.076: 133.79,103.18 133.79,102.22 133.44,101.87 133.44,101.63 133.46,101.61 arc(133.5,101.54) 133.52,101.46 133.52,101.33 arc(133.51,101.29) 133.48,101.25 133.29,100.93 UC1.D9
  BOTTOM w0.102: 135.06,106.16 135.06,104.74 133.79,103.47 133.79,103.18
  BOTTOM w0.108: v1(134.35,108.01) 134.35,107.86 135.06,107.15 135.06,106.16 ; US2.5 145.69,138.1 145.48,137.88 145.48,135.62 146.11,134.99 149.94,134.99 150.66,134.26 150.66,131.44 150.38,131.15 150.38,130.19 151.93,128.64 v2(151.93,127.19) 151.93,126.63 150.04,124.74 150.04,122.5 149.32,121.78 144.03,121.78 143.75,121.5 143.03,121.5 141.72,120.19 v1(141.72,113.42)
USB_OC3#: length 10
  TOP w0.108: v1(134.17,107.43) 133.87,107.43 133.61,107.68 133.61,108.67 133.34,108.95 v2(132.78,108.95) 132.77,108.96 RP10.5
  BOTTOM w0.102: UC1.B9 133.54,102.4 133.54,103.49 134.84,104.79 134.84,106.16
  BOTTOM w0.108: v1(134.17,107.43) 134.84,106.76 134.84,106.16
USB_PWR_SHR_EN#: length 289.7
  TOP w0.108: R9463.2 v1(253.3,50.79) 253.63,51.12 253.63,51.98 253.98,52.33 U37.A59
  IN2 w0.089: v1(25.46,91.45) 25.86,91.05 34.5,91.05 35.21,90.33 51.96,90.33 53.43,91.8 55.65,91.8 56.82,92.97 64,92.97 66.56,90.42 66.56,89.81 71.36,85.01 71.91,85.01 73.47,83.45 73.47,80.94 78.24,76.16 88.05,76.16 106.03,58.19 132.5,58.19 136.13,54.56 145.93,54.56 147.08,53.41 147.08,50.66 157.67,40.07 171,40.07 173.75,37.32 177.14,37.32 180.42,34.03 219.16,34.03 221.23,31.95 230.25,31.95 231.85,30.35 233.18,30.35 233.6,30.77 239.36,30.77 241.36,32.77 245.64,32.77 245.68,32.74 250.84,32.74 251.11,33 254.97,33 v1(255.36,33.39)
  IN4 w0.089: v1(255.36,33.39) 255.03,33.71 255.03,37.72 255.35,38.03 255.35,39.97 254.82,40.5 254.82,45.79 254.35,46.26 254.35,48.03 253.03,49.35 253.03,49.68 253.3,49.96 v1(253.3,50.79)
  BOTTOM w0.108: v1(25.46,91.45) 25.46,91.63 25.59,91.75 25.59,92.57 25.38,92.78 25.38,92.98 24.25,94.11 23.43,94.11 23.3,94.24 U6204.6 ; v1(253.3,50.79) 253.63,50.46 v2(253.63,50.15)
USB_PWR_SHR_VBUS_EN: length 299.8
  TOP w0.108: U37.B50 256.78,57.98 256.73,57.93 256.73,57.2 v1(257.14,56.78) ; v1(255.08,60.63) 254.82,60.88 R288.2
  IN2 w0.089: v1(254.52,33.44) 254.52,33.44 253.61,34.35 249.99,34.35 248.85,33.21 245.68,33.21 245.17,33.72 243.34,33.72 242.68,33.06 240.93,33.06 240.24,32.37 239.2,32.37 237.78,30.95 233.53,30.95 233.1,30.53 231.93,30.53 230.33,32.13 221.31,32.13 219.23,34.21 204.08,34.21 202.86,35.43 179.28,35.43 177.21,37.49 173.83,37.49 170.89,40.42 157.56,40.42 147.38,50.61 147.38,53.36 146,54.73 136.2,54.73 132.57,58.36 106.1,58.36 88.12,76.34 78.32,76.34 73.65,81.01 73.65,83.53 71.99,85.19 71.43,85.19 66.74,89.88 66.74,90.49 64.08,93.15 56.74,93.15 55.57,91.98 53.36,91.98 51.89,90.51 35.29,90.51 34.35,91.45 v1(26.1,91.45)
  BOTTOM w0.108: v2(255.08,61.47) v1(255.08,60.63) 254.82,60.38 254.82,59.11 v1(257.14,56.78) 257.65,56.28 257.65,51.32 256.7,50.38 256.7,48.04 255.99,47.33 255.99,46.08 254.98,45.06 254.98,42.06 254.89,41.98 254.89,40.78 254.12,40.02 254.12,36.75 255.04,35.82 255.04,34.46 254.52,33.94 254.52,33.44 v1(254.52,33.44) ; U6204.5 23.8,94.49 23.97,94.32 24.33,94.32 25.59,93.07 25.59,92.87 26.1,92.36 v1(26.1,91.45)
USH_DET#: length 127.8
  TOP w0.108: R9589.2 264.86,46.52 v1(264.65,46.72) 264.03,47.34 U37.A16
  IN1 w0.089: v1(267.49,29.08) 267.49,30.18 263.21,34.46 263.21,38.08 263,38.29 v1(262.6,38.29)
  IN2 w0.089: v1(175.27,32.43) 175.77,32.93 177.24,32.93 177.86,32.32 219.28,32.32 220.98,30.62 227.67,30.62 229.27,29.02 240.65,29.02 241.46,28.21 245.53,28.21 248.02,30.7 254.65,30.7 255.36,31.42 266.3,31.42 267.49,30.23 v1(267.49,29.08)
  BOTTOM w0.108: v2(267.8,29.86) 267.49,29.54 v1(267.49,29.08) ; v1(264.65,46.72) 264.65,45.48 264.41,45.24 264.41,43.64 261.89,41.12 261.89,39 v1(262.6,38.29) ; D7110.1 179.33,34.81 179.33,34.15 R9578.1 178.48,33.3 176.14,33.3 v1(175.27,32.43)
USH_DET#_R: length 5.2
  BOTTOM w0.108: R9578.2 177.94,33.97 177.79,33.82 v2(177.33,33.82) 177.33,34.46 177.4,34.53 D7110.2 177.96,35.67 177.96,36.18 177.19,36.96 JSEC1.26
USH_PWR_STATE#: length 123.5
  TOP w0.108: U37.A34 263.53,59.37 263.84,59.68 v1(263.84,63.01)
  IN3 w0.089: v1(175.02,36.28) 175.47,36.74 177.56,36.74 177.99,36.31 224.5,36.31 229.16,40.98 232.84,40.98 234.05,39.76 239.72,39.76 240.8,40.84 246.07,40.84 246.54,40.37 258.34,40.37 259.37,41.41 259.37,44.04 261.14,45.81 264.96,45.81 v1(266.63,47.49)
  BOTTOM w0.108: v1(266.63,47.49) 266.24,47.88 266.24,49.66 265.56,50.34 265.56,61.28 v2(264.56,62.28) v1(263.84,63.01) ; JSEC1.22 175.19,36.46 v1(175.02,36.28) 175.02,35.8 C9492.2 R195.2
USH_SMBCLK: length 91.6
  TOP w0.108: U38.A50 227.8,59.88 v1(227.29,60.39)
  IN4 w0.089: v1(170.7,44.64) 171.28,45.22 181.32,45.22 183.03,43.51 197.05,43.51 198.27,44.72 213.75,44.72 217.57,40.9 225.48,40.9 225.89,41.31 226.8,41.31 v1(227.26,41.77)
  BOTTOM w0.108: v1(170.7,44.64) 170.23,45.11 169.92,45.11 169.77,44.95 169.41,44.95 168.79,44.34 v2(168.79,44.11) 168.79,42.56 168.9,42.46 169,42.46 R2736.2 169.28,41.52 169.69,41.1 JSEC1.11 ; v1(227.26,41.77) 227.26,44.4 225.97,45.69 225.97,47.62 226.3,47.95 226.3,48.91 225.18,50.03 225.18,52.46 226.63,53.9 226.63,55.11 227.53,56.01 227.53,56.89 225.92,58.5 225.92,60.47 226.26,60.8 226.88,60.8 v1(227.29,60.39)
USH_SMBDAT: length 100
  TOP w0.108: v1(227.48,61.31) 229.25,61.31 229.72,60.84 229.72,60.38 229.47,60.13 U38.B53 ; v1(170.19,36.28) 170.19,41.39 168.79,42.79 168.79,43.7 169.73,44.64 v1(170.09,44.64)
  IN4 w0.089: v1(226.63,41.77) 225.84,41.77 225.27,41.19 217.71,41.19 213.89,45.02 198.14,45.02 196.93,43.8 183.15,43.8 181.44,45.51 170.96,45.51 v1(170.09,44.64)
  BOTTOM w0.108: JSEC1.12 v1(170.19,36.28) ; R196.2 169.28,44.28 169.63,44.64 v1(170.09,44.64) ; v1(226.63,41.77) 226.83,41.97 226.83,42.67 v2(226.59,42.9) 226.83,43.14 226.83,44.39 225.62,45.6 225.62,46.82 225.36,47.07 225.36,49.19 224.85,49.7 224.85,52.57 226.32,54.03 226.32,55.33 227.22,56.23 227.22,56.68 225.61,58.28 225.61,60.6 226.15,61.13 227.3,61.13 v1(227.48,61.31)
USX2064_RBIAS: length 3.2
  BOTTOM w0.108: v2(182.46,126.02) 182.87,126.43 182.87,126.91 R2720.1 183.36,127.01 183.76,127.41 183.76,127.75 183.6,127.91 U92.35
USX_SCL: length 12.9
  TOP w0.108: QC2807.1 188.75,133.7 v1(188.68,133.77)
  IN1 w0.089: v1(188.68,133.77) 188.02,133.77 187.87,133.92 v1(187.87,136.03)
  BOTTOM w0.108: v1(188.68,133.77) 188.83,133.62 189.72,133.62 R2730.2 190.18,131.84 v2(189.39,131.05) 189.02,130.68 U92.24 ; R2726.1 189.75,135.75 188.91,135.75 188.78,135.62 188.28,135.62 v1(187.87,136.03)
USX_SDA: length 9.8
  TOP w0.108: v1(187.13,136.01) 187.59,135.54 QC2807.4
  BOTTOM w0.108: v1(187.13,136.01) 187.82,135.32 v2(187.95,135.32) R2727.1 188.83,134.86 188.38,134.86 188.12,134.6 188.12,133.75 188.71,133.16 R2732.2 188.78,132.65 188.78,131.94 188.52,131.68 U92.22
VCI_IN2#: length 19.2
  TOP w0.108: v1(223.49,46.55) 223.49,46.56 223.84,46.9 R347.1 ; U38.B63 v1(229.96,55.13)
  IN3 w0.089: v1(229.93,46.22) 229.91,46.24 227.26,46.24 227.11,46.08 226.69,46.08 225.83,46.95 223.89,46.95 v1(223.49,46.55)
  BOTTOM w0.108: v1(229.96,55.13) 229.52,54.69 229.52,53.4 229.31,53.19 229.31,49.79 228.76,49.23 228.76,47.39 v1(229.93,46.22) ; v2(223.49,45.71) v1(223.49,46.55)
VCORE_VIN: length 9.1
  TOP w0.203: PU5801.33 72.56,116.56 72.96,116.96 72.96,117.92 73.57,118.53 74.51,118.53
  TOP w0.381: PR5810.2 74.2,121.73 74.31,121.63 74.31,120.49 v2(74.13,120.31)
  TOP w0.406: v2(74.13,120.31) 74.13,120.13 74.56,119.7 PC5804.2 75.12,119.14 74.51,118.53
VCT_LAN_R1: length 2.8
  TOP w0.108: U21.6 145.35,128.9 144.71,128.26 143.7,128.26 143.57,128.13 R175.1
VGA_DET: length 6
  TOP w0.089: U6.M3 84.5,132.28 83.85,132.93 83.63,132.93
  TOP w0.108: 83.63,132.93 82.92,132.93 82.69,132.7 v1(82.45,132.7) 82.35,132.8 R74.1
  BOTTOM w0.108: C9914.1 82.23,134.45 v2(82.3,134.38) 82.45,134.23 v1(82.45,132.7)
VGA_IREF: length 3.2
  TOP w0.089: 84.03,130.98 U6.M5
  TOP w0.102: 83.63,130.98 84.03,130.98
  TOP w0.108: 83.63,130.98 83.49,130.98 v2(82.69,131.79) 82.64,131.84 R2810.1
VGA_NC: length 1.2
  TOP w0.089: U6.L5 v8(85.63,131.31)
  BOTTOM w0.089: v8(85.63,131.31) 85.43,131.52 T7121.1
VIB_CTL1: length 275.5
  TOP w0.108: v1(41.73,97.77) 42.59,97.77 43.7,98.87 R9493.2 43.82,99.31 Q3609.1 ; v1(263,49.55) 262.78,49.33 U37.B14
  IN2 w0.089: v1(41.73,97.77) 41.45,97.48 41.45,94 44.23,91.22 51.59,91.22 53.06,92.69 55.28,92.69 56.45,93.86 64.63,93.86 67.45,91.04 67.45,90.18 71.73,85.9 72.51,85.9 74.36,84.05 74.36,81.31 78.51,77.15 88.32,77.15 106.33,59.14 132.83,59.14 135.42,56.55 143.62,56.55 144.24,55.94 145.41,55.94 145.9,55.45 146.94,55.45 148.83,53.56 148.83,49.91 157.76,40.98 171.44,40.98 174.39,38.03 177.43,38.03 179.37,36.09 202.96,36.09 204.31,34.74 219.6,34.74 221.38,32.96 237.81,32.96 239.11,34.27 240.47,34.27 241.16,34.96 242.53,34.96 245.66,38.09 261.78,38.09 v1(261.99,38.29)
  BOTTOM w0.108: v1(261.99,38.29) 261.68,38.6 261.68,42.46 262.27,43.04 v2(262.27,43.47) 262.27,45.07 262.49,45.3 262.49,49.04 v1(263,49.55)
VIBRATOR: length 4.1
  TOP w0.108: v1(40.73,100.38) 40.73,99.81 41.02,99.52 Q3609.2 39.71,99.31 v2(39.56,99.45)
  BOTTOM w0.108: v1(40.73,100.38) 40.73,100.6 41.03,100.9 JEDP1.34
VID0_PRIM_CORE: length 9
  BOTTOM w0.108: v2(170.52,108.73) 170.26,108.73 169.33,107.79 169.33,106.72 169.05,106.44 PR5617.2 PR5620.1 169.35,105.14 169.35,104.26 PR5614.2 169.63,103.75 170.22,104.33 170.67,104.33 170.76,104.24 PU5602.9
VID0_VCCIO: length 4.3
  BOTTOM w0.108: PR5606.2 PR5609.1 175.17,76.19 173.92,76.19 173.37,76.74 PU5601.9
VID1_PRIM_CORE: length 8.5
  BOTTOM w0.108: v2(166.56,106.44) PR5616.2 PR5619.1 166.94,105.02 166.94,103.52 PR5613.2 168.03,102.43 169.12,102.43 169.33,102.63 169.33,103.11 169.44,103.23 PU5602.8
VID1_VCCIO: length 3.7
  BOTTOM w0.108: PU5601.8 173.78,77.34 174.36,77.92 175.17,77.92 PR5608.1 PR5601.2
VIDALERT_N: length 36.9
  TOP w0.108: PR5808.2 v1(70.72,121.1) 70.72,121.43 v2(71,121.7) 71,122.29 PR5804.1
  IN4 w0.089: v1(70.72,121.1) 71.47,120.35 71.47,118.71 72.22,117.96 82.27,117.96 84.41,115.82 86.61,115.82 87.03,116.24 87.56,116.24 87.98,115.82 89.5,115.82 89.85,116.17 91.58,116.17 91.93,115.82 92.71,115.82 93.72,114.81 96.48,114.81 v1(97,114.29)
  BOTTOM w0.108: RC244.2 95.88,114.85 96.44,114.85 v1(97,114.29) 97.88,113.41 RC248.1
VIDSCLK: length 48.2
  TOP w0.108: PR5807.1 v1(69.86,121.15) 69.86,121.58 70.11,121.83 70.11,122.28 PR5802.1
  IN4 w0.089: v7(96.22,114.21) 96.17,114.26 93.41,114.26 92.96,114.71 84.75,114.71 82.05,117.42 71.99,117.42 70.93,118.48 70.93,120.08 v1(69.86,121.15)
  BOTTOM w0.076: UC1.A63 102.04,102.78 102.04,103.01 100.09,104.97 98.56,104.97
  BOTTOM w0.108: v7(96.22,114.21) 96.99,113.44 96.99,111.85 96.92,111.78 96.92,110.41 96.75,110.24 96.75,106.81 96.61,106.67 96.61,106.12 97.43,105.3 98.23,105.3 98.56,104.97
VIDSOUT: length 50
  TOP w0.108: PR5805.2 71.61,122.01 71.61,121.17 v1(71.59,121.15) PR5809.2
  IN4 w0.089: v7(98.04,114.35) 97.71,114.35 96.71,115.35 94.11,115.35 93.09,116.37 92.19,116.37 91.84,116.72 89.63,116.72 89.28,116.37 88.23,116.37 87.77,116.83 86.83,116.83 86.37,116.37 84.64,116.37 82.5,118.51 72.45,118.51 72.02,118.94 72.02,120.71 v1(71.59,121.15)
  BOTTOM w0.076: UC1.D64 101.76,101.3 101.76,101.4 arc(101.78,101.51) 101.84,101.6 101.98,101.73 102.2,101.73 102.5,102.04 102.5,102.48 102.54,102.57 102.54,102.93 102.43,103.05 102.43,103.54 102.09,103.87 101.81,103.87 101.61,104.08
  BOTTOM w0.108: v7(98.04,114.35) 98.44,113.95 98.44,111.63 98.33,111.52 98.33,109.82 RC249.2 97.88,107.3 99.38,105.8 99.88,105.8 101.61,104.08
VMM3320_LPM_DIS: length 170.5
  TOP w0.089: U6.B2 91.47,133.24 92.05,133.24 92.23,133.07 93.01,133.07 93.03,133.08
  TOP w0.108: 93.03,133.08 93.13,133.08 v1(93.52,133.47) 93.86,133.12 93.86,132.96 R55.1
  IN1 w0.089: v1(83.09,133.35) 83.45,133.71 84.37,133.71 85.65,134.99 86.8,134.99 88.25,136.44 90.36,136.44 91.45,135.35 93.38,135.35 93.66,135.07 93.66,134.35 93.52,134.21 v1(93.52,133.47) 93.78,133.21 99.42,133.21 101.37,135.15 103.4,135.15 104.84,136.6 106,136.6 107.12,137.73 107.12,140.73 108.68,142.29 111.43,142.29 111.92,141.8 130.41,141.8 134.04,138.16 135.55,138.16 142.66,131.06 142.66,128.54 143.19,128 143.19,127.24 142.53,126.58 142.53,125.5 142.03,124.99 142.03,124.19 142.81,123.41 142.81,120 143.59,119.22 153.12,119.22 163.39,108.95 163.39,107.51 161.19,105.3 161.19,101.01 160.74,100.57 160.74,99.37 159.66,98.29 158.81,98.29 158.2,97.68 158.2,96.83 156.09,94.72 156.09,93.78 155.77,93.46 152.9,93.46 152.2,92.76 152.2,92.76 150.65,91.21 148.23,91.21 146.44,89.43 146.44,89.19 145.69,88.44 142.13,88.44 140.98,87.29 140.98,86.58 140.21,85.81 140.21,83.53 140.67,83.07 140.76,83.07 141.27,82.56 141.27,80.94 v3(140.37,80.05)
  BOTTOM w0.076: v3(140.37,80.05) 140.37,79.85 139.56,79.03 138.44,79.03 138.02,78.61 135.3,78.61 134.6,79.31 134.2,79.31 133.67,79.85 133.67,80.91 UC1.BA8
  BOTTOM w0.089: v1(93.52,133.47) v2(93.05,133.01)
  BOTTOM w0.108: R9543.1 83.45,133.71 v1(83.09,133.35)
VMM_DPB_CTRLCLK: length 7.3
  TOP w0.089: 91.47,124.89 91.47,126.12 U6.B12
  TOP w0.108: 91.47,124.89 91.47,124.76 91.07,124.35 91.07,123.25 91.6,122.72 92.01,122.72 v5(92.49,122.24) 92.84,121.89 RP6.1
VMM_DPB_CTRLDAT: length 8.4
  TOP w0.089: v1(92.48,124.45) 92.48,125.19 92.12,125.56 92.12,125.91 91.81,126.22 U6.A12
  TOP w0.108: v1(91.73,122.11) 92.23,121.61 RP6.3
  BOTTOM w0.089: v2(93.2,124.85) 92.89,124.85 v1(92.48,124.45) 92.48,124.43 92.72,124.19
  BOTTOM w0.108: v1(91.73,122.11) 92.44,122.11 92.87,122.54 92.87,124.04 92.72,124.19
VMM_DPC_CTRLCLK: length 7.8
  TOP w0.089: 84.46,124.19 84.51,124.24 85.89,124.24 86.27,124.63 86.27,125.47 U6.K13
  TOP w0.108: 84.46,124.19 82.64,122.37 82.64,121.3 T6305.1
VMM_DPC_CTRLDAT: length 4.4
  TOP w0.108: U6.L14 84.8,124.63 84.58,124.63 83.44,123.48 83.04,123.48 T6306.1
VMM_EN: length 13.9
  TOP w0.108: R9682.2 96.39,111.74 96.39,110.85 95.1,109.56 95.1,109.12 94.09,108.12 v2(91.88,108.12) 89.19,108.12 88.63,108.67 88.63,110.55 88.85,110.77 U6221.4
VMM_GPIO4: length 5.7
  TOP w0.108: R9538.1 90.26,120.84 90.1,120.99 90.1,122.16 v5(90.56,122.62) 90.21,122.97 90.21,123.99 91.16,124.94 U6.B14
VMM_GPIO5: length 12.5
  TOP w0.108: U6.B13 90.84,125.46 90.84,125 90,124.16 90,122.64 89.88,122.52 89.88,120.69 R9537.1 88.91,119.72 88.91,118.23 88.68,118 87.34,118 87.03,117.69 87.03,116.9 87.29,116.65 87.78,116.65 v5(87.99,116.43)
VMM_GPIO6: length 4.4
  TOP w0.108: R9539.1 92.26,135.37 91.83,134.94 91.83,134.91 U6.C1
VMM_GPIO7: length 17.2
  TOP w0.108: v1(91.75,121.5) 91.73,121.49 RP6.5 ; U6.M12 84.65,126.43 82.05,126.43 v2(82.02,126.4) 81.82,126.2 v1(81.82,125.73)
  IN1 w0.089: v1(81.82,125.73) 81.85,125.7 81.85,124.7 85.65,120.9 91.15,120.9 v1(91.75,121.5)
VMM_GPIO8: length 14.8
  TOP w0.108: v1(90.64,123.66) 90.64,123.23 90.76,123.11 90.76,123.11 91.05,122.82 91.15,122.72 91.15,122.06 91.29,121.92 91.29,121.07 91.13,120.91 RP6.7 ; v1(82.48,125.78) U6.M13
  IN1 w0.089: v1(90.64,123.66) 89.97,124.33 86.26,124.33 85.51,125.08 84.24,125.08 83.54,125.78 v1(82.48,125.78)
VMM_GPIO9: length 5.5
  TOP w0.089: 83.63,133.43 84.46,132.6 85,132.6 U6.L3
  TOP w0.108: 83.63,133.43 82.94,134.11 v1(82.88,134.11)
  BOTTOM w0.108: v2(83.45,136.23) R9542.1 82.88,134.67 v1(82.88,134.11)
VMM_LP_EN: length 58.3
  TOP w0.108: R9682.1 97.93,113.22 98.62,113.91 98.62,115.39 97.68,116.32 97.09,116.32 95.7,117.71 95.42,117.71 95.18,117.95 95.18,118.28 95.21,118.31 95.21,122.03 v1(93.97,123.28) ; v8(92.82,131.76) 92.45,131.39 92.2,131.39 91.81,131 U6.A5 ; v2(69.34,142.71) 69.34,142.8 v1(68.9,143.24) 68.31,143.24 PR6092.1
  IN1 w0.089: v8(92.82,131.76) 93.36,131.76 95.08,130.04 95.08,124.52 93.97,123.41 v1(93.97,123.28)
  IN4 w0.089: v1(68.9,143.24) 70.42,141.72 80.83,141.72 82.36,140.2 88.02,140.2 93.51,134.7 93.51,134.2 93.08,133.77 93.08,132.02 v8(92.82,131.76)
VMM_SPI_CLK: length 30.6
  TOP w0.089: U6.B3 91.16,132.28 v8(90.84,131.96)
  TOP w0.108: U7.6 77.53,141.97 77.33,141.77 77.33,140.55 v2(75.78,139) 75.25,138.47 v1(75.25,135.88)
  IN4 w0.089: v1(75.25,135.88) 74.97,136.16 74.97,136.74 76.64,138.42 85.41,138.42 86.93,136.89 86.93,134.74 88.45,133.21 90.08,133.21 90.84,132.45 v8(90.84,131.96)
VMM_SPI_CS#: length 37.9
  TOP w0.089: v8(92.28,131.76) 91.94,131.76 U6.A4
  TOP w0.108: v1(70.29,140.96) 70.29,143.47 72.39,145.57 72.62,145.57 v2(73.06,146.01) 73.47,146.42 R64.1 74.05,144.97 73.59,144.51 U7.1
  IN4 w0.089: v1(70.29,140.96) 71.18,140.07 79.94,140.07 80.96,139.05 86.17,139.05 87.69,137.53 87.69,134.99 88.83,133.85 90.36,133.85 91.88,132.32 91.88,132.16 v8(92.28,131.76)
VMM_SPI_DIN: length 40.3
  TOP w0.089: U6.B4 91.16,131.63 v8(90.84,131.31)
  TOP w0.108: v1(69.68,140.93) 70.07,140.55 71.19,140.55 71.66,140.07 74.59,140.07 74.84,140.32 74.84,142.66 74.26,143.24 U7.2 71.82,143.24 v2(71.4,143.66)
  IN4 w0.089: v8(90.84,131.31) 91.37,131.85 91.37,132.45 90.23,133.59 88.58,133.59 87.31,134.86 87.31,137.4 85.91,138.8 80.07,138.8 79.18,139.69 70.92,139.69 v1(69.68,140.93)
VMM_SPI_DO: length 20.9
  TOP w0.089: v8(92.59,132.22) 92.53,132.28 U6.A3
  TOP w0.108: U7.5 79.82,140.7 v1(80.07,140.96) 80.58,140.45 v2(80.58,140.07)
  IN4 w0.089: v8(92.59,132.22) 90.49,134.33 88.86,134.33 88.07,135.12 88.07,137.66 86.29,139.43 81.6,139.43 v1(80.07,140.96)
VMM_SPI_HOLD: length 3
  TOP w0.108: v2(80.71,141.9) R65.1 80.25,142.94 79.94,143.24 U7.7
VMM_SPI_WP#: length 31.1
  TOP w0.108: R9570.1 93.53,135.07 92.72,135.07 92.54,134.89 v1(92.37,134.89) 92.26,134.79 92.26,134.69 U6.B1 ; v1(70.93,140.96) 70.93,141.3 v2(71.47,141.85) 71.6,141.97 U7.3
  IN4 w0.089: v1(70.93,140.96) 71.44,141.47 80.45,141.47 82.23,139.69 87.56,139.69 v1(92.37,134.89)
VOL_DOWN#: length 165.2
  TOP w0.108: v1(144.18,65.86) 143.97,65.64 143.02,65.64 142.57,65.19 141.23,65.19 137.75,61.71 136.15,61.71 134.94,60.49 133.18,60.49 v2(132.57,61.1) 131.91,61.76 128.65,61.76 126.87,63.55 125.8,63.55 125.5,63.25 JCSW1.4 ; v1(238.99,65.52) 239.2,65.3 R360.2 R349.2
  IN2 w0.089: v1(247.87,50.15) 247.51,49.8 232.23,49.8 232,49.56 229.22,49.56 228.82,49.17 225.24,49.17 225.12,49.05 225.12,48.42 224.83,48.12 207.6,48.12 204.38,51.34 196.24,51.34 193.92,49.02 193.81,48.92 188.04,48.92 187.76,48.64 187.76,48.24 187.59,48.06 184.58,48.06 181.09,51.55 181.09,56 179.21,57.87 177.69,57.87 170.68,64.89 168.59,64.89 167.93,65.55 158.61,65.55 156.82,67.34 148.67,67.34 146.75,65.42 144.61,65.42 v1(144.18,65.86)
  BOTTOM w0.108: v1(238.99,65.52) 238.99,65.49 239.6,64.88 241.93,64.88 243.44,63.37 243.44,62.57 244.03,61.99 244.03,60.93 245.06,59.91 245.06,57.58 245.32,57.32 246.25,57.32 246.58,56.99 246.58,53.75 247.46,52.88 247.46,50.56 v1(247.87,50.15)
VOL_DOWN#_R: length 4.9
  TOP w0.108: U38.B38 v1(236.5,60.72) ; R349.1 237.88,63.51 v1(237.88,63.26)
  IN4 w0.089: v1(237.88,63.26) 238.28,62.86 238.28,62.48 237,61.2 236.98,61.2 v1(236.5,60.72)
VOL_UP#: length 141.4
  TOP w0.108: R338.2 244.84,51.37 244.92,51.3 R362.2 245.53,50.28 v1(246.06,50.28) ; v1(144.99,65.82) 144.6,65.43 143.1,65.43 142.61,64.94 141.27,64.94 138.88,62.55 137.83,61.5 137.66,61.5 137.66,61.5 136.43,61.5 135.06,60.14 131.74,60.14 v2(130.8,61.08) 130.36,61.51 128.61,61.51 126.8,63.32 126.12,63.32 126,63.2 JCSW1.5
  IN2 w0.089: v1(246.06,50.28) 245.75,49.97 232.16,49.97 231.93,49.74 229.15,49.74 228.75,49.34 219.72,49.34 218.67,48.3 207.67,48.3 204.45,51.52 196.16,51.52 193.74,49.1 187.15,49.1 186.55,48.5 184.49,48.5 181.27,51.72 181.27,56.1 179.31,58.05 177.76,58.05 170.75,65.06 168.71,65.06 168.6,65.17 168.4,65.38 168.4,65.38 168.05,65.72 167.9,65.72 158.69,65.72 156.89,67.52 148.6,67.52 148.49,67.42 146.9,65.82 v1(144.99,65.82)
VOL_UP#_R: length 13.9
  TOP w0.108: v1(243.65,50.99) 243.65,51.4 R338.1 ; v1(233.82,53.2) 233.59,53.2 233.41,53.02 233.41,52.37 233.5,52.28 U38.B8
  IN1 w0.089: v1(233.82,53.2) 234.5,52.51 234.5,52.48 235.13,51.85 242.79,51.85 v1(243.65,50.99)
  BOTTOM w0.108: v2(242.94,50.99) v1(243.65,50.99)
VRALERT#: length 37.2
  IN1 w0.089: v1(150.94,86.35) 149.79,85.21 149.79,82.26 147.03,79.49 140.19,79.49 139.63,78.93 138.44,78.93 136.76,80.61 136.76,82.21 135.85,83.12 135.85,84.52 136.25,84.92 136.25,85.51 134.94,86.82 132.74,86.82 132.4,86.48 131.43,86.48 v3(131.07,86.12)
  BOTTOM w0.108: v1(150.94,86.35) 150.94,87.8 RC408.1 152.03,87.87 152.69,87.87 v2(153.3,88.48) 153.33,88.51 153.93,88.51 RC409.1 ; UC1.AM11 131.19,86.12 v3(131.07,86.12)
VSA_SEN+: length 60.6
  TOP w0.108: v1(85.49,105.4) 85.53,105.44 85.53,106.32 v2(83.82,108.03) 83.82,109.29 PC5818.1 84.36,110.35 84.44,110.43 PR5832.2 83.89,111.05 83.75,110.91 PC5824.2 PC5819.2 ; RC422.2 96.49,107.97 96.49,106.1 96.75,105.84 v3(97.41,105.84)
  IN4 w0.089: v3(126.5,97.8) 126.32,97.98 125.79,97.98 125.49,98.28 119.66,98.28 119.44,98.05 119.29,98.05 119.29,98.05 104.06,98.05 103.88,98.23 103.16,98.95 103.16,99.84 102.91,100.09 102.91,100.76 103.13,100.98 103.13,101.42 100.55,104 99.25,104 v3(97.41,105.84) 94.61,105.84 94.15,106.31 91.34,106.31 91.2,106.17 86.92,106.17 86.15,105.4 v1(85.49,105.4)
  BOTTOM w0.108: UC1.H20 126.72,97.8 v3(126.5,97.8)
VSA_SEN-: length 73.9
  TOP w0.108: v1(97.06,106.4) 97.06,107.48 98.51,108.93 98.51,109.79 RC423.1 ; PU5801.26 74.92,113.85 75.21,113.56 76.27,113.56 PC5825.2 76.84,114.13 79.23,114.13 79.36,114.26 79.65,114.26 79.75,114.36 80.66,114.36 80.74,114.28 80.76,114.28 81.01,114.02 81.01,112.24 80.98,112.21 80.98,111.65 82.56,110.07 PC5819.1 83.07,109.64 83.37,109.64 83.59,109.42 83.59,108.53 83.32,108.27 82.69,108.27 82.56,108.14 82.56,107.91 82.94,107.53 83.99,107.53 85.29,106.23 85.29,105.87 v1(84.87,105.44) 84.54,105.12 v2(84.54,104.84)
  IN4 w0.089: v3(126.5,98.37) 126.3,98.16 125.86,98.16 125.57,98.46 119.59,98.46 119.36,98.23 104.13,98.23 103.34,99.03 103.34,99.91 103.08,100.16 103.08,100.69 103.34,100.94 103.34,101.47 100.6,104.2 99.56,104.2 97.36,106.4 v1(97.06,106.4) 96.93,106.26 94.55,106.26 94.29,106.52 91.25,106.52 91.11,106.38 86.83,106.38 86.26,105.8 85.23,105.8 v1(84.87,105.44)
  BOTTOM w0.108: UC1.H21 126.37,98.37 v3(126.5,98.37)
VSET_5085: length 5
  TOP w0.108: v2(242.57,49.92) 242.57,50.78 R394.2 241.77,51.58 241.77,51.74 C367.1 241.4,52.15 240.67,52.88 U38.A17
VSYNC_BUF: length 20.5
  TOP w0.089: 83.63,126.94 83.65,126.94 83.71,127 83.73,127 84.04,127.31 84.04,127.33 84.29,127.57 84.29,127.8 84.56,128.07 85,128.07 U6.L9
  TOP w0.108: v1(80.02,127.8) 80.66,127.17 83.11,127.17 83.34,126.94 83.63,126.94
  BOTTOM w0.108: v1(80.02,127.8) 80.41,128.19 80.41,129.37 79.74,130.03 79.74,137.58 80.96,138.8 80.96,139.05 v2(80.99,139.08) 81.85,139.94 R2741.1
VSYNC_BUF_L: length 16.1
  IN4 w0.089: v1(89.44,145.12) 89.01,145.56 89.01,146.89 JCRT1.14
  BOTTOM w0.108: L5.2 87.08,141.95 88.28,143.15 91.71,143.15 v2(91.81,143.24) 92.16,143.6 R2742.1 C17.1 D4.3 90.08,144.92 89.88,145.12 v1(89.44,145.12)
VSYNC_BUF_R: length 3.2
  BOTTOM w0.108: L5.1 v2(83.37,141.95) 82.28,141.95 R2741.2
WIN8BTN: length 274.4
  TOP w0.108: R9417.2 v1(253.2,51.68) 253.2,52.19 253.5,52.48 253.79,52.48 254.63,53.32 254.63,53.33 U37.A57
  IN2 w0.089: v1(254.57,37.4) 254.14,36.97 244.79,36.97 242.61,34.79 241.23,34.79 240.54,34.09 239.24,34.09 237.93,32.79 221.3,32.79 219.53,34.56 204.23,34.56 203.01,35.78 179.42,35.78 177.36,37.85 174.22,37.85 171.29,40.78 157.71,40.78 148.76,49.74 148.63,49.87 148.63,53.51 146.87,55.27 145.83,55.27 145.34,55.76 144.17,55.76 143.55,56.38 135.35,56.38 132.76,58.97 106.25,58.97 88.24,76.98 78.44,76.98 74.18,81.23 74.18,83.98 72.44,85.72 71.66,85.72 67.27,90.11 67.27,90.97 64.56,93.68 56.52,93.68 55.35,92.51 53.14,92.51 51.67,91.04 44.15,91.04 41.27,93.93 41.27,97.97 42.29,98.98 v1(42.29,99.99)
  IN4 w0.089: v1(253.2,51.68) 252.85,51.32 252.85,49.26 254.17,47.94 254.17,46.19 254.55,45.81 254.55,39.28 254.57,39.25 v1(254.57,37.4)
  BOTTOM w0.108: JEDP1.31 42.53,100.83 42.45,100.75 42.45,100.16 v1(42.29,99.99) ; v2(253.58,52.26) 253.58,52.05 v1(253.2,51.68)
WIN8BTN_VDD: length 6.7
  TOP w0.108: v2(39.66,97.57) 40.55,97.57 41.72,98.74 v1(41.72,99.68)
  BOTTOM w0.254: R9416.1 41.39,99.68 v1(41.72,99.68) 41.69,99.71 41.69,100.08 42.03,100.41 JEDP1.32
WIRELESS_LED#: length 409.9
  TOP w0.254: v1(26.73,133.59) 25.84,133.59 25.53,133.27 Q30.3 ; R432.1 260.74,6.06 v1(260.74,6.21) ; Q25.1 v1(271.19,11.31) ; Q22.3 28.45,131.65 28.66,131.43 v1(29.02,131.43) 29.39,131.43 29.75,131.07 Q22.6 30.33,129.99 32.01,128.31 32.01,117.86 v2(31.8,117.64) 31.6,117.44 31.6,116.05 32.41,115.24 v1(32.41,113.42) ; U37.A47 257.03,59.22 256.78,59.48 256.29,59.48 256.14,59.32 255.41,59.32 254.16,60.57 254.16,60.64 253.58,61.23 253.45,61.23 253.3,61.38 253.3,63.49 v1(253.2,63.59)
  IN1 w0.254: v1(271.19,11.31) 272.93,13.05 272.93,61.96 270.92,63.97 262.67,63.97 261.96,63.26 261.28,63.26 260.44,64.1 256.17,64.1 254.98,62.91 253.83,62.91 253.2,63.54 v1(253.2,63.59) 253.14,63.65 250.47,63.65 249.62,64.5 246.01,64.5 242.81,67.7 224.14,67.7 222.57,66.13 v1(222.57,65.65)
  IN2 w0.254: v1(220.09,46.44) 220.09,46.4 219.37,45.68 209.01,45.68 208.86,45.53 205.76,45.53 203.1,48.2 196.97,48.2 194.71,45.94 183.64,45.94 175.94,53.64 173.08,53.64 171.8,54.92 171.8,56.83 170.55,58.08 169.38,58.08 166.82,60.64 166.82,60.95 165.02,62.75 162.85,62.75 162.65,62.95 158.96,62.95 158.36,62.35 155.23,62.35 153.13,64.45 152.37,64.45 150.42,62.51 147.45,62.51 146.32,61.38 146.04,61.38 145.87,61.2 144.4,61.2 143.67,61.93 135,61.93 133.21,63.73 118.41,63.73 117.79,63.11 107.17,63.11 85.04,85.23 85.04,85.81 81.66,89.2 74.49,89.2 72.19,91.5 72.19,93.03 69.43,95.8 69.43,105.61 65.33,109.72 63.06,109.72 61.5,111.28 51.86,111.28 50.22,109.65 43.74,109.65 39.97,113.42 v1(32.41,113.42)
  BOTTOM w0.254: v1(222.57,65.65) 222.57,65.61 221.55,64.6 221.55,62.47 219.23,60.15 219.23,55.45 219.85,54.83 219.85,52.61 219.47,52.23 219.47,48.32 220.09,47.7 v1(220.09,46.44) ; v1(260.74,6.21) 261.54,5.42 264.82,5.42 269.17,9.77 270.25,9.77 271.19,10.71 v1(271.19,11.31) ; v1(29.02,131.43) 27.65,131.43 26.73,132.35 v1(26.73,133.59)
WLAN_DISBL#: length 192.3
  TOP w0.108: v1(255.97,48.18) 255.89,48.18 255.63,48.44 U37.B68 ; v1(160.7,134.86) 160.34,135.23 160.34,136.01 U24.4
  IN1 w0.089: v1(255.97,48.18) 255.97,47.13 255.16,46.32 249.74,46.32 248.37,44.95 248.37,44.01 245.69,41.32 240.51,41.32 239.71,40.53 234.48,40.53 227.45,47.56 205.9,47.56 205.86,47.52 194.54,47.52 194.1,47.96 191.45,47.96 189.72,49.7 189.72,51.17 190.56,52 190.56,54.65 187.3,57.91 187.3,59.88 181.07,66.11 181.07,77.54 184.99,81.46 184.99,107.4 185.71,108.11 185.71,118.13 184.99,118.84 184.99,119.47 183.85,120.61 177.15,120.61 v1(176.34,121.43)
  IN2 w0.089: v1(160.7,134.86) 159.7,133.87 159.7,131.3 160.84,130.16 160.84,129.5 161.83,128.51 161.83,125.45 162.43,124.85 162.43,124.16 163.16,123.43 165.07,123.43 167.36,121.14 173.4,121.14 174.29,122.03 175.73,122.03 v1(176.34,121.43)
  BOTTOM w0.108: v2(255.97,48.84) v1(255.97,48.18)
WLAN_GND: length 3.3
  BOTTOM w0.305: JWLAN1.75 24.33,118.52 24.17,118.68
  BOTTOM w0.508: 24.17,118.68 R9648.2 23.3,118.68 22.79,119.19 v2(22.44,119.19)
WLAN_LED: length 13.3
  TOP w0.254: R435.2 267.47,9.44 v1(267.82,9.78)
  BOTTOM w0.254: v2(260.51,10.01) 260.68,9.84 JLED1.10 260.68,7.46 260.96,7.17 261.36,7.17 262.76,5.77 264.48,5.77 267.82,9.11 v1(267.82,9.78)
WLAN_LED#: length 6.5
  TOP w0.254: v1(29.02,135.12) 29.4,135.12 v2(29.69,134.82) 29.83,134.68 R227.2 29.83,133.26 29.75,133.18 Q22.1
  BOTTOM w0.254: v1(29.02,135.12) 30.41,135.12 31.06,135.77 JWLAN1.6
WLAN_LED_Q: length 5
  TOP w0.108: Q16.1 269.06,12.11 v1(269.68,11.49) 269.96,11.77 270.98,11.77 271.19,11.99 Q25.6
  BOTTOM w0.108: v1(269.68,11.49) 269.23,11.49 v2(269,11.27)
WLAN_LED_R: length 2.4
  TOP w0.254: v2(268.31,8.14) 268.34,8.17 R435.1 268.34,9.63 268.41,9.7 Q16.3
WLAN_WIGIG60GHZ_DIS#: length 298.7
  TOP w0.108: U37.A1 256.53,47.85 256.43,47.74 255.65,47.74 255.26,48.13 254.19,48.13 v1(253.68,47.61) 252.97,47.61 252.77,47.41 R9588.2 ; v1(24.05,121.46) 25.12,122.53 v2(25.69,122.53) D12.2
  IN2 w0.089: v1(24.05,121.46) 21.67,119.08 21.67,114.85 22.81,113.7 24.39,113.7 29.56,108.54 50.68,108.54 52.2,110.05 56.98,110.05 57.59,109.44 59.45,109.44 64.48,104.41 64.48,100.01 71.75,92.74 71.75,91.32 74.31,88.76 81.47,88.76 84.61,85.63 84.61,85.05 106.99,62.67 117.97,62.67 118.59,63.29 133.02,63.29 134.82,61.49 143.43,61.49 144.66,60.26 146.43,60.26 147,60.84 147,60.84 147.74,61.58 148.49,61.58 148.87,61.95 150.23,61.95 152.48,64.19 153.02,64.19 155.13,62.09 158.6,62.09 159.21,62.69 161.43,62.69 162.34,61.79 164.76,61.79 165.49,61.06 165.49,60.18 167.85,57.82 170.45,57.82 171.54,56.73 171.54,54.82 172.98,53.38 175.83,53.38 183.53,45.68 194.81,45.68 197.08,47.94 202.99,47.94 205.66,45.27 208.96,45.27 209.12,45.42 226.32,45.42 226.92,44.82 229.32,44.82 233.54,40.6 239.57,40.6 241.37,42.41 241.67,42.41 243.34,44.08 252.8,44.08 v1(253.46,43.41)
  BOTTOM w0.108: v1(253.68,47.61) 253.27,47.2 253.27,43.6 v1(253.46,43.41)
WLAN_WIGIG60GHZ_DIS_R: length 4.6
  TOP w0.108: v2(31.18,122.49) 30.9,122.49 v1(29.98,123.41) 29.59,123.01 D12.1
  BOTTOM w0.108: v1(29.98,123.41) 30.12,123.27 JWLAN1.56
WWAN_PWR_EN: length 4.6
  BOTTOM w0.108: v2(97.62,125.34) 98.31,124.65 98.31,123.99 98.53,123.76 98.84,123.76 RI31.2 99.63,123.31 100.11,122.83 JWWAN1.6
WWAN_RADIO_DIS#: length 282.9
  TOP w0.108: v1(253.2,55.87) 252.94,55.61 R286.2 253.42,55.33 U37.A53
  IN2 w0.089: v1(89.43,107.23) 88.45,107.23 86.53,105.31 86.53,104.85 87.05,104.33 87.05,103.84 86.79,103.57 84.55,103.57 83.37,104.75 83.37,104.85 80.9,107.32 73.76,107.32 73.12,106.68 73.12,104.32 74.23,103.21 74.23,99.4 76.87,96.76 76.87,94.28 80.59,90.56 82.21,90.56 86.45,86.32 86.45,85.71 107.72,64.43 117.24,64.43 117.86,65.06 133.77,65.06 135.21,63.62 138.78,63.62 140.08,64.92 146.5,64.92 148.67,67.09 156.48,67.09 158.33,65.24 167.42,65.24 169.72,62.94 170.78,62.94 171.01,62.71 171.01,62.53 173.38,60.17 175.03,60.17 177.51,57.7 179.03,57.7 180.91,55.81 180.91,51.48 184.5,47.89 190,47.89 190.85,48.74 193.89,48.74 196.31,51.16 204.3,51.16 207.52,47.94 227.85,47.94 229.29,49.38 232.07,49.38 232.31,49.62 251.44,49.62 253.01,51.19 253.55,51.19 v1(254.04,51.68)
  IN3 w0.089: v1(87.21,115.81) 87.54,116.14 87.54,116.47 87.06,116.94 87.06,118.16 87.47,118.56 94.78,118.56 99.47,123.25 99.47,123.84 100.28,124.64 v1(100.28,124.92)
  IN4 w0.089: v1(253.2,55.87) 254.11,54.95 254.15,54.95 254.56,54.54 254.56,52.2 v1(254.04,51.68)
  BOTTOM w0.108: v1(100.28,124.92) 99.31,124.92 98.87,125.36 D7112.2 ; v1(89.43,107.23) 89.42,107.23 88.63,108.01 88.63,109.04 R9445.1 87.67,110.01 87.67,114.82 87.82,114.97 87.82,115.58 87.59,115.81 v1(87.21,115.81) ; v2(253.53,55.11) 253.53,55.54 v1(253.2,55.87)
WWAN_RADIO_DIS#_R: length 5.5
  BOTTOM w0.108: v2(97.62,127.09) 98.39,126.33 98.39,125 D7112.1 99.73,123.66 99.78,123.66 100.12,123.33 JWWAN1.8
WWAN_WAKE#: length 233.2
  TOP w0.108: U37.B43 260.28,57.63 260.41,57.5 v1(260.66,57.5) ; v1(261.81,60.95) 262.06,61.2 R9592.2
  IN2 w0.089: v1(261.81,60.95) 261.12,61.63 258.41,61.63 258.33,61.71 246.72,61.71 244.16,64.27 227.03,64.27 226.44,63.67 222.47,63.67 222.3,63.84 220.71,63.84 216.12,59.25 213.7,59.25 212.87,60.08 206.48,60.08 205.84,59.45 204.26,59.45 202.15,57.33 196.83,57.33 194.25,59.91 190.29,59.91 186.92,63.28 186.83,63.28 184.42,65.69 184.42,69.74 183.81,70.35 183.81,79.73 187.92,83.84 187.92,85.03 187.92,85.33 188.78,86.18 188.78,96.2 188.4,96.57 188.4,105.17 183.27,110.31 176.18,110.31 175.27,111.21 173.98,112.5 167.14,112.5 164.48,115.16 158.54,115.16 155.22,118.48 140.02,118.48 132.4,126.1 128.74,126.1 126.86,127.98 123.6,127.98 122.74,128.84 122.74,129.38 120.31,131.81 114.59,131.81 112.53,129.76 108.82,129.76 106.11,127.04 105.88,127.04 v1(105.32,126.48)
  BOTTOM w0.108: v1(105.32,126.48) 105.91,127.08 JWWAN1.23 ; v2(261.81,61.8) v1(261.81,60.95) 261.18,60.32 261.18,58.03 v1(260.66,57.5)
XA20/GP16: length 3.2
  TOP w0.108: U6202.29 258.44,30.38 258.28,30.21 v1(258.28,29.88)
  BOTTOM w0.108: v1(258.28,29.88) 257.74,30.42 T6263.1
XCLK_BIASREF: length 4
  TOP w0.076: v3(113.72,99.71) 112.8,98.79 112.29,98.79 RC324.1 111.38,98.35 111.29,98.26 RC52.1
  BOTTOM w0.076: UC1.E42 114,99.99 v3(113.72,99.71)
XDP_DBRESET#: length 98
  TOP w0.108: v2(82.15,116.02) v1(82.74,115.43)
  IN1 w0.089: v1(135.14,113.55) 135.96,114.36 136.86,114.36 137.43,114.93 137.43,122.44 135.62,124.25 135.62,125.41 136.46,126.26 137,126.26 137.33,126.59 137.33,127.82 135.56,129.59 132.52,129.59 132.23,129.88 126.9,129.88 124.13,132.65 115.46,132.65 113.48,130.66 110.83,130.66 109.64,131.86 105.77,131.86 104.86,130.96 104.86,129.93 103.04,128.11 99.53,128.11 97.04,125.62 97.04,123.91 95,121.87 94.57,121.87 92.82,120.12 81.5,120.12 v1(80.29,118.91)
  IN3 w0.089: v1(80.29,118.91) 80.29,117.88 v1(82.74,115.43)
  BOTTOM w0.108: v1(80.29,118.91) 80.29,118.94 80.3,118.93 JXDP1.48 ; UC8.1 135.92,115.4 135.44,114.92 135.44,113.93 135.14,113.63 v1(135.14,113.55) 135.14,113.27 135.44,112.97 RC491.1 ; RC358.1 83.32,114.85 83.21,114.73 CC93.1 v1(82.74,115.43)
XDP_JTAGX: length 13.1
  BOTTOM w0.089: UC1.A59 104.59,103.23 104.73,103.37 104.99,103.37 105.2,103.58 105.2,103.89 103.13,105.96 103.13,106.16
  BOTTOM w0.108: 103.13,106.16 103.13,106.33 102.8,106.67 102.8,110.51 102.7,110.61 102.65,110.61 v2(102.09,111.16) 101.76,111.49 101.76,112.06 RC357.1 RC402.2
XDP_OBS0: length 4.3
  BOTTOM w0.108: JXDP1.21 73.8,125.87 73.8,125.87 v2(73.8,125.9) 73.8,126.35 RC84.2
XDP_OBS0_R: length 70
  TOP w0.108: v1(66.94,122.16) 66.53,122.57 v2(66.3,122.57)
  IN4 w0.089: v1(105.17,115.63) 102.69,118.11 96.24,118.11 95.67,118.68 84.85,118.68 83.74,119.79 77.8,119.79 77.44,120.15 77.44,121.75 76.62,122.57 67.81,122.57 67.4,122.16 v1(66.94,122.16)
  BOTTOM w0.076: 106.36,106.16 106.36,104.89 106.63,104.62 106.63,101.87 UC1.C55
  BOTTOM w0.108: v1(66.94,122.16) 66.94,122.39 66.71,122.62 66.71,122.65 66.71,122.65 66.71,126.31 67.92,127.52 70.67,127.52 71.82,128.67 72.93,128.67 73.21,128.39 RC84.1 ; 106.36,106.16 106.36,106.21 105.83,106.74 105.83,114.97 v1(105.17,115.63)
XDP_OBS1: length 7
  BOTTOM w0.108: JXDP1.23 74.3,125.18 74.36,125.24 74.36,127.5 v2(74.28,127.57) 74.28,128.05 RC371.2
XDP_OBS1_R: length 68.5
  IN4 w0.089: v1(106.27,109.18) 105.85,109.6 105.85,114.33 102.46,117.71 94.32,117.71 93.75,118.28 84.69,118.28 83.58,119.39 77.64,119.39 74.85,122.18 67.97,122.18 67.56,121.76 66.43,121.76 v1(66.4,121.79)
  BOTTOM w0.076: UC1.D55 106.73,101.31 106.73,101.44 106.79,101.58 106.82,101.61 106.82,101.87 106.8,101.89 106.8,105.27
  BOTTOM w0.108: 106.8,105.27 v2(106.87,105.35) 106.87,106.39 106.27,106.99 v1(106.27,109.18) ; RC371.1 71.86,129.32 70.51,127.98 67.75,127.98 66.27,126.5 66.27,122.44 66.4,122.31 v1(66.4,121.79)
XDP_OBS2_R: length 2.9
  TOP w0.108: T7136.1 107.17,103.64 v3(107.63,103.64)
  BOTTOM w0.089: UC1.B54 107.34,102.33 107.34,102.9 107.24,102.99 107.24,103.25 v3(107.63,103.64)
XDP_OBS3_R: length 1.2
  TOP w0.108: T7137.1 105.22,101.44 105.22,101.44 v3(105.48,101.18)
  BOTTOM w0.076: v3(105.48,101.18) 105.71,101.41 UC1.C56
XDP_PRSNT_PIN1: length 7
  BOTTOM w0.108: RC390.2 RC389.2 v2(70.22,126.73) 69.58,126.73 68.8,125.95 JXDP1.1
XTAL24_IN: length 10.8
  IN4 w0.089: v1(117.87,106.49) 117.87,105.78 117.26,105.17 117.26,101.13 v3(116.51,100.38)
  BOTTOM w0.076: v3(116.51,100.38) 116.9,99.99 UC1.E37
  BOTTOM w0.108: RC40.1 RC44.2 118.94,108.09 117.87,107.03 v1(117.87,106.49)
XTAL24_IN_R: length 5.7
  BOTTOM w0.108: v2(117.92,108.67) 118.07,108.83 RC40.2 118.07,110.21 CC7.1 118.63,110.76 118.63,112.64 117.67,113.59 YC2.3
XTAL24_OUT: length 13.3
  IN4 w0.089: v3(117.28,100.32) 117.44,100.47 117.44,104.41 118.71,105.68 v1(118.71,106.39)
  BOTTOM w0.076: 117.32,100.28 v3(117.28,100.32)
  BOTTOM w0.108: v1(118.71,106.39) 119.8,107.48 RC44.1 CC6.1 YC2.1 ; 117.32,100.28 117.61,99.99 UC1.E35
XTAL24M_IN: length 6.9
  BOTTOM w0.108: v2(182.51,123.89) 183.17,123.89 183.29,123.77 Y8.3 184.08,124.44 CC89.1 185.08,125.44 185.08,125.9 RC309.2 184.6,126.37 U92.33
XTAL24M_OUT: length 7.3
  BOTTOM w0.108: Y8.1 186.15,122.07 185.28,122.95 185.28,124.44 185.76,124.93 CC90.1 185.76,125.65 185.74,125.68 RC309.1 185.74,126.14 185.1,126.77 v2(185.1,127.12) U92.32
XTALI: length 9.7
  TOP w0.108: 147,127.12 147.15,127.27 147.15,128.41 146.95,128.61 U21.10 ; 147,127.12 147.31,126.81 v2(147.97,126.81) ; 147,127.12 146.28,126.39 C190.1 145.45,124.94 145.45,122.7 X1.3
XTALO: length 3.4
  TOP w0.108: U21.9 146.55,128.58 146.69,128.44 v2(146.69,128.06) 146.69,127.67 R98.2 145.76,126.73 R183.2
XTALO_R: length 3.2
  TOP w0.108: X1.1 144.02,124.63 C189.1 144.02,126.21 R183.1
Z4012: length 2.7
  TOP w0.305: RTCR1.2 v2(75.93,31.46)
  TOP w0.508: RTCD1.1 75.9,29.57 75.93,29.6 RTCR1.2
ZVM#: length 2.6
  TOP w0.108: T7123.1 105.95,83.71 v3(105.47,84.19)
  BOTTOM w0.076: v3(105.47,84.19) 105.61,84.19 UC1.AR56
N25881076: length 3.5
  TOP w0.108: R149.1 50.25,122.31 51.45,122.31 C136.1 52.59,122.8 v2(52.82,122.57)
N25881078: length 3.8
  TOP w0.108: v2(51.94,120.31) C135.1 51.39,122.08 50.32,122.08 R148.1
N25881150: length 4.3
  BOTTOM w0.108: U18.10 48.79,129 C148.2 47.88,129.91 v2(46.29,129.91)
N25881154: length 5.5
  BOTTOM w0.108: U18.5 53.33,129 R154.2 ; R154.2 54.42,130.09 54.42,130.91 v2(54.31,131.02) ; R154.2 53.74,129.83 53.73,129.84 52.86,129.84 52.82,129.8 U18.3
N25881176: length 3.3
  BOTTOM w0.108: U18.12 49.32,129.8 49.08,130.04 48.89,130.04 C147.2 48.19,130.73 48.19,131.23 v2(47.94,131.48)
N25884648: length 2.6
  TOP w0.108: C402.1 208.11,63.08 207.73,62.7 v2(207.73,62.57) 207.73,62.5 207.73,62.49 U46.10
N25884728: length 4.2
  TOP w0.108: v5(180.86,98.97) 181.47,98.36 181.52,98.36 C391.1 184.21,97.91 184.23,97.92 U43.10
N27847262: length 6.1
  BOTTOM w0.108: v2(191.3,127.7) 191.3,126.89 R2724.1 190.59,127.39 188.91,127.39 188.61,127.7 188.61,128.99 188.42,129.18 U92.27
N27847602: length 3.9
  BOTTOM w0.108: R2722.1 v2(189.34,126.78) 189.06,126.78 187.42,128.43 U92.28
N27916660: length 5.2
  TOP w0.108: U37.B19 264.66,50.08 264.56,49.99 264.56,49.37 265.31,48.62 265.31,47.28 v2(265.54,47.05) 266.03,46.57 266.2,46.57 R321.1
N28286535: length 9.5
  TOP w0.108: v2(257.81,21.27) 258.38,20.7 258.38,19.51 258.79,19.1 259.41,19.1 259.74,18.77 259.74,18.09 259.01,17.36 D23.2 259.83,16.68 260.11,16.96 261.69,16.96 261.8,16.85 Q3602.3
N28286556: length 20.2
  TOP w0.108: D24.1 258.59,18.35 258.51,18.26 258.51,15.55 D23.1 260.42,15.04 R428.2 261.25,14.21 266.33,14.21 266.96,14.85 268.03,14.85 268.67,14.21 272.4,14.21 v2(272.51,14.33) 272.91,13.93 272.91,13.63 272.49,13.21 Q25.4
N28399188: length 2.8
  BOTTOM w0.254: C413.1 198.86,40.2 v2(198.63,40.42) 198.63,40.62 198.94,40.93 U32.6
N29376521: length 7
  TOP w0.108: QZ22.5 17.86,120.51 17.23,121.15 R460.1 v1(16.75,121.78)
  BOTTOM w0.108: v1(16.75,121.78) 16.75,122.22 17.18,122.64 19.77,122.64 v2(20.53,123.41)
N31264629: length 6
  BOTTOM w0.108: R9414.1 153.99,126.94 153.63,127.29 v2(153.63,127.85) 154.65,127.85 154.87,127.63 Q3604.1 155.7,128.35 156.61,129.26 Q3605.6
N31379868: length 2.9
  BOTTOM w0.108: JEDP1.12 52.03,100.39 v2(51.73,100.09) LE1.1
N32390347: length 6.1
  BOTTOM w0.108: Q1701.3 91.68,117.29 91.83,117.13 91.83,116.45 91.94,116.34 Q3607.1 92.76,116.34 93.15,115.94 R9453.1 92.44,115.05 v2(92.19,114.8) 91.78,114.8 91.68,114.69 R9686.1
N32768769: length 5
  TOP w0.108: R9580.2 R9581.2 188.59,96.8 v2(188.17,97.22) 188.17,97.68 187.87,97.98 187.16,97.98 187.1,97.92 U43.5
N37704732: length 9.9
  TOP w0.108: PC5801.1 PR5801.2 63.89,119.01 v2(63.89,118.35) 64.02,118.23 66.32,118.23 67,117.55 67.92,117.55 68.72,116.75 68.72,115.18 68.84,115.05 PU5801.2
N37704841: length 2.2
  TOP w0.108: PR5822.1 64.18,115.78 v2(63.98,115.98) 63.71,116.24 PC5808.1
N37704844: length 4.3
  TOP w0.108: PU5801.4 68.83,114.25 68.01,115.08 68.01,115.43 67.5,115.94 66.3,115.94 66.14,115.78 PR5822.2
N37705143: length 2.5
  TOP w0.108: PR5813.2 68.49,116.14 68.49,114.97 68.81,114.65 PU5801.3
N37705431: length 6
  TOP w0.108: PU5801.40 69.76,116.43 68.57,117.62 68.57,117.87 v2(68.06,118.38) 67.65,117.97 67.17,117.97 66.86,118.28 66.86,119.37 PR5817.2
N37705513: length 5.3
  TOP w0.108: PU5801.39 70.16,116.48 69.56,117.08 v2(69.56,117.39) 68.82,118.12 68.82,118.71 PR5814.2 PR5811.1
N37705908: length 7.4
  TOP w0.108: PR5806.2 69.19,122.2 v5(69.19,121.5) 69.28,121.41 69.28,118.57 70.19,117.65 70.19,117.21 70.56,116.84 PU5801.38
N37706292: length 4
  TOP w0.108: PR5807.2 70.35,119.08 70.35,118.3 70.8,117.85 70.8,117.13 70.96,116.97 PU5801.37
N37706345: length 3.9
  TOP w0.108: PR5808.1 70.95,119.34 70.95,118.73 v2(70.85,118.63) 71.36,118.12 PU5801.36
N37706546: length 3.8
  TOP w0.108: PR5809.1 71.97,119.19 71.97,117.23 v2(71.92,117.18) 71.76,117.03 PU5801.35
N37707683: length 9.1
  TOP w0.216: PC5803.2 73.11,119.56 73.11,118.81 72.59,118.29 72.59,117.09 72.16,116.67 PU5801.34
  TOP w0.254: PC5803.2 72.5,119.74 72.25,119.99 72.25,121.74 72.57,122.06 72.91,122.06 v2(73.19,122.34) PR5812.2
N37708781: length 5.5
  TOP w0.108: PU5801.32 72.96,116.53 73.7,117.26 v2(73.7,117.84) 73.92,118.07 74.82,118.07 75.48,118.73 75.48,118.98 PR5816.2
N37709339: length 43.2
  TOP w0.108: v1(54.67,89.35) 55.85,89.35 56.63,89.71 58.53,90.14 58.59,90.15 59.92,90.15 PH5801.2 PR5833.2 ; PR5813.1 66.86,116.45 66.79,116.37 64.93,116.37 v1(64.65,116.65)
  IN1 w0.089: v1(64.65,116.65) 64.65,115.4 62.59,113.34 62.59,108.94 57.01,103.36 57.01,95.85 56.19,95.02 56.19,91.8 55.48,91.09 55.48,90.72 54.67,89.91 v1(54.67,89.35)
  BOTTOM w0.108: v1(54.67,89.35) 55.28,88.74 v2(56.5,88.74)
N37709662: length 4.8
  TOP w0.222: PU5801.28 74.58,114.65
  TOP w0.254: 74.58,114.65 75.13,114.65 75.29,114.81 75.81,114.81 75.81,114.81 75.82,114.81 v2(76.43,115.42) 76.7,115.69 PC5806.2 PR5815.2
N37709683: length 2
  TOP w0.254: PR5818.2 78.55,114.95 v2(78.43,114.83) PC5806.1
N37711026: length 2.8
  TOP w0.254: PH5802.2 122.11,116.38 PR5823.1 121.27,115.55 v5(121.27,114.59)
N37711496: length 8.5
  TOP w0.108: PC5823.2 79.81,110.61 79.54,110.61 PR5838.2 79.18,111.11 79,111.3 78.63,111.3 78.1,110.77 77.55,110.77 77.36,110.96 v2(75.07,110.96) 73.55,110.96 73.36,111.14 PU5801.20
N37711508: length 2
  TOP w0.254: PR5836.2 80.83,109.13 v2(80.15,109.13) 80.13,109.15 PC5823.1
N37711615: length 1.2
  TOP w0.254: PH5803.2 PR5843.1
N37713439: length 5.2
  TOP w0.254: v2(73.98,89.83) 73.14,90.67 PH5805.1 72.39,90.09 72.12,89.83 PR5844.2
N37714014: length 1.7
  TOP w0.254: PC5834.2 66.23,110.25 PR5847.1
N37714017: length 6.2
  TOP w0.222: PU5801.8 68.66,112.65 68.65,112.67 68.26,112.67 67.99,112.4 67.99,111.14 PC5834.1
  TOP w0.254: PR5853.1 65.54,109.39 65.57,109.36 v2(66.11,109.36) 66.37,109.61 66.37,109.8 66.85,110.29 67.08,110.29 67.09,110.3 67.14,110.3 PC5834.1
