# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCK_SMB_ALERT#: length 139.5
  TOP w0.108: R292.2 252.94,56.83 v1(253.02,56.76) 253.45,56.33 U37.A51
  IN3 w0.089: v1(252.21,63.16) 252.21,62.78 251.83,62.4 251.32,62.4 251.24,62.32 248.19,62.32 246.67,63.85 245.4,63.85 240.6,68.64 240.14,68.64 239.63,69.15 223.5,69.15 222.03,67.69 216.73,67.69 213.4,64.36 208.08,64.36 206.69,62.96 196.96,62.96 194.52,65.39 194.06,65.39 190.61,68.84 190.61,69.7 189.75,70.56 189.75,76.59 186.85,79.49 186.85,91.26 182.63,95.48 180.54,95.48 179.76,96.26 176.92,96.26 175.76,95.09 166.53,95.09 160.84,100.78 160.08,100.78 v1(159.37,101.49)
  BOTTOM w0.108: v1(252.21,63.16) 252.21,62.62 252.13,62.55 252.13,62.19 251.47,61.53 251.47,60.57 252.54,59.5 v2(252.54,57.98) 252.54,57.24 v1(253.02,56.76) ; v1(159.37,101.49) 158.03,100.15 JDOCK1.8
DOCK_SMB_CLK: length 146.8
  TOP w0.108: R361.1 230.37,47.24 230.37,47.57 v1(230.69,47.89) ; U38.B4 231.5,53.01 v1(231.68,53.2)
  IN3 w0.089: v1(159.38,100.27) 159.64,100.01 160.4,100.01 165.9,94.51 176.5,94.51 177.12,95.14 179.49,95.14 180.49,94.13 182.43,94.13 186.12,90.45 186.12,79.4 189.16,76.35 189.16,70.32 190.03,69.46 190.03,68.01 190.56,67.48 190.56,66.32 195.08,61.8 196.93,61.8 197.17,62.03 200.51,62.03 200.85,62.37 206.92,62.37 208.33,63.77 213.64,63.77 216.97,67.1 225.88,67.1 226.12,67.34 231.37,67.34 231.54,67.52 232.75,67.52 233.01,67.79 233.6,67.79 v1(234,68.19)
  IN4 w0.089: v1(234,68.19) 234,68.41 234.31,68.73 239.25,68.73 241.16,66.82 241.16,62.97 240.43,62.24 240.43,61.35 v1(240.28,61.2)
  BOTTOM w0.108: JDOCK1.10 158.02,99.15 159.14,100.27 v1(159.38,100.27) ; v1(240.28,61.2) 239.87,61.61 239.45,61.61 239.01,61.18 239.01,60.81 239.01,59.87 238.21,59.06 236.81,59.06 236.62,58.88 235.57,58.88 234.88,58.19 234.88,54.29 v2(234.68,54.09) 234.59,54 232.48,54 v1(231.68,53.2) 231.57,53.08 231.57,49.5 231.13,49.07 231.13,48.33 v1(230.69,47.89)
DOCK_SMB_DAT: length 149.6
  TOP w0.108: U38.A3 231.25,50.25 230.67,49.67 v1(230.67,48.53) 230.06,47.92 230.06,47.49 229.68,47.11 R359.1
  IN3 w0.089: v1(233.36,68.19) 233,68.19 232.62,67.81 231.42,67.81 231.24,67.63 226,67.63 225.76,67.39 216.85,67.39 213.52,64.07 208.21,64.07 206.8,62.66 200.73,62.66 200.41,62.35 197.07,62.35 196.81,62.09 195.2,62.09 190.85,66.44 190.85,67.6 190.32,68.13 190.32,69.58 189.46,70.44 189.46,76.47 186.43,79.49 186.43,90.54 182.55,94.43 180.61,94.43 179.61,95.43 177,95.43 176.38,94.8 166.02,94.8 160.52,100.3 159.95,100.3 v1(159.38,100.88)
  IN4 w0.089: v1(233.36,68.19) 234.19,69.02 239.38,69.02 241.45,66.94 241.45,62.84 240.73,62.12 240.73,61.38 v1(240.9,61.2)
  BOTTOM w0.108: JDOCK1.9 158.02,99.65 159.24,100.88 v1(159.38,100.88) ; v1(230.67,48.53) 230.82,48.68 230.82,49.19 231.26,49.63 231.26,53.53 231.44,53.72 231.76,53.72 232.36,54.31 234.22,54.31 234.57,54.67 234.57,55.7 v2(234.38,55.89) 234.57,56.09 234.57,58.32 235.45,59.19 236.5,59.19 236.68,59.38 238.08,59.38 238.7,60 238.7,61.31 239.32,61.92 240.18,61.92 v1(240.9,61.2)
DPB_AUX: length 140.6
  TOP w0.076: v1(93.86,123.91) 93.19,123.91 92.94,124.17 92.94,124.36 92.94,124.36 92.94,125.37 92.24,126.07 92.24,126.45 91.95,126.74 91.5,126.74 U6.B11
  TOP w0.102: v1(93.86,123.91) 93.99,123.79 94.19,123.79 R47.1
  IN3 w0.102: v1(93.86,123.91) 94.73,124.78 94.73,133.87 96.25,135.4 96.25,135.86 101.05,140.65 101.05,141.39 103.08,143.42 105.65,143.42 106.21,143.98 116.75,143.98 117.6,144.83 125.27,144.83 125.89,144.21 131.91,144.21 132.8,143.32 133.43,143.32 134.94,141.82 134.94,141.26 138.89,137.3 140.98,137.3 142.27,136.01 147.53,136.01 148.24,135.29 149.75,135.29 150.26,135.8 157.54,135.8 158.79,134.55 158.79,130.91 157.08,129.2 156.84,129.2 153.96,126.33 153.96,124.63 154.42,124.17 154.42,121.8 156.27,119.95 156.27,111.3 155.88,110.91 155.88,109.05 155.61,108.78 155.61,96.05 156.4,95.26 156.4,92.31 155.16,91.07 154.77,91.07 154.62,91.22 154.62,91.5 154.44,91.69 154.21,91.69 154.11,91.58 v1(154.11,91.43)
  BOTTOM w0.102: v1(154.11,91.43) 154.27,91.27 154.45,91.27 C9948.2
DPB_AUX#: length 140.6
  TOP w0.076: v1(93.86,124.52) 93.79,124.6 93.43,124.6 93.33,124.5 93.33,124.4 93.48,124.25 93.48,124.16 93.4,124.08 93.26,124.08 93.1,124.24 93.1,124.43 93.1,125.44 92.4,126.14 92.4,126.52 92.02,126.9 91.99,126.9 U6.A11
  TOP w0.102: v1(93.86,124.52) 94.09,124.52 R44.1
  IN3 w0.102: v1(93.86,124.52) 94.11,124.52 94.47,124.88 94.47,133.98 96,135.5 96,135.96 100.8,140.76 100.8,141.5 102.98,143.68 105.55,143.68 106.11,144.23 116.65,144.23 117.49,145.08 125.38,145.08 125.99,144.46 132.01,144.46 132.9,143.58 133.54,143.58 135.19,141.93 135.19,141.36 139,137.55 141.08,137.55 142.38,136.26 147.64,136.26 148.35,135.55 149.64,135.55 150.15,136.06 157.64,136.06 159.05,134.65 159.05,130.81 157.19,128.95 156.94,128.95 154.21,126.22 154.21,124.73 154.67,124.27 154.67,121.91 156.53,120.05 156.53,111.19 156.14,110.8 156.14,108.94 155.87,108.67 155.87,96.15 156.65,95.37 156.65,92.2 155.27,90.82 v1(154.12,90.82)
  BOTTOM w0.102: v1(154.12,90.82) 154.28,90.98 154.46,90.98 C9949.2
DPB_AUX#_C: length 1.7
  BOTTOM w0.102: C9949.1 156.24,91.15 JDOCK1.26
DPB_AUX_C: length 1.7
  BOTTOM w0.102: C9948.1 155.99,91.35 156.45,91.35 156.75,91.65 JDOCK1.25
DPB_CA_DET: length 6.4
  TOP w0.108: U6.A14 91.73,125.05 91.73,124.29 92.53,123.49 92.53,123.21 93.35,122.39 93.35,121.18 v5(93.86,120.67) 93.66,120.47 R9544.1
DPB_DOCK_HPD: length 118.2
  TOP w0.089: v8(92.34,131.03) 91.81,130.5 U6.A6
  IN1 w0.089: v8(92.34,131.03) 91.93,131.44 91.93,133.35 92.46,133.88 92.79,133.88 93.08,133.6 93.08,133.34 93.39,133.03 99.5,133.03 101.44,134.98 103.47,134.98 104.92,136.42 106.07,136.42 107.38,137.73 107.38,140.62 108.87,142.11 111.35,142.11 111.85,141.62 130.34,141.62 134.04,137.91 135.48,137.91 142.48,130.91 142.48,128.46 142.98,127.96 142.98,127.29 142.35,126.66 142.35,125.57 141.83,125.05 141.83,120.73 143.52,119.04 153.01,119.04 163.21,108.84 163.21,107.58 160.79,105.16 v1(160.79,101.88)
  BOTTOM w0.108: v1(160.79,101.88) 160.18,101.28 160.18,100.42 159.45,99.68 159.19,99.68 158.16,98.65 JDOCK1.11 155.94,98.65 C9459.1 155.59,98.27 v2(155.59,97.19)
DPB_LANE_N0: length 119.5
  TOP w0.076: v1(93.54,130.59) 93.16,130.21 93.03,130.21 92.68,129.86 91.99,129.86 U6.A7
  IN4 w0.102: v1(167.03,98.96) 167.25,98.74 167.35,98.74 168.03,99.43 168.73,99.43 169.48,100.17 169.48,107.81 154.61,122.68 154.61,123.69 149.56,128.74 143.77,128.74 142.52,129.99 137.07,129.99 136.13,130.93 129.22,130.93 124.16,135.98 121.98,135.98 120.99,136.97 112.25,136.97 111.74,137.48 108.1,137.48 106.95,136.34 100.96,136.34 98.16,133.54 96.16,133.54 93.46,130.84 93.46,130.68 v1(93.54,130.59)
  BOTTOM w0.102: v1(167.03,98.96) 167.45,98.55 167.45,97.24 167.19,96.98 166,96.98 164.38,95.37 163.92,95.37 ; JDOCK1.23 157.95,92.65 158.05,92.75 158.05,92.85 158.15,92.95 161.71,92.95 162.55,93.78 162.55,94.75 163.16,95.37 163.92,95.37 ; 163.92,95.37 v6(163.92,95.35)
DPB_LANE_N1: length 112.2
  TOP w0.076: U6.A8 91.99,128.85 92.73,128.85 92.88,129 v1(92.88,129.35)
  IN4 w0.102: v1(92.88,129.35) 93.11,129.58 93.11,129.79 93.34,130.01 93.7,130.01 96.47,132.78 98.66,132.78 100.79,134.91 107.83,134.91 108.49,135.57 113.1,135.57 114.65,134.02 125.25,134.02 128.96,130.32 135.17,130.32 136.16,129.32 142.23,129.32 143.83,127.72 146.76,127.72 147.78,126.71 150.05,126.71 152.31,124.45 152.31,123.89 167.78,108.42 167.78,100.48 v1(165.52,98.23)
  BOTTOM w0.102: v1(165.52,98.23) 165.24,98.51 164.94,98.51 162.07,95.64 160.57,95.64 159.38,94.45 158.15,94.45 157.85,94.15 JDOCK1.20
DPB_LANE_N2: length 108.7
  TOP w0.076: U6.A9 91.95,128.24 93.15,128.24 v1(93.39,128.49)
  IN4 w0.102: v1(165.52,100.1) 165.71,100.29 166.21,100.29 166.97,101.05 166.97,107 151.01,122.95 151.01,124.46 149.6,125.87 146.6,125.87 145.71,126.76 141.95,126.76 140.24,128.46 134.5,128.46 133.46,129.5 128.63,129.5 124.92,133.21 114.94,133.21 112.83,131.1 108.85,131.1 107.22,132.73 105.16,132.73 103.63,131.2 98.2,131.2 95.33,128.33 93.54,128.33 v1(93.39,128.49)
  BOTTOM w0.102: JDOCK1.17 157.75,95.65 158.05,95.95 158.96,95.95 160.77,97.75 162.56,97.75 163.49,98.68 v6(163.52,98.68) 163.52,98.72 165.1,100.29 165.33,100.29 v1(165.52,100.1)
DPB_LANE_N3: length 104
  TOP w0.076: v1(93.97,127.04) 93.8,126.87 93.5,126.87 93.25,127.12 92.57,127.12 92.1,127.58 91.96,127.58 U6.A10
  IN4 w0.102: v1(165.14,101.5) 166.13,102.48 166.13,103.24 164.96,104.4 164.96,107.32 151.04,121.25 147.43,121.25 142.81,125.87 135.32,125.87 133.24,127.95 129.03,127.95 124.86,132.12 115.14,132.12 113.31,130.29 108.29,130.29 106.67,131.92 105.57,131.92 104.04,130.39 100.36,130.39 96.85,126.88 94.12,126.88 v1(93.97,127.04)
  BOTTOM w0.102: JDOCK1.14 157.78,97.15 158.07,97.45 158.84,97.45 162.28,100.89 163.47,100.89 164.2,101.61 165.03,101.61 v1(165.14,101.5)
DPB_LANE_P0: length 119.6
  TOP w0.076: U6.B7 91.35,129.68 91.7,130.03 92.61,130.03 92.92,130.34 v1(92.92,130.59)
  IN4 w0.102: v1(167.03,98.35) 167.22,98.54 167.43,98.54 168.12,99.23 168.82,99.23 169.68,100.09 169.68,107.9 154.81,122.77 154.81,123.77 149.64,128.94 143.85,128.94 142.61,130.19 137.15,130.19 136.21,131.13 129.3,131.13 124.25,136.18 122.07,136.18 121.08,137.17 112.33,137.17 111.82,137.68 108.01,137.68 106.87,136.54 100.87,136.54 98.08,133.74 96.07,133.74 v1(92.92,130.59)
  BOTTOM w0.102: v6(166.47,97.2) 166.47,97.19 ; 166.47,97.19 165.92,97.19 164.3,95.57 163.08,95.57 162.34,94.83 162.34,93.87 161.63,93.15 JDOCK1.22 ; 166.47,97.19 167.1,97.19 167.24,97.33 167.24,98.14 v1(167.03,98.35)
DPB_LANE_P1: length 112.1
  TOP w0.076: v1(93.58,129.35) 93.18,128.94 93.06,128.94 92.8,128.69 91.72,128.69 91.38,129.03 U6.B8
  IN4 w0.102: v1(93.58,129.35) 93.32,129.61 93.32,129.71 93.42,129.81 93.79,129.81 96.56,132.58 98.74,132.58 100.87,134.71 107.91,134.71 108.57,135.37 113.02,135.37 114.56,133.82 125.17,133.82 128.88,130.11 135.09,130.11 136.08,129.12 142.14,129.12 143.74,127.52 146.68,127.52 147.69,126.51 149.96,126.51 152.11,124.36 152.11,123.81 167.57,108.34 167.57,100.57 165.85,98.84 v1(165.52,98.84)
  BOTTOM w0.102: v1(165.52,98.84) 165.4,98.72 164.86,98.72 161.99,95.85 160.49,95.85 159.29,94.65 JDOCK1.19
DPB_LANE_P2: length 108.6
  TOP w0.076: U6.B9 91.38,128.38 91.68,128.08 93.19,128.08 v1(93.39,127.88)
  IN4 w0.102: v1(93.39,127.88) 93.65,128.13 95.41,128.13 98.28,131 103.72,131 105.24,132.53 107.14,132.53 108.77,130.9 112.91,130.9 115.02,133.01 124.83,133.01 128.54,129.3 133.38,129.3 134.42,128.26 140.16,128.26 141.86,126.56 145.63,126.56 146.52,125.67 149.52,125.67 150.81,124.37 150.81,122.87 166.76,106.91 166.76,101.13 166.12,100.49 165.75,100.49 v1(165.53,100.71)
  BOTTOM w0.102: JDOCK1.16 158.88,96.15 160.68,97.96 162.47,97.96 164.58,100.06 v6(164.58,100.09) 164.61,100.09 165.01,100.5 165.31,100.5 v1(165.53,100.71)
DPB_LANE_P3: length 104
  TOP w0.076: v1(93.97,126.42) 93.69,126.7 93.43,126.7 93.19,126.95 92.51,126.95 92.04,127.42 91.68,127.42 91.37,127.73 U6.B10
  IN4 w0.102: v1(165.14,102.14) 165.5,102.14 165.92,102.57 165.92,103.15 164.76,104.32 164.76,107.24 150.95,121.04 147.35,121.04 142.73,125.67 135.24,125.67 133.16,127.75 128.94,127.75 124.78,131.92 115.23,131.92 113.4,130.09 108.21,130.09 106.58,131.71 105.65,131.71 104.13,130.19 100.44,130.19 96.93,126.68 94.22,126.68 v1(93.97,126.42)
  BOTTOM w0.102: JDOCK1.13 158.75,97.65 162.19,101.09 163.39,101.09 164.11,101.82 164.82,101.82 v1(165.14,102.14)
DPC_CA_DET: length 4.4
  TOP w0.108: U6.M14 83.29,123.76 T6302.1
DPC_DOCK_HPD: length 5.6
  TOP w0.089: 83.63,125.45 85.64,125.45 U6.K14
  TOP w0.108: R268.1 81.9,124.68 v2(82.33,124.68) 83.11,125.45 83.63,125.45
DPC_LANE_N0: length 7.8
  TOP w0.089: 89.57,124.19 89.57,124.47 89.46,124.58
  TOP w0.102: T6295.1 87.48,119.59 87.75,119.59 89.46,121.3 89.46,122.81 89.57,122.92 89.57,124.19 ; U6.E14 89.21,124.83 89.46,124.58
DPC_LANE_N1: length 2.4
  TOP w0.089: U6.F14 88.56,124.83 88.39,124.65 88.39,124.19
  TOP w0.102: T6297.1 88.39,123.34 88.39,124.19
DPC_LANE_N2: length 6.6
  TOP w0.089: 87.92,124.19 87.92,124.83 87.91,124.83 U6.G14
  TOP w0.102: 87.92,124.19 87.92,124.19 87.7,123.97 87.7,123.68 87.11,123.09 87.11,122.32 86.85,122.07 86.85,120.23 86.61,119.99 86.18,119.99 T6299.1
DPC_LANE_N3: length 6.6
  TOP w0.089: U6.H14 87.26,124.37 87.08,124.19
  TOP w0.102: T6301.1 83.78,121.25 83.96,121.07 84.62,121.07 85.1,121.55 85.1,122.02 87.08,124 87.08,124.19
DPC_LANE_P0: length 8.1
  TOP w0.089: 89.53,124.87 89.77,124.63 89.77,124.19
  TOP w0.102: 89.77,124.19 89.77,122.75 89.66,122.63 89.66,121.18 88.4,119.92 T6294.1 ; 89.53,124.87 89.53,125.46 89.21,125.78 U6.E13
DPC_LANE_P1: length 4.7
  TOP w0.089: U6.F13 88.87,125.47 88.87,124.54 89.22,124.19
  TOP w0.102: T6296.1 88.94,123.28 89.22,123.56 89.22,124.19
DPC_LANE_P2: length 6.5
  TOP w0.089: 88.12,124.19 88.14,124.21 88.14,124.88 88.23,124.97 88.23,125.47 U6.G13
  TOP w0.102: T6298.1 87.21,120.33 87.06,120.49 87.06,121.98 87.31,122.24 87.31,123.01 87.9,123.6 87.9,123.89 88.12,124.1 88.12,124.19
DPC_LANE_P3: length 7.9
  TOP w0.089: 87.56,124.19 87.57,124.2 87.57,125.47 U6.H13
  TOP w0.102: T6300.1 83.78,120.71 83.93,120.87 84.7,120.87 85.3,121.47 85.3,121.93 87.56,124.19
DSR1#: length 154.2
  TOP w0.108: v1(264.42,23.46) 265.24,24.28 RP4806.4 ; v1(262.06,27.42) 262.22,27.58 U6202.37
  IN1 w0.089: v1(262.06,27.42) 261.43,28.06 258.16,28.06 257.64,28.57 257.64,31.67 254.76,34.55 249.83,34.55 247.98,36.41 232.89,36.41 232.21,37.09 230.15,37.09 228.52,38.71 228.52,41.59 227.06,43.05 223.62,43.05 223.09,43.58 206.69,43.58 205.98,44.29 190.31,44.29 189.34,43.32 184.34,43.32 178.22,49.44 178.22,51.88 177.17,52.93 177.17,94.16 178.37,95.37 178.67,95.37 v1(179.16,95.85)
  BOTTOM w0.108: v1(179.16,95.85) 178.53,95.23 JIOR1.25 ; v1(262.06,27.42) v2(263.23,26.25) 263.84,25.64 263.84,24.04 v1(264.42,23.46)
DSR2: length 5.3
  TOP w0.108: U6202.47 267.22,27.91 267.01,27.7 266.16,27.7 265.9,27.45 v1(265.9,27.29) 265.97,27.22 RP4806.6
  BOTTOM w0.108: v1(265.9,27.29) 266.48,26.71 266.48,25.19 v2(266.48,25.19)
DSR3: length 228.9
  TOP w0.108: U6202.22 v1(258.91,33.88) ; RP4804.7 255.33,37.99 255.45,37.86 256.09,37.86 256.54,37.41 256.56,37.41 257.19,36.78 257.19,36.04 v1(257.68,35.56) ; U6203.17 123.55,138.77 124.24,139.46 124.24,139.79 124.38,139.92 124.38,140.33 124.5,140.45 v1(124.5,140.75)
  IN3 w0.089: v1(250.52,36.25) 251.06,35.71 255.2,35.71 255.35,35.56 v1(257.68,35.56)
  IN4 w0.089: v1(124.5,140.75) 125.85,142.11 133.4,142.11 134.05,141.46 134.05,141.18 140.13,135.09 142.78,135.09 143.51,135.82 147.37,135.82 148.02,135.17 150.27,135.17 153.55,131.89 153.55,130.6 160.39,123.77 160.39,123.18 162.79,120.78 163.44,120.78 171.47,112.76 172.91,112.76 176.47,109.2 176.93,109.2 178.77,107.35 178.77,105.98 180.1,104.65 182.63,104.65 184.74,102.54 184.74,80.72 183.35,79.34 183.35,75.69 179.06,71.39 179.06,67.13 186.81,59.38 186.81,58.49 189.6,55.7 204.18,55.7 204.69,56.2 208.02,56.2 208.64,56.83 217.57,56.83 220.18,54.22 223.58,54.22 224.52,53.28 230.95,53.28 231.64,53.98 236.09,53.98 236.97,53.09 238.98,53.09 239.84,52.23 243.71,52.23 245.32,50.62 245.32,49.57 245.08,49.32 245.08,44.53 245.4,44.21 245.4,43.41 248.97,39.84 250.08,39.84 250.32,39.61 250.32,38.16 249.85,37.7 249.85,36.92 v1(250.52,36.25) ; v1(257.68,35.56) 258.13,35.11 258.13,34.66 v1(258.91,33.88)
  BOTTOM w0.108: v2(258.91,34.55) v1(258.91,33.88)
DSR3_T: length 10.7
  TOP w0.108: U6203.6 127.45,145.48 124.56,148.38 124.56,148.99 v1(124.97,149.4)
  IN2 w0.089: v1(124.97,149.4) 124.32,150.05 123.94,150.05 123.36,150.63 JSER1.6
  BOTTOM w0.108: v2(125.26,147.77) 124.47,148.55 124.47,148.93 124.94,149.4 v1(124.97,149.4)
DTR1#: length 155.1
  TOP w0.108: v2(260.74,24.4) 261.02,24.12 v1(261.35,24.12) 261.53,24.3 R9427.1 262.75,24.98 262.75,27.5 263.05,27.8 263.59,27.8 263.72,27.93 U6202.40
  IN1 w0.089: v1(261.35,24.12) 261.75,24.12 262.39,24.75 262.39,25.48 261.46,26.4 260.67,26.4 259.27,27.8 258.11,27.8 256.4,29.51 256.4,30.74 253.6,33.54 249.97,33.54 247.33,36.18 232.81,36.18 232.12,36.87 230.06,36.87 228.31,38.62 228.31,41.5 226.97,42.84 223.53,42.84 223,43.36 206.6,43.36 205.89,44.07 190.4,44.07 189.43,43.11 184.25,43.11 178.01,49.35 178.01,51.79 176.95,52.84 176.95,76.21 176.19,76.97 176.19,83.46 176.64,83.91 176.64,93.96 v1(178.53,95.86)
  BOTTOM w0.108: v1(178.53,95.86) 178.4,95.73 JIOR1.24
DTR2: length 2.7
  TOP w0.108: v2(270,30.43) R9394.1 269.3,29.45 269.23,29.38 U6202.50
DTR3: length 231.7
  TOP w0.108: R9430.1 258.38,32.5 258.5,32.38 U6202.25 v1(260.28,32.38) ; v1(123.08,145.63) 122.9,145.45 U6203.13
  IN3 w0.089: v1(260.28,32.38) 258.22,32.38 257.7,32.9 253.38,32.9 252.89,33.39 251.06,33.39 v1(250.51,33.95)
  IN4 w0.089: v1(250.51,33.95) 251.13,34.58 251.13,36.67 250.89,36.91 250.89,39.64 250.26,40.27 249.15,40.27 245.85,43.57 245.85,44.55 245.51,44.9 245.51,48.66 246.49,49.65 246.49,50.43 244.26,52.66 240.05,52.66 238.35,54.36 238.35,54.49 238.07,54.77 237.13,54.77 236.83,54.46 231.52,54.46 230.77,53.72 224.69,53.72 223.76,54.65 220.36,54.65 217.75,57.26 208.46,57.26 207.84,56.64 204.49,56.64 203.98,56.13 189.78,56.13 187.24,58.67 187.24,59.56 179.49,67.31 179.49,71.21 183.79,75.51 183.79,79.16 185.17,80.54 185.17,102.95 179.98,108.14 178.94,108.14 177.43,109.65 176.63,109.65 173.35,112.94 173.35,113.73 170.03,117.04 167.79,117.04 163.62,121.21 162.97,121.21 160.82,123.36 160.82,123.94 154.14,130.63 154.14,132.04 150.58,135.61 148.37,135.61 147.72,136.25 139.58,136.25 134.48,141.36 134.48,141.64 133.38,142.74 132.88,142.74 131.74,143.88 124.83,143.88 v1(123.08,145.63)
  BOTTOM w0.108: v1(260.28,32.38) 261.44,32.38 v2(261.63,32.18)
DTR3_T: length 13.1
  TOP w0.108: U6203.10 124.85,145.45 123.7,146.61 v2(117.91,146.61) 116.88,147.64 116.88,149.13 116.42,149.59 JSER1.4
EC5048_TX: length 49.9
  TOP w0.108: v1(257.28,50.21) 256.78,49.71 U37.B2 ; R406.2 v1(225.36,68.57)
  IN1 w0.089: v1(225.36,68.57) 225.96,69.17 239.64,69.17 240.35,68.45 242.75,68.45 246.22,64.99 249.92,64.99 250.79,64.12 254.26,64.12 254.42,63.97 v1(254.42,63.39)
  BOTTOM w0.108: v1(257.28,50.21) 258.08,51.01 258.08,56.92 257.58,57.42 257.58,58.87 256.8,59.65 256.8,60.23 256.57,60.46 256.57,60.47 256.55,60.49 256.55,61.91 v2(255.2,63.26) 255.08,63.39 v1(254.42,63.39)
EC_32KHZ_ECE5048: length 52.5
  TOP w0.108: R379.1 229.36,48.52 v1(229.66,48.52) ; U37.B35 v1(264.28,57.65)
  IN4 w0.089: v1(264.28,57.65) 263.84,58.09 263.84,60.74 262.34,62.24 254.88,62.24 252.68,60.05 251.9,60.05 251.38,60.57 248.27,60.57 246.45,62.39 v1(241.62,62.39)
  BOTTOM w0.108: v1(229.66,48.52) 229.66,49.44 229.8,49.59 229.8,52.99 230.39,53.58 230.61,53.58 231.71,54.68 231.71,55.38 233.36,57.03 233.36,58.37 234.67,59.68 235.7,59.68 236.03,60.01 236.03,60.83 236.4,61.2 237.9,61.2 239.56,62.86 239.96,62.86 240.43,62.39 v1(241.62,62.39) ; v1(264.28,57.65) v2(264.28,58.4)
EC_32KHZ_ECE5048_R: length 8.2
  TOP w0.108: U38.B2 230.5,52.54 v1(230.21,52.82) ; R379.2 228.56,47.66 229.42,47.66 v1(229.63,47.88)
  BOTTOM w0.108: v1(229.63,47.88) 230.19,48.43 230.19,49.16 230.29,49.26 230.29,51.3 v2(230.36,51.37) 230.52,51.52 230.52,52.52 v1(230.21,52.82)
EC_+3.3V_ALW2_R: length 5.1
  TOP w0.254: U38.A59 227.6,55.38 v2(227.35,55.63) 227.21,55.49 R370.1 225.92,56 224.65,56 R367.1
EC_FPM_EN: length 92.2
  TOP w0.108: v1(230.57,55.13) 230.57,55.49 230.42,55.63 U38.B62
  IN2 w0.089: v1(231.76,40.02) 228.46,40.02 227.65,39.21 226.83,39.21 226.53,39.51 223.06,39.51 222.15,38.6 205.76,38.6 204.42,39.94 190.37,39.94 190.06,40.25 175.82,40.25 172.77,43.29 168.27,43.29 v1(167.42,44.13)
  BOTTOM w0.108: v1(231.76,40.02) v2(231.14,40.64) 228.94,42.84 228.94,46.91 228.55,47.3 228.55,49.34 229.1,49.9 229.1,53.28 229.31,53.49 229.31,55.06 229.79,55.54 230.16,55.54 v1(230.57,55.13) ; v1(167.42,44.13) 168.03,43.52 168.03,42.48 166.69,41.14 JSEC1.5
ECPC_BD_ID0#: length 153.9
  TOP w0.108: v1(263.71,50.79) 263.46,50.53 263.46,49.41 263.28,49.24 U37.B15 ; v1(263.28,46.81) 262.95,46.48 R419.1
  IN1 w0.089: v1(242.5,26.28) 241.98,25.76 229.23,25.76 228.77,25.29 219.64,25.29 213.55,31.38 189.47,31.38 184.25,36.6 179.55,36.6 176.49,39.66 176.49,44.92 173.11,48.3 173.11,54.29 v1(173.04,54.37)
  IN3 w0.089: v1(242.5,26.28) 247.33,26.28 247.98,26.93 255.62,26.93 256.21,26.33 263.79,26.33 264.7,27.25 264.7,27.85 265.34,28.49 267.72,28.49 268.18,28.94 268.18,42.26 266.87,43.57 266.87,45.56 267.1,45.79 267.1,48.86 266.69,49.26 265.24,49.26 v1(263.71,50.79)
  BOTTOM w0.108: v2(262.82,50.86) 263.14,51.18 263.32,51.18 v1(263.71,50.79) 263.46,50.53 263.46,49.39 263.28,49.22 v1(263.28,46.81) ; JEPC1.1 173.63,56.78 CE22.1 172.11,54.45 172.96,54.45 v1(173.04,54.37)
ECPC_BD_ID1#: length 104.1
  TOP w0.108: R9461.1 267.85,56.63 v1(267.98,56.5) ; v1(264.38,56.99) 264.47,57.08 U37.B33
  IN3 w0.089: v1(264.38,56.99) 265,56.99 265.92,56.07 267.55,56.07 v1(267.98,56.5) 269.32,57.84 269.32,61.09 268.77,61.63 251.78,61.63 250.61,60.47 245.01,60.47 243.85,61.63 243.85,63.52 240.55,66.82 233.41,66.82 233.15,66.56 231.94,66.56 231.2,65.81 231.2,65.08 230.84,64.72 224.05,64.72 223.25,63.92 216.66,63.92 216.01,63.27 215.31,63.27 212.7,60.66 206.28,60.66 205.52,59.9 204.15,59.9 204.14,59.89 204.09,59.89 203.16,58.96 201.54,58.96 195.55,58.96 194.43,60.08 191.58,60.08 v1(190.63,61.03)
  BOTTOM w0.108: v1(190.63,61.03) 190.89,60.77 191.68,60.77 191.86,60.59 191.86,58.2 192.13,57.93 JEPC1.38 ; v1(267.98,56.5) v2(268.72,55.77)
ECPC_PWR_EN: length 101.7
  TOP w0.108: U37.A31 266.07,56.83 267.72,58.48 267.72,59.72 v1(268.92,60.92)
  IN2 w0.089: v1(268.92,60.92) 268.42,60.42 265.76,60.42 264.01,62.17 258.63,62.17 256.8,64 251.88,64 251.8,63.92 251.8,62.62 251.65,62.47 248.4,62.47 247.2,63.67 245.78,63.67 242.71,66.73 224.88,66.73 223.14,65 220.61,65 219.23,63.63 217.13,63.63 216.8,63.3 215.15,63.3 214.62,62.78 208.54,62.78 206.75,60.99 204.39,60.99 202.53,59.12 196.3,59.12 194.4,61.02 192.41,61.02 190.91,62.52 190,62.52 189.67,62.19 v1(189.67,61.94)
  BOTTOM w0.108: v2(268.92,61.61) v1(268.92,60.92) ; JEPC1.28 187.13,60.59 188.48,61.94 v1(189.67,61.94)
EDP_BIA_PWM: length 227.9
  TOP w0.108: v1(163.21,73.6) 165.21,71.59 165.21,66.97 164.63,66.38 v1(164.63,66.18)
  IN1 w0.089: v1(161.5,82.38) 161.86,82.38 163.21,81.04 v1(163.21,73.6) ; v1(43.85,111.14) 44.86,111.14 47.65,108.34 47.65,99.87 47.26,99.48 47.26,94.89 47.96,94.2 47.96,93.45 v1(47.1,92.6) ; v1(160.46,58.33) 161.99,59.86 161.99,63.54 v1(164.63,66.18)
  IN2 w0.089: v1(47.1,92.6) 48.33,93.83 49.49,93.83 50.17,94.51 52.7,94.51 54.19,96 57.84,96 58.13,96.29 63.82,96.29 68.59,91.52 68.59,91.21 69.68,90.12 70.16,90.12 73.42,86.85 74.08,86.85 75.5,85.44 75.5,81.78 78.76,78.52 88.56,78.52 106.8,60.29 118.51,60.29 119.7,61.48 132.14,61.48 135.92,57.7 145.32,57.7 145.45,57.57 146.97,57.57 147.7,56.84 150.41,56.84 150.99,57.42 159.55,57.42 v1(160.46,58.33)
  IN4 w0.076: v3(131.61,94.28) 131.99,94.65 136.17,94.65 136.21,94.69 136.65,94.69
  IN4 w0.102: 136.65,94.69 137.18,94.16 141.32,94.16 141.42,94.07 147.76,94.07 148.66,94.96 150.6,94.96 151.06,94.49 151.06,93.57 152.72,91.92 152.72,91.01 153.31,90.41 154.69,90.41 157.54,87.56 157.54,86.08 v1(158.05,85.57)
  BOTTOM w0.076: UC1.R11 131.86,94.53 131.61,94.27 v3(131.61,94.28)
  BOTTOM w0.108: v1(158.05,85.57) 161.05,82.57 161.32,82.57 v1(161.5,82.38) ; v2(160.74,59.27) 160.46,58.99 v1(160.46,58.33) ; v1(43.85,111.14) 43.85,113.07 43.28,113.64 Q4213.2
EDP_BIA_PWM_Q: length 3.4
  BOTTOM w0.108: Q4213.3 44.54,113.33 45.02,113.8 D7123.1
EDP_COMP: length 14.2
  TOP w0.127: RC134.2 100.52,109.06 100.52,107.71 103.19,105.04 104.13,105.04 106.84,102.32 v5(106.84,101.46) 106.84,100.97 v3(108.16,99.64)
  BOTTOM w0.305: UC1.E52 108.32,99.64 v3(108.16,99.64)
EDP_CPU_AUX: length 81.6
  IN3 w0.102: v3(111.87,99.62) 111.47,100.02 111.47,100.7 111.09,101.08 108.96,101.08 108.35,101.69 100.46,101.69 99.43,102.72 98.5,102.72 97.87,102.1 93.79,102.1 93.33,101.64 93.33,100.7 92.34,99.71 89.01,99.71 88.61,99.3 83.35,99.3 81.75,97.7 76.57,97.7 75.89,98.37 64.69,98.37 63.51,99.56 61.35,99.56 59.65,101.26 55.06,101.26 53.63,99.83 53.63,98.13 53.05,97.55 52.26,97.55 49.04,94.32 45.35,94.32 43.64,96.03 43.13,96.03 43.01,95.91 43.01,95.73 v1(43.24,95.49)
  BOTTOM w0.102: C55.1 43.11,96.06 43.11,95.62 v1(43.24,95.49) ; v3(111.87,99.62) 112.2,99.62 112.32,99.49 UC1.F45
EDP_CPU_AUX#: length 81.6
  IN3 w0.102: v1(42.61,95.49) 42.75,95.64 42.75,96.01 43.03,96.29 43.74,96.29 45.45,94.58 48.93,94.58 52.16,97.8 52.94,97.8 53.38,98.24 53.38,99.94 54.95,101.51 59.75,101.51 61.45,99.81 63.61,99.81 64.79,98.63 76,98.63 76.67,97.96 81.65,97.96 83.25,99.56 88.5,99.56 88.91,99.96 92.23,99.96 93.08,100.8 93.08,101.74 93.69,102.35 97.77,102.35 98.39,102.97 99.54,102.97 100.57,101.94 108.45,101.94 109.06,101.33 111.19,101.33 111.69,100.83 111.69,100.4 v3(111.87,100.23)
  BOTTOM w0.102: UC1.E45 112.11,99.99 v3(111.87,100.23) ; v1(42.61,95.49) 42.82,95.71 42.82,96.1 C54.1
EDP_CPU_AUX#_C: length 6.7
  BOTTOM w0.102: 45.73,99.84 45.32,99.43 45.02,99.43 44.51,98.92 43.5,98.92 42.9,98.32 42.9,97.75 C54.2 ; 45.73,99.84 46.16,100.27 46.16,100.88 46.03,101.01 JEDP1.24 ; 45.73,99.84 v6(45.73,99.87)
EDP_CPU_AUX_C: length 6.7
  BOTTOM w0.102: 44.18,98.72 44.6,98.72 45.1,99.23 45.41,99.23 46.37,100.18 46.37,100.8 46.53,100.96 JEDP1.23 ; 44.18,98.72 43.58,98.72 43.1,98.24 43.1,97.73 C55.2 ; 44.18,98.72 v6(44.18,98.71)
EDP_CPU_LANE_N0: length 80.8
  IN3 w0.102: v1(111.31,104.11) 110.91,104.11 110.83,104.18 110.83,104.5 110.69,104.64 101.92,104.64 101.66,104.38 99.1,104.38 98.18,103.47 93.69,103.47 92.68,102.45 91.06,102.45 90.15,103.37 88.05,103.37 85.1,100.42 83.33,100.42 81.35,98.44 77.2,98.44 72.8,102.83 65.85,102.83 65.11,103.57 56.07,103.57 51.19,98.69 51.19,98.18 49.64,96.64 49.13,96.64 48.01,95.51 46.63,95.51 45.91,96.23 45.53,96.23 45.43,96.13 45.43,95.83 v1(45.64,95.62)
  BOTTOM w0.102: v1(111.31,104.11) 111.62,104.11 111.72,104 111.72,103.2 111.25,102.73 111.25,101.98 111.14,101.87 111.14,101.65 UC1.C47 ; C56.1 45.31,96.1 45.31,95.95 v1(45.64,95.62)
EDP_CPU_LANE_N0_C: length 6
  BOTTOM w0.102: JEDP1.20 48.03,101.12 47.86,100.95 47.86,100.31 47.47,99.91 47.06,99.91 45.69,98.54 45.43,98.54 45.27,98.38 45.27,97.71 C56.2
EDP_CPU_LANE_N1: length 80.3
  IN3 w0.102: v1(48.3,96.79) 48.07,97.02 48.07,99.32 50.95,102.2 52.24,102.2 54.35,104.31 65.65,104.31 66.38,103.57 73.18,103.57 77.55,99.2 81.06,99.2 83.09,101.23 84.85,101.23 87.77,104.15 88.23,104.15 89.62,105.55 90.97,105.55 91.27,105.25 94.58,105.25 95.51,104.31 97.83,104.31 98.74,105.22 111.64,105.22 112,104.86 v3(112,104.69)
  BOTTOM w0.076: 112.13,103.34 112.13,103.33 112.15,103.31 112.15,103.27 112.16,103.25 112.16,103.07 112.29,102.95 112.29,102.61 112.25,102.52 112.25,102.27 112.29,102.15 112.29,101.96 112.25,101.86 112.15,101.75 112.14,101.75 112,101.75 arc(111.9,101.73) 111.82,101.68 111.76,101.62 UC1.D46
  BOTTOM w0.102: C57.1 47.73,97.43 47.73,97.29 47.87,97.16 48.1,97.16 48.3,96.96 v1(48.3,96.79) ; 112.13,103.34 112.13,103.7 112.36,103.92 112.36,104.33 v3(112,104.69)
EDP_CPU_LANE_N1_C: length 4.6
  BOTTOM w0.102: C57.2 47.65,98.97 47.65,99.11 47.85,99.31 48.9,99.31 49.39,99.8 49.39,100.95 49.53,101.1 JEDP1.17
EDP_CPU_LANE_P0: length 80.9
  IN3 w0.102: v1(111.31,104.74) 110.95,104.74 110.8,104.89 101.81,104.89 101.56,104.64 98.99,104.64 98.08,103.72 93.59,103.72 92.57,102.71 91.17,102.71 90.26,103.62 87.94,103.62 85,100.67 83.22,100.67 81.24,98.69 77.3,98.69 72.91,103.09 65.95,103.09 65.22,103.82 55.97,103.82 50.94,98.79 50.94,98.29 49.54,96.89 49.03,96.89 47.9,95.76 46.73,95.76 46.01,96.48 45.42,96.48 45.17,96.23 45.17,95.8 v1(44.99,95.62)
  BOTTOM w0.102: v1(44.99,95.62) 45.1,95.72 45.1,95.99 C59.1 ; v1(111.31,104.74) 111.31,104.7 111.92,104.09 111.92,103.11 111.46,102.64 UC1.C46
EDP_CPU_LANE_P0_C: length 6
  BOTTOM w0.102: C59.2 45.07,97.77 45.07,98.46 45.35,98.74 45.61,98.74 46.98,100.12 47.15,100.12 47.15,100.11 47.38,100.11 47.66,100.39 47.66,100.98 47.53,101.11 JEDP1.21
EDP_CPU_LANE_P1: length 80.3
  IN3 w0.102: v3(112.56,104.66) 111.75,105.47 98.64,105.47 97.72,104.56 95.62,104.56 94.68,105.5 91.38,105.5 91.07,105.8 89.52,105.8 88.12,104.41 87.66,104.41 84.74,101.49 82.99,101.49 80.96,99.45 77.66,99.45 73.29,103.82 66.49,103.82 65.75,104.56 54.24,104.56 52.13,102.45 50.84,102.45 47.81,99.42 47.81,96.94 v1(47.66,96.79)
  BOTTOM w0.076: 112.33,103.34 112.33,103.14 112.45,103.02 112.45,102.58 112.42,102.49 112.42,102.3 112.45,102.18 112.45,101.93 112.39,101.77 112.21,101.59 UC1.C45
  BOTTOM w0.102: 112.33,103.34 112.33,103.61 112.56,103.84 v3(112.56,104.66) ; C60.1 47.66,97.05 v1(47.66,96.79)
EDP_CPU_LANE_P1_C: length 4.7
  BOTTOM w0.102: 48.35,99.52 47.77,99.52 47.43,99.18 47.43,99.04 C60.2 ; 48.35,99.52 48.82,99.52 49.19,99.89 49.19,100.95 49.03,101.11 JEDP1.18 ; 48.35,99.52 v6(48.35,99.54)
EDP_HPD: length 196
  TOP w0.108: v3(132.86,96.26) 132.95,96.17 RC158.1
  IN2 w0.089: v1(50.74,100.57) 50.34,100.17 50.34,99.19 51.88,97.65 64.94,97.65 70.69,91.91 70.69,90.88 73.96,87.6 81.12,87.6 83.45,85.28 83.45,84.7 106.55,61.6 118.7,61.6 119.32,62.22 132.53,62.22 136.14,58.62 142.3,58.62 142.8,59.12 146.82,59.12 147.15,59.46 147.65,59.46 147.82,59.29 148.3,59.29 148.99,59.98 148.99,60.42 149.4,60.84 151.27,60.84 152.43,59.68 157.34,59.68 159.42,61.76 v1(160.36,61.76)
  IN4 w0.076: 136,96.2 135.59,96.61 133.21,96.61 v3(132.86,96.26)
  IN4 w0.089: v1(160.36,61.76) 160.36,64.89 158.73,66.52 158.73,74.76 159.49,75.52 159.49,77.52 160.34,78.37 160.34,79.84 159.82,80.36 159.82,81.01 159.12,81.7 159.12,84.46 158.64,84.94 158.64,87.63 157.94,88.33 157.94,88.44 154.36,92.02 153.45,92.02 151.8,93.67 151.8,94.79 150.72,95.87 148.58,95.87 146.85,97.6 142,97.6 141.33,96.93 137.6,96.93 136.87,96.2 136,96.2
  BOTTOM w0.108: JEDP1.14 51.03,100.87 v1(50.74,100.57) ; v1(160.36,61.76) 160.84,61.76 v2(161.53,61.08) ; UC1.L10 132.51,96.61 v3(132.86,96.26)
EMMC_RCOMP: length 8.3
  TOP w0.203: v3(139.81,85.33) 139.81,85.76 v2(139.61,85.97) 139.48,86.09 138.92,86.09 138.34,86.68 138.34,89.12 138.62,89.4 RC21.1
  BOTTOM w0.203: v3(139.81,85.33) 139.05,84.57 138.36,84.57 137.98,84.19 137.76,84.19 UC1.AT1
EN_1.0V_PRIM_COREP: length 5.1
  BOTTOM w0.254: PU5602.13 173.46,103.23 173.65,103.42 PC5620.1 PR5623.1 PR5621.2 174.31,105.86 v2(174.13,105.86)
EN_1VS_VCCIO: length 7
  BOTTOM w0.108: v2(166.16,75.87) 166.16,75.57 166.63,75.1 167.93,75.1 168.26,74.77
  BOTTOM w0.254: PR5610.2 PR5612.1 PC5610.1 168.77,76.95 169.61,76.95 170,77.34 PU5601.13
EN_+1VALWP: length 5.6
  TOP w0.108: PU5501.1 133.38,124.34 133.13,124.09 133.13,123.74 132.93,123.53 132.93,122.82 PC5514.1 132.45,122.34 v2(131.53,122.34) 131.25,122.06 130.9,122.06 PR5509.1 PR5507.2
EN_I2S_NB_CODEC#: length 293.3
  TOP w0.108: v1(50.38,114.42) 50.15,114.42 50.15,114.41 48.37,114.41 46.74,116.05 46.74,117.5 v2(47.08,117.84) 47.08,118.71 45.31,120.47 U17.1 ; U37.B36 263.78,58.1 263.33,57.65 v1(263.21,57.65)
  IN1 w0.089: v1(220.69,68.09) 222.17,69.57 239.8,69.57 240.52,68.85 242.92,68.85 246.35,65.42 250.05,65.42 250.95,64.52 260.91,64.52 v1(261.68,63.74)
  IN2 w0.089: v1(50.38,114.42) 50.8,113.99 53.69,113.99 54.14,114.43 56.34,114.43 59.11,111.67 62.77,111.67 63.41,111.03 64.38,111.03 69.94,105.47 69.94,95.66 72.45,93.14 72.45,91.61 74.6,89.46 81.76,89.46 85.3,85.92 85.3,85.34 107.28,63.37 117.68,63.37 118.3,63.99 133.31,63.99 135.11,62.19 143.78,62.19 144.51,61.46 145.76,61.46 145.94,61.64 146.21,61.64 147.34,62.77 150.32,62.77 152.26,64.71 153.25,64.71 154.61,63.35 158.72,63.35 159.01,63.63 164.82,63.63 165.05,63.4 165.05,63.16 167.19,61.02 167.19,60.64 169.4,58.43 171.13,58.43 175.66,53.9 176.05,53.9 182.95,47 190.47,47 190.91,47.44 194.12,47.44 196.14,49.46 202.84,49.46 206.33,45.97 208.6,45.97 208.75,46.12 216.24,46.12 v1(216.75,46.62)
  BOTTOM w0.108: v1(220.69,68.09) 219.45,66.85 219.45,64.31 217.8,62.66 217.8,62.37 216.72,61.3 216.72,47.59 216.75,47.57 v1(216.75,46.62) ; v1(263.21,57.65) 262.49,58.36 262.49,61.81 261.68,62.62 v1(261.68,63.74)
EN_INVPWR: length 261.2
  TOP w0.108: v1(58.46,121.63) 57.84,121.63 56.95,120.74 Q4211.2 ; U38.A25 239.76,56.88 239.9,57.02 240.98,57.02 241.12,56.88 R371.2 242.2,57.52 244.08,57.52 244.29,57.72 246.29,57.72 246.9,57.12 246.9,56.42 247.35,55.97 247.35,51.28 248.28,50.35 248.28,49.42 v1(247.87,49.01)
  IN2 w0.089: v1(247.87,49.01) 247.49,48.64 241.86,48.64 241.39,49.11 232.3,49.11 232.22,49.03 229.44,49.03 228,47.59 206.84,47.59 203.62,50.81 196.71,50.81 193.88,47.98 190.69,47.98 190.25,47.53 183.69,47.53 176.62,54.6 176.62,57.91 175.09,59.44 171.78,59.44 170.53,60.69 169.86,60.69 168.8,61.75 168.8,62.98 166.89,64.89 158.18,64.89 156.33,66.73 148.82,66.73 146.64,64.56 145.02,64.56 143.19,62.73 135.33,62.73 133.53,64.52 118.08,64.52 117.46,63.9 107.5,63.9 85.91,85.48 85.91,86.1 82.02,89.99 74.82,89.99 73.06,91.75 73.06,95.9 70.6,98.36 70.6,105.88 70.88,106.16 70.88,107.05 67.57,110.35 67.57,110.53 64.68,113.42 63.7,113.42 63.23,113.9 63.23,115.05 62.32,115.96 62.32,116.78 58.56,120.54 58.56,121.53 v1(58.46,121.63)
  BOTTOM w0.108: v2(58.86,122.67) 58.46,122.26 v1(58.46,121.63)
EN_INVPWR_Q: length 258.2
  TOP w0.108: Q4.1 44.96,101.55 44.78,101.36 v1(44.78,100.25) ; 59.68,121.02 60.11,121.45 v2(60.87,121.45) ; 59.68,121.02 Q4211.3 ; 59.68,121.02 60.23,121.02 R9692.2 60.74,120.13 61.04,119.84 v1(61.76,119.84)
  IN2 w0.089: v1(144.56,56.36) 144.19,56.73 135.5,56.73 132.91,59.32 106.4,59.32 88.34,77.38 78.53,77.38 74.53,81.38 74.53,84.13 72.59,86.08 71.8,86.08 67.63,90.25 67.63,91.12 64.7,94.04 56.37,94.04 55.2,92.87 52.99,92.87 51.52,91.4 45.32,91.4 44.59,92.12 44.59,96.49 45.06,96.96 45.06,99.96 v1(44.78,100.25) ; v1(142.38,63.34) 142,63.71 139.25,63.71 138.98,63.44 135.13,63.44 133.7,64.88 117.93,64.88 117.31,64.26 107.65,64.26 86.27,85.63 86.27,86.25 82.17,90.35 74.97,90.35 73.42,91.9 73.42,96.23 70.98,98.67 70.98,105.76 71.23,106.01 71.23,108.93 68.82,111.34 68.67,111.34 68.67,111.34 67.83,111.34 65.39,113.78 63.85,113.78 63.58,114.05 63.58,116.08 61.76,117.9 v1(61.76,119.84)
  BOTTOM w0.108: v1(142.38,63.34) 142.38,62.5 143.72,61.15 143.72,57.2 v1(144.56,56.36)
EN_LCDPWR: length 45
  TOP w0.108: v1(60.89,116.45) v2(60.89,117.11) 60.53,117.48 Q4210.3 ; v1(55.04,93.45) 55.04,93.24 52.41,90.62 52.41,89.02 52.79,88.63 52.79,87.36 52.16,86.73 50.2,86.73 49.52,87.41 49.52,88.2 49.4,88.32 U6207.2
  IN1 w0.089: v1(55.04,93.45) 55.04,93.39 55.16,93.51 55.53,93.51 55.84,93.82 55.84,94.47 55.18,95.12 55.18,102.5 57.62,104.95 57.62,105.13 57.66,105.16 57.66,111.33 58.48,112.15 58.48,113.09 59.19,113.8 59.19,114.75 v1(60.89,116.45)
  BOTTOM w0.108: U9.3 54.79,93.2 v1(55.04,93.45) 55.25,93.45 55.87,94.06 R4104.2
EN_LCDPWR_Q: length 26
  TOP w0.108: Q4210.2 57.63,116.53 57.9,116.26 57.9,112.18 v2(57.67,111.95) 57.57,111.86 57.57,105.51 55.18,103.11 55.18,99.36 55.43,99.11 55.43,97.61 v1(55.97,97.07)
  BOTTOM w0.108: D2.3 55.94,93.84 56.25,94.15 56.25,96.78 55.97,97.07 v1(55.97,97.07)
ENVDD_PCH: length 280.1
  TOP w0.108: U38.A7 233.25,50.88 233.31,50.82 233.31,49.37 231.2,47.26 231.2,43.21 231.34,43.07 v2(231.34,42.16) 231.15,41.97 v1(230.69,41.97)
  IN2 w0.089: v1(230.69,41.97) 230.41,42.25 222.29,42.25 219.83,44.71 209.41,44.71 209.26,44.56 203.51,44.56 201.85,46.22 201.85,46.69 201.49,47.05 197.49,47.05 194.27,43.83 183.5,43.83 177.57,49.75 175.56,49.75 175.04,50.28 172.33,50.28 170.45,52.17 169.06,52.17 165.95,55.28 161.92,55.28 161.3,55.9 v1(161.3,57.21) 160.88,56.79 150.94,56.79 150.6,56.45 147.54,56.45 146.81,57.17 v1(146.47,57.17)
  IN2 w0.254: v1(55.93,90.64) 56.01,90.73 65.37,90.73 65.92,90.18 65.92,89.54 69.09,86.37 70.29,85.17 71.15,84.32 71.73,84.32 72.83,83.22 72.83,80.6 77.91,75.52 87.56,75.52 105.82,57.27 131.66,57.27 135.19,53.73 v1(144.89,53.73)
  IN4 w0.076: v3(130.33,94.28) 130.9,93.7 140.66,93.7 141.16,93.21
  IN4 w0.089: 141.16,93.21 141.84,92.52 150.55,92.52 151.45,91.63 151.45,90.05 151.95,89.54 151.95,88.69 153.35,87.29 153.55,87.29 155.67,85.17 156.11,85.17 157.32,83.96 157.32,81.51 156.73,80.92 156.73,79.12 157.55,78.31 157.55,75.38 157.46,75.29 157.46,64.19 157.27,64 157.27,59.92 159.49,57.7 160.82,57.7 v1(161.3,57.21)
  BOTTOM w0.076: v3(130.33,94.28) 130.56,94.04 UC1.U13
  BOTTOM w0.108: v1(146.47,57.17) 146.33,57.17 145.92,56.76 145.92,54.76 v1(144.89,53.73)
  BOTTOM w0.254: v1(55.93,90.64) D2.2
EPC_SMBCLK: length 11.3
  TOP w0.108: R731.2 v1(182.1,54.53) 181.84,54.53 180.56,53.25 180.56,51.6 180.97,51.18 QC2808.4 v2(180.97,48.61)
  BOTTOM w0.108: JEPC1.16 181.13,56.76 182.1,55.78 v1(182.1,54.53)
EPC_SMBDAT: length 10.1
  TOP w0.108: QC2808.1 182.27,53.31 v1(182.08,53.51) 182.48,53.51 v2(182.71,53.73) 182.89,53.91 183.47,53.91 183.73,54.17 183.73,54.51 183.49,54.76 182.88,54.76 182.71,54.93 182.71,55.5 R732.2
  BOTTOM w0.108: JEPC1.15 180.63,56.61 181.62,55.62 181.62,53.99 182.1,53.51 v1(182.08,53.51)
EXPRCRD_STBY_R#: length 7.5
  BOTTOM w0.108: R717.2 R734.2 185.23,52.29 185.35,52.41 185.35,54.96 185.16,55.15 185.16,55.63 v2(184.8,55.99) 184.13,56.67 JEPC1.22
F_CMT0: length 2.8
  TOP w0.508: L2800.15 v1(176.46,132.97)
  BOTTOM w0.108: v2(177.58,133.54) R9658.2
  BOTTOM w0.508: v1(176.46,132.97) 176.49,133 R9658.2
F_CMT1: length 2.9
  TOP w0.508: v1(175.45,132.97) 175.45,132.98 175.19,133.24 L2800.16
  BOTTOM w0.108: R9659.2 175.14,133.62 v2(174.25,133.62)
  BOTTOM w0.508: v1(175.45,132.97) 175.22,133.2 R9659.2
F_CMT2: length 2.7
  TOP w0.508: L2800.21 v1(168.84,132.96)
  BOTTOM w0.108: R9660.2 v2(169.86,133.54)
  BOTTOM w0.508: v1(168.84,132.96) 168.87,132.98 R9660.2
F_CMT3: length 2.5
  TOP w0.508: L2800.22 v1(167.57,132.96)
  BOTTOM w0.108: v1(167.57,132.96) 167.52,132.91 v2(167.52,132.25)
  BOTTOM w0.508: v1(167.57,132.96) 167.6,132.98 R9661.2
F_TRLM0: length 18.4
  TOP w0.146: v1(174.31,137.78) 174.57,137.52 174.57,136.57 175.51,135.62 v6(175.87,135.62) 178.47,135.62 178.69,135.41 178.69,135.15 178.5,134.96 177.89,134.96 177.73,134.81 L2800.14
  BOTTOM w0.146: JLAN1.2 169.66,140.68 169.52,140.82 169.34,140.82 168.96,140.45 168.96,140.07 169.63,139.4 169.63,137.91 170.53,137.01 174.3,137.01 174.53,137.25 174.53,137.55 v1(174.31,137.78)
F_TRLM1: length 8.8
  TOP w0.146: v1(172.32,137.88) 172.61,137.88 173.19,137.31 v6(173.19,135.9) 173.19,135.4 172.93,135.14 172.81,135.14 172.65,134.99 L2800.18
  BOTTOM w0.146: v1(172.32,137.88) 172.48,138.04 173.26,138.04 174.42,139.2 JLAN1.6
F_TRLM2: length 9.6
  TOP w0.146: v1(173.4,139.95) 173.13,139.68 172.17,139.68 170.68,138.2 170.68,136.03 170.36,135.71 170.36,135.18 170.11,134.94 L2800.20
  BOTTOM w0.146: JLAN1.5 v1(173.4,139.95)
F_TRLM3: length 19
  TOP w0.146: v1(168.72,136.64) 168.9,136.46 168.9,136.16 168.77,136.03 165.96,136.03 165.5,135.56 165.5,135.28 165.03,134.82 L2800.24
  BOTTOM w0.146: JLAN1.8 176.1,140.32 175.82,140.32 175.69,140.19 175.69,139.7 176.03,139.36 176.03,136.53 175.12,135.63 v6(174.65,135.63) 169.3,135.63 168.9,136.03 168.9,136.46 v1(168.72,136.64)
F_TRLP0: length 18.4
  TOP w0.146: L2800.13 179,135.04 178.93,135.11 178.93,135.51 178.57,135.87 175.61,135.87 174.81,136.67 174.81,137.66 v1(174.94,137.78)
  BOTTOM w0.146: v1(174.94,137.78) 174.78,137.62 174.78,137.15 174.4,136.77 v6(171.04,136.77) 170.43,136.77 169.38,137.81 169.38,139.3 168.72,139.96 168.72,140.55 169.32,141.16 JLAN1.1
F_TRLP1: length 8.8
  TOP w0.146: L2800.17 173.92,135.09 173.92,135.09 173.92,135.14 173.44,135.63 173.44,137.41 v6(173.09,137.76) v1(172.32,138.52)
  BOTTOM w0.146: v1(172.32,138.52) 171.36,139.48 JLAN1.3
F_TRLP2: length 9.9
  TOP w0.146: 171.38,134.08 171.38,134.83 171.28,134.93 170.73,134.93 170.6,135.05 170.6,135.6 170.93,135.93 v6(170.93,136.59) 170.93,138.09 172.27,139.43 173.16,139.43 v1(173.42,139.18)
  BOTTOM w0.146: JLAN1.4 172.96,140.11 172.96,139.64 v1(173.42,139.18)
F_TRLP3: length 19
  TOP w0.146: v1(169.35,136.64) 169.14,136.43 169.14,136.05 168.87,135.78 166.07,135.78 165.75,135.46 165.75,135.13 165.94,134.94 166.2,134.94 166.3,134.84 166.3,134.08
  BOTTOM w0.146: v1(169.35,136.64) 169.15,136.44 169.15,136.13 169.4,135.88 v6(172.55,135.88) 175.02,135.88 175.78,136.63 175.78,139.26 175.44,139.6 JLAN1.7
FAN1_PWM: length 229.3
  TOP w0.108: v1(74.72,77.9) 75.09,78.27 v2(75.09,78.5) ; v1(251.13,43.27) 251.35,43.48 251.35,44.89 250.6,45.64 250.6,46.57 250.67,46.63 250.67,47.66 249.73,48.6 247.7,48.6 247.4,48.89 247.4,50.34 246.98,50.77 246.98,55.81 246.52,56.27 246.52,56.96 246.14,57.35 244.44,57.35 R408.2 243.47,56.38 241.06,56.38 240.79,56.65 240.06,56.65 239.79,56.38 U38.A24
  IN3 w0.089: v1(74.72,77.9) 74.72,77.41 75.09,77.05 87.79,77.05 90.7,74.14 90.7,72.14 105.46,57.38 138.42,57.38 138.67,57.13 142.38,57.13 145,57.13 145.57,56.56 145.57,56.24 148.6,53.22 152.11,53.22 154.66,50.67 154.66,50.29 155.05,49.9 156.47,49.9 163.92,42.44 178.57,42.44 179.91,41.11 189.67,41.11 190.33,40.46 202.2,40.46 204.63,42.89 212.02,42.89 212.63,43.5 215.65,43.5 215.78,43.38 222.02,43.38 223.16,44.52 226.27,44.52 226.97,43.82 230.04,43.82 232.06,41.8 233.01,41.8 234.31,40.5 239.47,40.5 240.51,41.54 245.11,41.54 245.55,41.97 249.57,41.97 250.86,43.27 v1(251.13,43.27)
  BOTTOM w0.108: v1(74.72,77.9) 74.72,76.38 75.8,75.3 75.8,74.68 JFAN1.2
FAN1_TACH: length 225.6
  TOP w0.108: U38.B22 238.38,54.63 238.23,54.78 237.41,54.78 237.3,54.67 v1(237.3,54.37) ; v1(243.29,54.47) 243.79,54.98 R376.2
  IN1 w0.089: v1(243.29,54.47) 242.12,54.47 241.21,55.39 238.36,55.39 237.7,54.73 237.65,54.73 v1(237.3,54.37)
  IN3 w0.089: v1(75.25,77.46) 87.91,77.46 91.06,74.31 91.06,72.29 105.61,57.73 138.57,57.73 138.82,57.49 142.24,57.49 142.75,58 144.64,58 145.93,56.7 145.93,56.39 148.74,53.57 152.29,53.57 154.91,50.95 156.66,50.95 159.04,48.57 159.04,47.9 164.13,42.81 178.71,42.81 180.05,41.47 198.26,41.47 198.91,40.81 201.81,40.81 204.24,43.24 211.87,43.24 212.48,43.86 215.83,43.86 215.96,43.73 221.87,43.73 223.01,44.88 226.42,44.88 227.12,44.17 230.19,44.17 230.3,44.06 230.31,44.06 232.22,42.15 233.15,42.15 234.45,40.85 239.32,40.85 240.36,41.9 244.97,41.9 245.63,42.57 248.25,42.57 v1(248.98,43.3)
  IN4 w0.089: v1(248.98,43.3) 248.3,43.98 248.3,50.62 246.9,52.02 246.9,53.39 246.84,53.45 246.84,53.45 246.22,54.07 245.83,54.07 245.83,54.07 245.6,54.07 245.2,54.47 v1(243.29,54.47)
  BOTTOM w0.108: JFAN1.3 76.26,73.37 v2(76.26,75.98) 76.26,76.44 v1(75.25,77.46)
FB_+1VALWP: length 4.3
  TOP w0.203: PU5501.4 133.05,125.69 132.66,126.08 131.99,126.08 PR5508.2 131.51,125.6 131.3,125.81 PR5504.1 131.3,126.89 131.25,126.94 PR5505.1
FCCM_GT: length 30.5
  TOP w0.222: PU5801.11 68.93,111.3 68.37,110.74 v1(68.37,110.22)
  TOP w0.254: v1(63.64,91.83) 63.74,91.73 PR5913.1
  IN1 w0.254: v1(63.64,91.83) 62.85,92.62 62.85,93.08 62.27,93.66 60.39,93.66 59.93,94.12 59.93,97.37 60.82,98.26 60.82,102.88 61.9,103.97 66.41,103.97 68.08,105.64 68.08,109.94 v1(68.37,110.22)
FCCM_IA: length 44.7
  TOP w0.203: PU5801.21 74.18,111.85 v1(74.51,111.52)
  TOP w0.254: v5(107.81,127.93) 107.81,126.46 v1(107.4,126.05) 107.2,125.85 107.2,125.36 PR5915.1
  IN1 w0.254: v1(107.4,126.05) 107.4,125.93 105.66,124.19 103.69,124.19 102.96,123.46 102.15,123.46 100.12,121.43 99.27,121.43 98.55,120.7 97.41,120.7 94.93,118.22 94.93,117.54 94.01,116.61 93.99,116.61 93.82,116.45 93.38,116.45 90.77,113.83 85.53,113.83 85.15,114.2 85.11,114.25 77.71,114.25 76.34,112.88 76.34,111.43 75.99,111.09 74.94,111.09 v1(74.51,111.52)
FCCM_VSA: length 61.4
  TOP w0.222: PU5801.29 74.99,115.05 75.5,115.56 v1(75.71,115.56)
  TOP w0.254: PU5902.7 123.38,126.48 122.87,126.99 v1(122.87,127.37)
  IN2 w0.254: v1(100.29,125.54) 100.7,125.54 101.03,125.21 101.03,124.7 101.33,124.4 101.99,124.4 102.83,125.24 104.48,125.24 104.84,124.88 106.82,124.88 107.53,124.17 113.24,124.17 115.83,126.76 122.26,126.76 v1(122.87,127.37)
  IN3 w0.254: v1(75.71,115.56) 75.71,119.25 76.06,119.6 83.36,119.6 83.72,119.24 94.5,119.24 98.79,123.53 98.79,124.12 100.21,125.54 v1(100.29,125.54)
  BOTTOM w0.254: v1(122.87,127.37) 123.02,127.52 v2(123.02,128.16)
FFS_INT1: length 2.4
  BOTTOM w0.108: R9458.1 189.42,46.98 189.77,47.33 190.54,47.33 190.69,47.49 U15.12
FFS_INT2: length 142.3
  TOP w0.108: v1(192.97,47) 193.08,46.9 193.08,46.06 193.71,45.43 196.05,45.43 197.85,47.23 199.45,47.23 199.83,47.61 199.83,49.29 v1(199.07,50.05)
  IN1 w0.089: v1(189.04,58.76) 189.04,57.68 191.62,55.1 191.62,51.56 191.41,51.35 191.41,49.54 191.91,49.03 194.68,49.03 195.13,48.58 198.66,48.58 198.95,48.88 198.95,49.93 v1(199.07,50.05)
  IN2 w0.089: v1(189.04,58.76) 186.07,61.73 185.61,61.73 180.12,67.22 180.12,83.48 179.18,84.42 179.18,85.89 178.73,86.35 178.63,86.35 177.71,87.26 177.71,92.44 177.71,92.59 172.91,97.39 169.1,97.39 169.09,97.39 168.95,97.39 168.65,97.39 168.64,97.39 167.58,96.33 163.58,96.33 161.89,98.02 161.74,98.02 158.09,98.02 156.9,96.84 156.04,96.84 154.95,97.93 151.78,97.93 150.37,99.33 143.7,99.33 139.68,103.35 139.68,103.83 v3(139.13,104.38)
  BOTTOM w0.076: 138.92,104.59 v3(139.13,104.38) 139.84,103.67 139.84,100.36 138.72,99.24 138.72,98.9 137.98,98.16 136.18,98.16 UC1.J4
  BOTTOM w0.108: RC346.1 139.3,107.63 139.3,107 138.92,106.62 138.92,104.59 ; 191.19,47.53 191.28,47.44 192.55,47.44 192.99,47 v1(192.97,47) ; 191.19,47.53 U15.11 ; 191.19,47.53 190.71,47.05 190.19,47.05 189.9,46.77 189.9,46.04 190.61,45.33 190.9,45.33 191.22,45 191.22,43.35 190.87,42.99 190.31,42.99 190.18,42.86 Q19.2 v2(190.18,40.64)
FFS_INT2_Q: length 50.9
  IN3 w0.089: v1(160.34,60.36) 160.46,60.24 168.52,60.24 168.61,60.33 172.25,60.33 172.62,59.97 179.09,59.97 181.75,57.32 184.12,57.32 184.7,56.74 184.7,55 184.97,54.73 186.71,54.73 187.33,54.1 187.33,53.71 v1(187.84,53.2)
  BOTTOM w0.108: v1(160.34,60.36) 160.13,60.36 v2(159.75,60.74) 157.15,63.35 JSTRG1.4 ; Q19.3 189.53,42.34 R125.1 187.9,43.97 187.9,44.69 187.51,45.08 187.51,46.98 186.02,48.47 186.02,49.14 187.83,50.95 187.83,53.2 v1(187.84,53.2)
FIVR_EN: length 9.1
  TOP w0.108: v5(74.81,129.71) v1(74.81,130.39)
  IN1 w0.089: v1(77.38,126.1) 77.38,128.23 76.71,128.89 76.31,128.89 v1(74.81,130.39)
  BOTTOM w0.108: v1(74.81,130.39) 74.81,130.6 RC382.1 RC383.1 ; v1(77.38,126.1) 77.28,126.2 RC379.1
FIVR_EN_R: length 41.2
  TOP w0.108: v1(71.03,124.37) 71.46,124.8 v5(71.46,125.08)
  IN1 w0.089: v1(66.18,118.99) 66.18,120.43 66.43,120.69 66.43,121.25 66.7,121.52 66.93,121.52 68.51,123.1 68.51,123.1 68.82,123.41 70.24,123.41 71.03,124.19 v1(71.03,124.37)
  IN3 w0.089: v1(71.03,124.37) 71.21,124.55 71.21,125.44 72.65,126.89 74.18,126.89 75.17,127.88 75.17,129.41 v1(76.16,130.39)
  BOTTOM w0.108: RC381.1 70.5,109.25 69.91,109.83 69.91,110.99 69.02,111.88 69.02,113.4 68.2,114.22 67.89,114.22 RC376.2 66.94,115.17 66.94,117.99 66.18,118.76 v1(66.18,118.99) ; JXDP1.45 79.8,123.96 79.07,124.69 79.07,124.81 78.8,125.08 78.35,125.08 77.75,125.69 77.21,125.69 76.97,125.93 76.97,126.2 76.85,126.33 76.85,127.12 76.94,127.24 RC379.2 76.85,128.11 76.85,130.29 76.74,130.39 v1(76.16,130.39)
FWP#: length 12.9
  TOP w0.108: v2(221.27,56.02) 221.91,56.02 v1(222.44,55.49) 223.25,56.3 R399.1 R393.2 ; U38.B65 v1(229.93,54.13)
  IN1 w0.089: v1(222.44,55.49) 222.91,55.96 225.74,55.96 226.1,55.6 226.1,55.32 227.29,54.13 v1(229.93,54.13)
GFX_B_DET#: length 264.2
  TOP w0.108: U37.B59 256.08,54.08 256.22,53.94 v1(256.22,53.67) ; v1(250.55,53.96) 249.95,54.57 R302.2
  IN1 w0.089: v1(131.52,143.23) 131.88,142.86 133.88,142.86 137.14,139.6 137.14,138.24 139.49,135.9 143.13,135.9 143.77,135.25 147.66,135.25 148.34,134.57 149.22,134.57 150.18,133.62 150.18,132.24 149.24,131.31 149.24,130.73 150.04,129.93 152.99,129.93 166.73,116.2 166.73,103.1 166.56,102.93 166.56,96.94 166.27,96.65 166.27,93.18 167.24,92.21 167.24,90.54 166.07,89.36 166.07,68.21 168.73,65.55 170.52,65.55 171.8,64.27 171.8,47.97 175.41,44.36 175.41,38.09 176.39,37.11 176.39,35.82 176.88,35.33 184.98,35.33 189.11,31.2 211.7,31.2 213.47,29.43 213.6,29.3 213.6,28.06 214.62,27.04 215.5,27.04 217.43,25.12 228.94,25.12 229.41,25.58 242.53,25.58 244.19,27.24 256.27,27.24 v1(256.73,26.79) ; v1(250.55,53.96) 251.42,53.09 251.44,53.09 251.59,52.95 255.49,52.95 v1(256.22,53.67)
  IN4 w0.089: v1(256.22,53.67) 256.62,53.27 256.62,52.42 255.64,51.44 255.64,49.46 255.57,49.38 255.57,46.17 256.27,45.47 256.27,43.97 255.93,43.63 255.93,40.87 257.01,39.79 257.01,39.19 255.39,37.57 255.39,34.88 256.47,33.8 256.47,27.04 v1(256.73,26.79)
  BOTTOM w0.108: JGFX1.1 131.7,143.04 v1(131.52,143.23) ; v2(257.06,54.37) 256.59,54.37 256.22,54 v1(256.22,53.67)
GP11/DRVDEN1/FDC_PP: length 1.9
  TOP w0.108: U6202.64 269.23,36.38 T6271.1
GP12/IO_SMI#: length 2.4
  TOP w0.108: U6202.27 258.78,31.38 v1(258.28,30.87)
  BOTTOM w0.108: v1(258.28,30.87) T6265.1
GP13/IRQIN1/LED1#: length 2.1
  TOP w0.108: U6202.28 v1(258.89,30.88)
  BOTTOM w0.108: v1(258.89,30.88) 259.51,30.88 T6266.1
GP21/IRTX2/WDT: length 3.1
  TOP w0.108: v1(258.31,28.78) 258.9,29.38 U6202.31
  BOTTOM w0.108: v1(258.31,28.78) 257.45,27.93 T6249.1
GP22/IRMODE/XCS2#: length 2.1
  TOP w0.108: v1(258.92,28.78) 259.01,28.88 U6202.32
  BOTTOM w0.108: T6256.1 259.09,28.61 v1(258.92,28.78)
GP23/LED2#/IRQIN2: length 1.7
  TOP w0.108: v1(265.82,37.68) 265.72,37.58 U6202.5
  BOTTOM w0.108: v1(265.82,37.68) 265.82,37.47 T6272.1
GPIO_PSID_SELECT: length 13.2
  TOP w0.108: v1(254.95,39.44) 253.89,39.44 253.19,38.74 PU1.6 ; v1(258.38,47.36) 258.51,47.36 259.03,47.89 U37.A6
  BOTTOM w0.108: v1(258.38,47.36) 257.97,46.95 257.97,45.75 256.91,44.69 256.91,43 256.12,42.2 256.12,41.22 v2(255.99,41.1) 255.73,40.84 255.73,40.23 v1(254.95,39.44)
GPP_B23: length 33.2
  TOP w0.076: 141.16,87.62 140.87,87.33 140.87,86.44 140.63,86.2 140.58,86.15 140.39,85.96 140.39,85.18 140.03,84.81 137.16,84.81 135.76,86.22 135.75,86.22 135.56,86.41 134.09,86.41 v3(133.81,86.13)
  TOP w0.108: 141.16,87.62 142.44,88.9 148.31,88.9 v2(148.96,89.55) 150.56,89.55 151.6,88.51 154.59,88.51 154.81,88.28 157.15,88.28 157.41,88.02 157.41,87.29 RC472.2 156.93,86.81 155.48,86.81 155.43,86.86 RC469.1 155.05,86.22 155.01,86.18 Q4203.2
  BOTTOM w0.076: v3(133.81,86.13) 133.95,86.13 UC1.AM7
GPP_B23_G: length 2.9
  TOP w0.108: RC474.2 RC473.2 156.53,83.17 156.3,83.4 156.1,83.4 155.83,83.67 Q4203.1
GPP_B23_Q: length 6.7
  TOP w0.108: RC471.2 156.5,87.26 v2(155.99,87.26) 155.43,87.26 155.41,87.29 154.62,87.29 RC469.2 154.19,86.3 153.93,86.04 153.05,86.04 152.4,85.4 Q4203.3
GPP_C5: length 5.5
  BOTTOM w0.076: 141.16,92.93 141.08,92.93 140.9,93.1 138.64,93.1 138.11,92.57 UC1.W1
  BOTTOM w0.108: v2(142.12,93.59) 142.12,92.9 RC350.1 141.59,92.93 141.16,92.93
