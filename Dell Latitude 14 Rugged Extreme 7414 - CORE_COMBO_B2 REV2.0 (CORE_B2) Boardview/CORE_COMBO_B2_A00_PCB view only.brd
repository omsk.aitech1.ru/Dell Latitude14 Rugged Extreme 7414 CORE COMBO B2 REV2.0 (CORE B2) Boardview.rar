# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1 (solid shape): 113.26,151.19 113.01,150.86 113,150.44 113,149.65 112.53,147.86 110.93,146.94 110.93,146.92 105.29,146.92 104.85,146.48 104.86,146.56 104.86,148.39 104.84,148.54 104.78,148.69 109.68,148.69 111.42,148.52 111.26,150.27 111.26,151.19
GND on IN1 (solid shape): 197.45,58.03 197.8,57.89 198.15,58.03 198.34,58.03 198.69,57.89 199.04,58.03 199.48,58.03 199.83,57.89 200.18,58.03 203.16,58.03 203.44,57.75 203.44,50.8 202.29,50.8 201.98,50.49 200.92,50.49 199.73,49.29 199.49,49.44 199.26,49.41 199.17,49.42 199.12,49.5 199.12,49.67 199.16,49.68 199.24,49.71 199.31,49.76 199.38,49.78 199.44,49.76 200.07,50.04 199.45,50.34 199.38,50.32 199.32,50.34 199.02,50.43 198.76,50.27 198.68,50.23 198.59,50.27 197.9,50.05 198.59,49.83 198.68,49.87 198.76,49.83 198.78,49.81 198.78,48.95 198.66,48.83 195.47,48.83 193.81,50.49 193.43,50.49 193.43,58.03
GND on IN1 (solid shape): outline of 180 points within 130.24,111.32 137.08,122.04
GND on IN1 (solid shape): 161.95,152.77 162.03,152.72 162.04,152.63 161.99,152.47 161.98,152.31 161.98,150.25 162.6,149.42 163.69,149.83 163.76,149.73 163.76,144.59 163.29,143.93 163.38,143.13 163.38,140.27 162.59,139.48 159.47,139.48 158.49,139.52 157.62,139.95 156.54,139.95 156.45,140 156.45,140.1 156.52,140.6 156.26,141.03 156.22,141.15 156.32,141.22 158.14,141.22 159.71,140.9 160.04,142.47 160.03,142.57 160.11,142.62 160.55,142.85 160.72,143.31 160.72,144.3 160.45,144.84 159.76,144.97 159.72,145.05 159.72,152.77
GND on IN1 (solid shape): 144.85,145.05 144.81,144.97 144.12,144.84 143.85,144.3 143.85,143.31 144.02,142.85 144.46,142.62 144.54,142.57 144.53,142.47 144.86,140.9 146.43,141.22 148.25,141.22 148.35,141.15 148.31,141.04 148.05,140.6 148.12,140.1 148.12,140 148.03,139.95 146.95,139.95 145.06,139.49 143.45,140.58 140.9,140.58 136.84,144.64 136.84,145.66 135.08,147.42 134.68,147.42 134.55,147.3 134.55,146.42 134.43,146.29 133.92,146.29 133.79,146.42 133.79,147.3 133.67,147.42 129.23,147.42 126.44,147.32 125.43,149.92 125.22,149.92 125.13,149.99 125.16,150.1 125.41,150.54 125.29,151.03 125.28,151.13 125.37,151.19 127.12,151.19 127.12,150.27 126.96,148.52 128.7,148.69 134.96,148.69 136.05,149.49 135.59,150.77 135.59,152.77 144.85,152.77
GND on IN1 (solid shape): outline of 1609 points within 42.38,129.12 104.27,152.77
GND on IN1 (solid shape): outline of 7660 points within 0.64,0.64 277.09,152.77
GND on VCC (solid shape): outline of 2535 points within 0.64,0.64 277.09,152.77
GND on IN2 (solid shape): 161.95,152.77 162.03,152.72 162.04,152.63 161.99,152.47 161.98,152.31 161.98,150.25 162.6,149.42 163.69,149.83 163.76,149.73 163.76,144.59 163.29,143.93 163.38,143.13 163.38,140.25 163.38,139.5 159.59,139.5 158.55,139.51 157.62,139.95 156.54,139.95 156.45,140 156.45,140.1 156.52,140.6 156.26,141.04 156.22,141.15 156.32,141.22 158.14,141.22 159.71,140.9 160.04,142.47 160.03,142.57 160.11,142.62 160.55,142.85 160.72,143.31 160.72,144.3 160.45,144.84 159.76,144.97 159.72,145.05 159.72,152.77
GND on IN2 (solid shape): 144.85,144.91 144.18,144.88 143.85,144.3 143.85,143.31 144.13,142.75 144.76,142.66 144.48,142.38 144.9,140.88 146.43,141.22 148.17,141.22 148.31,141.07 148.31,141.04 148.05,140.6 148.12,140.1 148.12,140 148.03,139.95 146.95,139.95 145.06,139.49 143.45,140.58 140.9,140.58 136.84,144.64 136.84,145.66 135.08,147.42 134.96,147.42 134.67,147.42 134.55,147.31 134.55,146.42 134.43,146.29 133.92,146.29 133.79,146.42 133.79,147.3 133.67,147.42 129.23,147.42 128.55,147.06 127.79,146.92 127.73,146.92 125.85,147.86 125.43,149.92 125.22,149.92 125.13,149.99 125.16,150.1 125.41,150.54 125.29,151.03 125.28,151.13 125.37,151.19 127.12,151.19 127.12,150.27 126.96,148.52 128.7,148.69 134.96,148.69 136.05,149.49 135.59,150.77 135.59,152.77 144.85,152.77
GND on IN2 (solid shape): outline of 1672 points within 42.38,132.65 113.12,152.77
GND on IN2 (solid shape): outline of 8086 points within 0.64,0.64 277.09,152.77
GND on IN3 (solid shape): 121.85,113.53 121.85,109.82 121.45,109.41 116.29,109.41 115.66,110.05 115.66,114.58 116.67,115.58 119.8,115.58
GND on IN3 (solid shape): 102.78,150.77 102.33,149.49 103.42,148.69 103.61,148.69 103.55,148.54 103.53,148.39 103.53,147.42 103.42,147.42 102.6,147.57 101.88,147.98 101.85,147.99 101.81,147.97 101.08,147.4 100.19,147.14 100.19,148.41 101.09,149.3 100.61,150.47 100.61,152.77 102.78,152.77
GND on IN3 (solid shape): 113.26,151.19 113,150.83 113.02,150.39 113.02,149.92 113.01,149.52 111.77,147.21 109.15,147.42 104.86,147.42 104.86,148.39 104.84,148.54 104.78,148.69 109.68,148.69 111.42,148.52 111.26,150.27 111.26,151.19
GND on IN3 (solid shape): 92.14,150.47 91.98,148.73 93.72,148.9 98.68,148.9 98.59,148.69 98.56,148.47 98.56,147.73 98.46,147.63 94.25,147.63 91.46,147.52 90.45,150.13 89.5,150.13 89.41,150.19 89.43,150.3 89.59,150.77 89.37,151.22 89.34,151.33 89.44,151.4 92.14,151.4
GND on IN3 (solid shape): 161.95,152.77 162.03,152.72 162.04,152.63 161.99,152.47 161.98,152.31 161.98,150.25 162.6,149.42 163.69,149.83 163.76,149.73 163.76,144.59 163.29,143.93 163.38,143.13 163.38,140.25 163.38,139.5 159.58,139.5 158.55,139.51 157.62,139.95 156.54,139.95 156.45,140 156.45,140.1 156.52,140.6 156.26,141.04 156.22,141.15 156.32,141.22 158.14,141.22 159.71,140.9 160.04,142.47 160.03,142.57 160.11,142.62 160.55,142.85 160.72,143.31 160.72,144.3 160.45,144.84 159.76,144.97 159.72,145.05 159.72,152.77
GND on IN3 (solid shape): 144.85,144.91 144.18,144.88 143.85,144.3 143.85,143.31 144.1,142.78 144.66,142.63 144.78,140.97 146.43,141.22 148.34,141.22 148.43,141.13 148.39,141.09 148.06,140.64 148.12,140.1 148.12,140 148.03,139.95 146.95,139.95 145.06,139.49 143.45,140.58 140.9,140.58 136.84,144.64 136.84,145.66 135.08,147.42 134.67,147.42 134.55,147.31 134.55,146.42 134.43,146.29 133.92,146.29 133.79,146.42 133.79,147.31 133.68,147.42 129.23,147.42 126.44,147.32 125.43,149.92 125.22,149.92 125.13,149.99 125.16,150.1 125.41,150.54 125.29,151.03 125.28,151.14 125.37,151.19 127.12,151.19 127.12,150.27 126.96,148.52 128.7,148.69 134.96,148.69 136.05,149.49 135.59,150.77 135.59,152.77 144.85,152.77
GND on IN3 (solid shape): outline of 488 points within 42.38,132.65 90.54,152.77
GND on IN3 (solid shape): outline of 5661 points within 0.64,0.64 277.09,152.77
GND on GND2 (solid shape): outline of 2884 points within 0.64,0.64 277.09,152.77
GND on IN4 (solid shape): 121.73,115.05 121.73,108.57 120.18,107.03 116.31,107.03 115.63,107.71 115.63,114.67 116.39,115.43 121.35,115.43
GND on IN4 (solid shape): 157.06,56.35 157.06,48.71 156.89,48.54 155.14,48.54 154.72,48.96 154.72,56.15 155.15,56.58 156.83,56.58
GND on IN4 (solid shape): 178.73,58.69 178.73,56.53 178.52,56.33 177.63,56.33 177.51,56.45 177.51,58.62 177.66,58.76 178.65,58.76
GND on IN4 (solid shape): 187.54,126.08 187.54,120.92 182.82,120.92 182.82,125.14 184.21,126.53 187.08,126.53
GND on IN4 (solid shape): 195.76,27.82 195.76,27.1 195.19,26.53 189.58,26.53 189.42,26.69 189.42,27.75 189.75,28.08 195.5,28.08
GND on IN4 (solid shape): 200.14,30.18 200.14,28.98 199.81,28.65 198.27,28.65 197.77,29.15 197.77,30.38 197.98,30.6 199.73,30.6
GND on IN4 (solid shape): 176.74,58.41 176.74,56.02 176.49,55.77 174.1,55.77 173.87,56 173.87,58.69 174.05,58.87 176.29,58.87
GND on IN4 (solid shape): 113.6,139.71 113.84,139.71 113.98,139.69 114.12,139.71 118.4,139.71 118.53,139.84 120.28,139.84 120.53,140.09 121.42,140.09 121.6,139.92 121.6,139.74 121.27,139.41 121.27,138.09 120.76,137.58 112.58,137.58 111.72,138.44 111.72,139.64 112.48,140.4 112.91,140.4
GND on IN4 (solid shape): 154.66,77.1 154.66,76.97 154.39,76.7 154.39,74.2 150.53,74.2 145.77,74.2 145.77,76.7 153.16,76.7 153.31,76.72 153.45,76.81 153.48,76.82 153.52,76.81 153.93,76.72 154.17,77.07 154.16,77.21 154.11,77.34 154.14,77.4 154.21,77.42 154.34,77.42
GND on IN4 (solid shape): outline of 100 points within 122.06,135.98 127.32,139.15
GND on IN4 (solid shape): 161.95,152.77 162.03,152.72 162.04,152.63 161.99,152.47 161.98,152.31 161.98,150.25 162.6,149.42 163.69,149.83 163.76,149.73 163.76,144.59 163.29,143.93 163.38,143.13 163.38,140.25 163.38,139.47 159.39,139.47 158.46,139.53 157.62,139.95 156.78,139.95 156.78,141.22 158.14,141.22 159.71,140.9 160.04,142.47 160.03,142.57 160.11,142.62 160.55,142.85 160.72,143.31 160.72,144.3 160.45,144.84 159.76,144.97 159.72,145.05 159.72,152.77
GND on IN4 (solid shape): 144.85,144.91 144.18,144.88 143.85,144.3 143.85,143.31 144.1,142.78 144.66,142.63 144.78,140.97 146.43,141.22 148.25,141.22 148.35,141.15 148.31,141.04 148.05,140.6 148.12,140.1 148.12,140 148.03,139.95 146.95,139.95 145.06,139.49 143.45,140.58 140.9,140.58 136.84,144.64 136.84,145.66 135.08,147.42 134.66,147.42 134.55,147.32 134.55,146.42 134.43,146.29 133.92,146.29 133.79,146.42 133.79,147.3 133.67,147.42 129.23,147.42 126.44,147.32 125.43,149.92 125.22,149.92 125.13,149.99 125.16,150.1 125.41,150.54 125.29,151.03 125.27,151.08 125.28,151.13 127.12,151.13 127.12,150.27 126.96,148.52 128.7,148.69 134.96,148.69 136.05,149.49 135.59,150.77 135.59,152.77 144.85,152.77
GND on IN4 (solid shape): outline of 342 points within 99.85,145.78 113.12,152.77
GND on IN4 (solid shape): outline of 559 points within 42.38,132.65 84.52,152.77
GND on IN4 (solid shape): outline of 902 points within 86.6,140.38 111.74,151.4
GND on IN4 (solid shape): outline of 6083 points within 0.64,0.64 277.09,152.77
GND on GND3 (solid shape): outline of 3023 points within 0.64,0.64 277.09,152.77
GNDA on TOP (solid shape): 34.48,129.83 34.48,128.92 34.32,128.76 33.46,128.76 33.46,129.76 33.79,130.09 34.22,130.09
GNDA on TOP (solid shape): 38.97,117.23 40.17,117.23 40.22,117.18 40.22,116.55 40.14,116.47 35.7,116.47 35.39,116.78 35.39,117.36 35.67,117.64 38.57,117.64
GNDA on TOP (solid shape): 37.07,143.17 37.26,143.11 37.4,142.97 37.43,142.89 37.44,142.8 37.44,135.55 37.48,135.17 37.61,134.81 38.22,134.16 39.07,133.92 41.62,133.92 41.62,132.65 39.07,132.65 37.02,133.5 36.17,135.55 36.17,141.9 16.7,141.9 16.42,141.9 16.42,143.17
GNDA on BOTTOM (solid shape): 38.31,127.95 38.31,126.86 38.14,126.68 37.4,126.68 37.3,126.78 37.3,127.98 37.4,128.08 38.19,128.08
GNDA on BOTTOM (solid shape): 37.07,143.17 37.26,143.11 37.4,142.97 37.43,142.89 37.44,142.8 37.44,135.55 37.48,135.17 37.61,134.81 38.22,134.16 39.07,133.92 41.62,133.92 41.62,132.65 39.07,132.65 37.55,133.08 36.48,134.23 36.26,134.81 36.17,135.42 36.2,135.5 36.27,135.53 36.53,135.53 36.53,136.8 35.67,136.8 35.67,138.44 36.17,138.94 36.17,141.9 23.13,141.9 23.12,141.9 22.85,142.18 16.42,142.18 16.42,143.17
GNDA on GND1 (solid shape): 37.07,143.17 37.33,143.06 37.44,142.8 37.44,135.55 37.91,134.39 39.07,133.92 41.62,133.92 41.62,125.21 39.43,125.21 39.39,125.17 39.29,125.1 39.21,124.99 39.18,124.96 39.18,120.13 40.32,120.13 40.32,116.62 40.14,116.45 34.89,116.45 34.05,117.29 33.59,117.75 33.59,128.56 33.59,128.56 33.59,129.96 33.59,137.68 31.85,139.56 23.43,139.56 23.43,137.81 23.02,137.4 16.92,137.4 16.91,137.39 16.91,139.26 16.91,139.3 16.91,139.34 16.43,139.82 16.43,143.17
GNDA on IN1 (solid shape): 37.07,143.17 37.33,143.06 37.44,142.8 37.44,135.55 37.91,134.39 39.07,133.92 41.62,133.92 41.62,132.65 39.07,132.65 37.02,133.5 36.17,135.55 36.17,141.9 16.42,141.9 16.42,143.17
GNDA on VCC (solid shape): 37.07,143.17 37.33,143.06 37.44,142.8 37.44,135.55 37.91,134.39 39.07,133.92 41.62,133.92 41.62,125.21 39.43,125.21 39.39,125.17 39.29,125.1 39.21,124.99 39.18,124.96 39.18,120.38 39.2,120.38 39.34,120.2 39.56,120.13 40.32,120.13 40.32,116.6 40.16,116.45 34.89,116.45 33.59,117.75 33.59,137.68 33.57,137.68 33.55,137.69 33.52,137.74 33.49,137.79 31.96,139.44 31.84,139.53 31.68,139.56 23.43,139.56 23.43,137.81 23.02,137.4 16.92,137.4 16.91,137.39 16.91,139.26 16.91,139.3 16.91,139.34 16.43,139.82 16.43,143.17
GNDA on IN2 (solid shape): 37.07,143.17 37.26,143.11 37.4,142.97 37.43,142.89 37.44,142.8 37.44,135.55 37.48,135.17 37.61,134.81 38.22,134.16 39.07,133.92 41.62,133.92 41.62,132.65 39.07,132.65 37.55,133.08 36.48,134.23 36.25,134.87 36.17,135.55 36.17,141.9 16.7,141.9 16.42,141.9 16.42,143.17
GNDA on IN2 (solid shape): 33.44,139.59 33.44,138.52 33.35,138.43 32.89,138.43 31.85,139.56 23.43,139.56 23.43,138.95 23.37,138.85 23.26,138.87 22.64,138.57 23.26,138.27 23.37,138.29 23.43,138.2 23.43,137.81 23.02,137.4 21.27,137.4 21.27,139.1 21.42,139.28 21.47,139.51 21.5,139.58 21.57,139.61 21.85,139.76 21.92,140.07 21.94,140.16 22.02,140.2 32.83,140.2
GNDA on IN3 (solid shape): 37.07,143.17 37.26,143.11 37.4,142.97 37.43,142.89 37.44,142.8 37.44,135.55 37.48,135.17 37.61,134.81 38.22,134.16 39.07,133.92 41.62,133.92 41.62,132.65 39.07,132.65 37.55,133.08 36.48,134.23 36.25,134.87 36.17,135.55 36.17,141.9 16.7,141.9 16.42,141.9 16.42,143.17
GNDA on GND2 (solid shape): 37.07,143.17 37.33,143.06 37.44,142.8 37.44,135.55 37.91,134.39 39.07,133.92 41.62,133.92 41.62,125.21 39.43,125.21 39.39,125.17 39.29,125.1 39.21,124.99 39.18,124.96 39.18,120.13 40.32,120.13 40.32,116.62 40.14,116.45 34.89,116.45 33.59,117.75 33.59,137.68 31.85,139.56 23.43,139.56 23.43,137.81 23.02,137.4 16.92,137.4 16.91,137.39 16.91,139.26 16.91,139.3 16.91,139.34 16.43,139.82 16.43,143.17
GNDA on IN4 (solid shape): 37.07,143.17 37.33,143.06 37.44,142.8 37.44,135.55 37.91,134.39 39.07,133.92 41.62,133.92 41.62,132.65 39.07,132.65 37.02,133.5 36.17,135.55 36.17,141.9 16.42,141.9 16.42,143.17
GNDA on GND3 (solid shape): 37.07,143.17 37.33,143.06 37.44,142.8 37.44,135.55 37.91,134.39 39.07,133.92 41.62,133.92 41.62,125.21 39.43,125.21 39.39,125.17 39.29,125.1 39.21,124.99 39.18,124.96 39.18,120.13 40.32,120.13 40.32,116.62 40.14,116.45 34.89,116.45 33.59,117.75 33.59,137.68 31.85,139.56 23.43,139.56 23.43,137.81 23.02,137.4 16.92,137.4 16.91,137.39 16.91,139.26 16.91,139.3 16.91,139.34 16.43,139.82 16.43,143.17
VCC_SW on TOP (solid shape): 116.02,125.66 116.02,121.15 115.76,120.89 113.6,120.89 112.88,121.62 112.68,121.62 112.58,121.67 112.46,121.69 111.72,121.69 111.64,121.62 107.82,121.62 107.63,121.81 107.63,123.48 107.84,123.69 109.31,123.69 109.76,124.14 111.24,124.14 111.57,124.48 111.57,124.5 111.64,124.73 111.57,124.95 111.57,125.59 111.7,125.72 114.44,125.72 114.82,126.1 115.58,126.1
VCC_VIN on TOP (solid shape): 124.67,132.88 124.67,131.69 124.45,131.46 122.95,131.46 122.74,131.25 119.75,131.25 118.04,129.54 116.6,129.54 115.32,128.26 111.7,128.26 111.57,128.39 111.57,130.93 111.7,131.05 113.09,131.05 115.01,132.97 124.59,132.97
VCC_VIN on BOTTOM (solid shape): 118.49,131.85 118.49,129.21 117.66,128.39 111.7,128.39 111.57,128.51 111.57,130.42 111.7,130.55 113.35,130.55 115,132.2 118.15,132.2
VIN_1V_PRIM on BOTTOM (solid shape): 173.67,108.52 173.67,105.42 173.54,105.3 173.54,104.38 173.39,104.23 172.55,104.23 172.4,104.08 172.4,103.54 172.38,103.52 172.15,103.52 172.12,103.54 172.12,104.15 172.07,104.2 171.94,104.2 171.89,104.15 171.89,103.54 171.87,103.52 171.66,103.52 171.64,103.54 171.64,104.15 171.59,104.2 171.44,104.2 171.38,104.15 171.38,103.54 171.36,103.52 171.16,103.52 171.13,103.54 171.13,108.07 171.82,108.75 173.44,108.75
VIN_1VS_VCCIO on BOTTOM (solid shape): 171.16,77 171.16,76.39 171.21,76.34 171.33,76.34 171.38,76.39 171.38,77 171.41,77.03 171.61,77.03 171.64,77 171.64,76.39 171.69,76.34 171.84,76.34 171.89,76.39 171.89,77 171.92,77.03 172.12,77.03 172.15,77 172.15,75.05 172.02,74.92 172.02,72.25 171.89,72.12 167.8,72.12 167.55,72.38 167.55,73.01 167.73,73.19 169.38,73.19 169.63,73.44 169.63,74.03 170.06,74.46 170.84,74.46 170.84,76.11 170.24,76.11 170.24,76.32 170.34,76.42 170.83,76.42 170.88,76.47 170.88,77 170.9,77.03 171.13,77.03
+BL_PWR_SRC on TOP (solid shape): 53.27,112 53.27,111.39 53.88,110.78 53.88,106.85 53.81,106.77 52.74,106.77 51.93,107.58 49.31,107.58 48.96,107.94 48.96,111.88 49.21,112.13 53.15,112.13
+BL_PWR_SRC on BOTTOM (solid shape): 57.08,100.11 56.98,100.01 56.32,100.01 56.12,99.81 55.56,99.81 55.43,99.94 55.43,100.82 57.08,100.82
+BL_PWR_SRC on IN2 (solid shape): 54.87,109.11 54.87,106.36 56.35,104.89 56.35,99.94 56.14,99.74 53.57,99.74 51.92,101.38 51.92,104.3 51.65,104.56 51.65,108.75 52.41,109.51 54.48,109.51
+CRT_VCC on TOP (solid shape): 85.91,150.74 85.91,149.4 85.9,149.36 85.89,149.27 85.89,149.19 85.9,149.11 85.91,149.06 85.91,146.47 86.37,146.01 86.37,143.14 86.12,142.89 84.29,142.89 83.73,143.45 83.73,146.83 83.86,146.83 83.86,146.77 83.87,146.72 83.89,146.66 83.92,146.61 83.95,146.57 83.99,146.53 84.04,146.5 84.09,146.47 84.14,146.46 84.2,146.45 84.25,146.44 84.31,146.45 84.36,146.46 84.41,146.49 84.46,146.51 84.5,146.55 84.54,146.59 84.57,146.64 84.59,146.69 84.61,146.74 84.62,146.8 84.62,146.85 84.61,146.91 84.59,146.96 84.57,147.01 84.54,147.06 84.5,147.1 84.46,147.14 84.41,147.17 84.36,147.19 84.31,147.2 84.25,147.21 84.2,147.21 84.14,147.2 84.09,147.18 84.04,147.15 83.99,147.12 83.95,147.08 83.92,147.04 83.89,146.99 83.87,146.94 83.86,146.88 83.86,146.83 83.73,146.83 83.73,147.36 85.18,148.81 85.18,150.81 85.3,150.94 85.71,150.94
+CRT_VCC on IN1 (solid shape): 86.17,144.93 86.17,144.43 85.84,144.09 83.78,144.09 83.48,144.4 83.48,144.98 83.73,145.24 85.86,145.24
+DC_IN on TOP (solid shape): 72.83,85.08 72.83,84.7 72.84,84.7 72.84,81.65 72.58,81.4 70.17,81.4 69.78,81.78 69.78,83.05 69.66,83.17 69.66,84.95 69.82,85.12 72.79,85.12
+DC_IN on TOP (solid shape): 33.97,91.81 33.97,89.4 34.23,89.14 34.23,87.11 34.1,86.99 30.42,86.99 30.29,87.11 30.29,91.81 30.42,91.94 33.85,91.94
+DC_IN on IN1 (solid shape): 34.1,89.52 34.1,87.49 33.53,86.92 30.73,86.92 30.29,87.36 30.29,89.9 30.41,90.03 33.59,90.03
+DC_IN on IN1 (solid shape): 72.2,82.92 72.2,81.65 71.94,81.4 70.17,81.4 69.66,81.9 68.77,81.9 68.64,82.03 68.64,83.55 68.77,83.68 71.44,83.68
+DC_IN on IN2 (solid shape): 34.1,89.52 34.1,87.49 33.53,86.92 30.73,86.92 30.29,87.36 30.29,89.9 30.41,90.03 33.59,90.03
+DC_IN on IN2 (solid shape): 72.2,82.92 72.2,81.65 71.94,81.4 70.17,81.4 69.66,81.9 68.77,81.9 68.64,82.03 68.64,83.55 68.77,83.68 71.44,83.68
+DC_IN on IN3 (solid shape): 34.1,89.52 34.1,87.49 33.53,86.92 30.73,86.92 30.29,87.36 30.29,89.9 30.41,90.03 33.59,90.03
+DC_IN on IN3 (solid shape): 72.2,82.92 72.2,81.65 71.94,81.4 70.17,81.4 69.66,81.9 68.77,81.9 68.64,82.03 68.64,83.55 68.77,83.68 71.44,83.68
+DC_IN on IN4 (solid shape): 34.1,89.52 34.1,87.49 33.53,86.92 30.73,86.92 30.29,87.36 30.29,89.9 30.41,90.03 33.59,90.03
+DC_IN on IN4 (solid shape): 72.2,82.92 72.2,81.65 71.94,81.4 70.17,81.4 69.66,81.9 68.77,81.9 68.64,82.03 68.64,83.55 68.77,83.68 71.44,83.68
+DC_IN_SS on TOP (solid shape): 79.72,65.72 79.72,64 79.09,63.37 76.83,63.37 76.64,63.56 76.64,65.46 77.33,66.16 79.28,66.16
+DC_IN_SS on TOP (solid shape): 208.72,24.71 208.72,22.21 208.47,21.96 201.36,21.96 201.23,22.09 201.23,23.63 205.16,23.63 205.32,23.79 205.32,24.27 205.8,24.75 208.68,24.75
+DC_IN_SS on TOP (solid shape): 151.62,25.35 151.62,22.49 151.34,22.21 149.54,22.21 149.41,22.34 149.41,25.41 149.86,25.86 151.12,25.86
+DC_IN_SS on TOP (solid shape): 70.4,79.2 70.62,79.13 70.83,79.2 72.77,79.2 72.83,79.13 72.83,75.17 71.18,73.52 69.53,73.52 69.4,73.65 69.4,74.28 69.02,74.66 69.02,77.2 68.39,77.84 68.39,79.06 68.53,79.2
+DC_IN_SS on BOTTOM (solid shape): 151.32,25.64 151.32,22.34 151.19,22.21 149.54,22.21 149.41,22.34 149.41,25.52 149.79,25.9 151.06,25.9
+DC_IN_SS on BOTTOM (solid shape): 79.29,65.58 79.29,64.35 78.4,63.45 76.22,63.45 76.06,63.62 76.06,65.88 76.29,66.1 78.77,66.1
+DC_IN_SS on IN1 (solid shape): 152.02,25.96 152.02,22.53 151.89,22.4 148.46,22.4 148.33,22.53 148.33,25.39 149.03,26.09 151.89,26.09
+DC_IN_SS on IN1 (solid shape): 73.09,77.33 73.09,74.54 77.58,70.05 77.65,69.96 77.79,69.83 77.79,69.2 77.66,68.79 77.77,68.38 77.66,67.96 77.79,67.56 77.79,67.17 78.5,66.46 78.5,64.98 78.5,64.89 79.11,64.28 79.11,63.49 78.85,63.23 74.37,63.23 73,66.34 71.34,69.31 70.35,70.82 69.29,72.28 69.28,72.3 69.28,77.33 69.53,77.59 72.83,77.59
+DC_IN_SS on IN1 (solid shape): outline of 424 points within 181.53,21.93 207.9,27.05
+DC_IN_SS on IN4 (solid shape): 153.1,25.01 153.1,22.34 152.97,22.21 149.54,22.21 149.41,22.34 149.41,25.52 149.79,25.9 152.21,25.9
+DC_IN_SS on IN4 (solid shape): 73.09,77.33 73.09,74.54 77.58,70.05 77.65,69.96 77.79,69.84 77.79,69.19 77.66,68.79 77.77,68.38 77.66,67.97 77.79,67.56 77.79,67.17 79.11,65.85 79.11,63.49 78.85,63.23 74.37,63.23 73,66.34 71.34,69.31 70.35,70.82 69.29,72.28 69.28,72.3 69.28,77.33 69.53,77.59 72.83,77.59
+DC_IN_SS on IN4 (solid shape): outline of 421 points within 181.53,21.93 207.9,27.05
+DCIN_JACK on TOP (solid shape): 29.66,91.81 29.66,87.24 29.4,86.99 27.37,86.99 27.12,87.24 27.12,91.81 27.24,91.94 29.53,91.94
+DCIN_JACK on BOTTOM (solid shape): 31.81,97.15 31.81,89.95 31.77,89.94 31.22,89.41 31.28,88.65 31.17,88.2 31.28,87.76 31.18,87.44 31.19,87.11 31.17,87.02 31.09,86.99 27.37,86.99 27.12,87.24 27.12,89.02 28.02,89.92 28.02,97.16 28.13,97.27 31.68,97.27
+DOCK_DC_IN on TOP (solid shape): 228.14,29.22 228.14,22.45 228.03,22.34 225.61,22.34 225.36,22.59 225.36,28.94 225.49,29.07 226.17,29.07 226.62,29.52 227.84,29.52
+DOCK_DC_IN on TOP (solid shape): outline of 848 points within 153.33,45.77 159.57,71.62
+DOCK_DC_IN on BOTTOM (solid shape): 213.5,41.22 213.5,39.61 213.27,39.38 208.58,39.38 206.81,41.14 206.81,41.85 207.12,42.15 212.57,42.15
+DOCK_DC_IN on BOTTOM (solid shape): 156.52,75.87 157.15,75.87 157.74,75.87 158.37,76.06 157.9,76.52 157.81,76.54 157.77,76.62 157.77,81.27 158.18,81.27 158.28,81.17 159.4,81.17 159.55,81.02 159.55,77.96 159.12,77.28 159.53,76.6 159.55,76.53 159.55,75.66 159.32,75.43 159.32,73.71 159.31,73.7 159.29,73.52 159.31,73.34 159.32,73.34 159.32,72.12 157.73,70.54 155.73,70.54 155.03,69.84 153.33,69.84 153.13,70.03 153.13,72.29 153.74,72.9 153.74,73.92 154.37,74.54 154.37,76.55 154.53,76.71 154.54,76.7 154.69,76.85 154.69,76.87 154.7,76.88 154.77,77.04 154.76,77.22 154.77,77.23 154.77,78.04 155,78.27 155,80.58 155.69,81.27 156.52,81.27
+DOCK_DC_IN on IN1 (solid shape): outline of 435 points within 206.81,26.59 228.2,42.15
+DOCK_DC_IN on VCC (solid shape): 158.56,80 158.56,70.98 158.05,70.47 156.02,70.47 155.92,70.45 155.84,70.4 155.4,69.97 153.33,69.97 153.22,70.07 153.22,73.92 153.33,74.03 153.86,74.03 153.96,74.05 154.04,74.1 154.42,74.48 154.47,74.57 154.49,74.66 154.49,75.57 155.31,76.39 155.36,76.47 155.38,76.57 155.38,80.15 155.74,80.51 158.05,80.51
+DOCK_DC_IN on IN4 (solid shape): outline of 1176 points within 150.25,33.74 213.5,48.83
+PBATT on TOP (solid shape): outline of 271 points within 155.89,26.38 167.85,34.35
+PWR_SRC on TOP (solid shape): 79.56,62.6 79.56,60.49 79.37,60.3 78.41,60.3 78.29,60.41 78.29,62.45 78.55,62.7 79.46,62.7
+PWR_SRC on TOP (solid shape): 131.18,134.1 131.18,131.81 130.82,131.46 125.51,131.46 125.36,131.61 125.36,133.44 125.61,133.69 127.54,133.69 128.2,134.35 130.92,134.35
+PWR_SRC on TOP (solid shape): 152.84,123.93 152.84,121.97 151.7,121.97 151.7,119.88 151.45,119.62 150.05,119.62 147.76,121.91 147.76,124.7 148.78,125.72 151.05,125.72
+PWR_SRC on TOP (solid shape): 48.45,111.77 48.45,109.31 48.16,109.02 43,109.02 42.99,109.03 42.99,109.44 43.11,109.56 44.59,109.56 44.78,109.75 44.78,112.01 44.89,112.13 48.09,112.13
+PWR_SRC on TOP (solid shape): outline of 144 points within 177.44,27.09 197.32,43.63
+PWR_SRC on TOP (solid shape): outline of 3265 points within 159.19,53.28 181.8,116.88
+PWR_SRC on BOTTOM (solid shape): 68.39,82.79 68.88,82.3 68.88,81.29 68.77,80.89 68.88,80.48 68.88,77.89 68.58,77.59 66.99,77.59 66.74,77.84 66.74,80.63 66.74,80.64 66.74,82.54 66.99,82.79 68.39,82.79
+PWR_SRC on BOTTOM (solid shape): 164.53,30.6 164.53,28.99 164.98,28.54 164.98,27 164.76,26.77 162.96,26.77 162.75,26.99 162.75,28.44 162.18,28.44 162.1,28.48 162.09,28.58 162.1,29.25 161.63,29.74 161.63,30.47 161.86,30.7 164.43,30.7
+PWR_SRC on BOTTOM (solid shape): outline of 300 points within 177.18,26.91 189.85,55.87
+PWR_SRC on BOTTOM (solid shape): outline of 988 points within 128.46,122.42 149.41,139.05
+PWR_SRC on VCC (solid shape): 140.98,129.35 141.06,129.29 141.16,129.27 148.8,129.27 151.06,127.01 151.06,125.7 150.12,124.75 150.07,124.67 150.05,124.58 150.05,122.54 149.92,122.42 144.44,122.42 143.88,122.98 143.8,123.05 143.7,123.05 139.51,123.05 139.4,123.05 139.33,122.98 138.77,122.42 137.83,122.42 128.71,131.54 128.71,136.21 128.89,136.39 133.94,136.39
+PWR_SRC on VCC (solid shape): 56.52,90.61 56.61,90.56 56.7,90.54 67.88,90.54 68.13,90.29 68.13,77.82 68.03,77.71 66.97,77.71 66.86,77.82 66.86,86.6 66.84,86.7 66.79,86.78 64.38,89.19 64.29,89.25 64.2,89.27 56.96,89.27 56.86,89.25 56.78,89.19 55.58,88 51.98,88 50.86,89.12 50.86,90.29 51.12,90.54 53.78,90.54 53.88,90.56 53.96,90.61 54.4,91.05 56.09,91.05
+PWR_SRC on IN2 (solid shape): 69,80.33 69,77.59 66.99,77.59 66.74,77.84 66.74,81.14 66.99,81.4 67.93,81.4
+PWR_SRC on IN2 (solid shape): 186.57,28.64 186.57,27.01 186.32,26.76 181.29,26.76 180.94,27.12 180.94,28.66 181.19,28.92 186.29,28.92
+PWR_SRC on IN2 (solid shape): 79.56,62.6 79.56,59.42 79.44,59.3 75.75,59.3 75.63,59.42 75.63,62.6 75.75,62.73 79.44,62.73
+PWR_SRC on IN2 (solid shape): 168.73,28.3 168.73,23.19 167.63,22.09 163.28,22.09 162.32,23.05 162.32,25.39 162.7,25.39 162.7,25.3 162.71,25.22 162.73,25.14 162.76,25.06 162.8,24.98 162.84,24.91 162.89,24.84 162.94,24.77 163,24.72 163.07,24.66 163.14,24.62 163.22,24.58 163.3,24.55 163.38,24.52 163.46,24.51 163.54,24.5 163.63,24.5 163.71,24.51 163.8,24.52 163.88,24.55 163.96,24.58 164.03,24.62 164.1,24.66 164.17,24.72 164.23,24.77 164.29,24.84 164.34,24.91 164.38,24.98 164.41,25.06 164.44,25.14 164.46,25.22 164.47,25.3 164.48,25.39 164.47,25.47 164.46,25.56 164.44,25.64 164.41,25.72 164.38,25.8 164.34,25.87 164.29,25.94 164.23,26 164.17,26.06 164.1,26.11 164.03,26.16 163.96,26.2 163.88,26.23 163.8,26.25 163.71,26.27 163.63,26.28 163.54,26.28 163.46,26.27 163.38,26.25 163.3,26.23 163.22,26.2 163.14,26.16 163.07,26.11 163,26.06 162.94,26 162.89,25.94 162.84,25.87 162.8,25.8 162.76,25.72 162.73,25.64 162.71,25.56 162.7,25.47 162.7,25.39 162.32,25.39 162.32,28.97 162.8,29.45 167.57,29.45
+PWR_SRC on IN3 (solid shape): 69,80.33 69,77.59 66.99,77.59 66.74,77.84 66.74,81.14 66.99,81.4 67.93,81.4
+PWR_SRC on IN3 (solid shape): 186.57,28.64 186.57,27.01 186.32,26.76 181.29,26.76 180.94,27.12 180.94,28.66 181.19,28.92 186.29,28.92
+PWR_SRC on IN3 (solid shape): 79.56,62.6 79.56,59.42 79.44,59.3 75.75,59.3 75.63,59.42 75.63,62.6 75.75,62.73 79.44,62.73
+PWR_SRC on IN3 (solid shape): 168.73,28.3 168.73,23.19 167.63,22.09 163.28,22.09 162.32,23.05 162.32,25.39 162.7,25.39 162.7,25.3 162.71,25.22 162.73,25.14 162.76,25.06 162.8,24.98 162.84,24.91 162.89,24.84 162.94,24.77 163,24.72 163.07,24.66 163.14,24.62 163.22,24.58 163.3,24.55 163.38,24.52 163.46,24.51 163.54,24.5 163.63,24.5 163.71,24.51 163.8,24.52 163.88,24.55 163.96,24.58 164.03,24.62 164.1,24.66 164.17,24.72 164.23,24.77 164.29,24.84 164.34,24.91 164.38,24.98 164.41,25.06 164.44,25.14 164.46,25.22 164.47,25.3 164.48,25.39 164.47,25.47 164.46,25.56 164.44,25.64 164.41,25.72 164.38,25.8 164.34,25.87 164.29,25.94 164.23,26 164.17,26.06 164.1,26.11 164.03,26.16 163.96,26.2 163.88,26.23 163.8,26.25 163.71,26.27 163.63,26.28 163.54,26.28 163.46,26.27 163.38,26.25 163.3,26.23 163.22,26.2 163.14,26.16 163.07,26.11 163,26.06 162.94,26 162.89,25.94 162.84,25.87 162.8,25.8 162.76,25.72 162.73,25.64 162.71,25.56 162.7,25.47 162.7,25.39 162.32,25.39 162.32,28.97 162.8,29.45 167.57,29.45
+PWR_SRC_AC on TOP (solid shape): 225.11,32.12 225.11,30.21 224.72,29.83 224.72,26.53 224.22,26.02 224.22,22.59 224.09,22.47 215.07,22.47 214.82,22.72 214.82,24.02 214.87,24.3 214.82,24.57 214.82,24.63 218.5,28.31 219.9,28.31 220.79,29.2 220.79,30.47 222.69,32.37 224.85,32.37
+SDC_IN on TOP (solid shape): 236.79,28.31 236.79,27.42 236.66,27.29 235.77,27.29 235.65,27.42 235.65,28.31 235.77,28.44 236.66,28.44
+SDC_IN on TOP (solid shape): 205.08,28.44 210.51,28.44 210.6,28.35 210.82,27.87 211.3,27.65 212.09,26.86 212.09,25.26 212.74,24.6 212.74,24.45 212.73,24.22 212.79,24.01 212.79,23.23 212.53,22.98 209.99,22.98 209.9,23.07 209.9,24.83 209.9,24.83 209.9,25.02 209.53,25.39 205.37,25.39 204.77,24.79 204.77,24.55 204.76,24.48 204.58,24.3 201.43,24.3 201.23,24.5 201.23,28.44 202.56,28.44 202.57,28.44 205.07,28.44
+SDC_IN on BOTTOM (solid shape): 236.79,27.8 236.79,26.79 236.66,26.66 235.77,26.66 235.65,26.79 235.65,27.8 235.77,27.93 236.66,27.93
+SIM_PW on TOP (solid shape): 248.11,100.66 248.35,100.42 248.35,99.51 248.27,99.43 247.84,99.43 247.74,99.53 247.74,100.7 247.82,100.78 247.82,101.09 247.82,102.23 247.84,102.25 248.11,102.25
+V_DDR_REF on TOP (solid shape): 88.05,54.12 88.05,53.35 88,53.3 87.62,53.3 87.39,53.53 86.04,53.53 86.02,53.56 86.02,53.71 86.04,53.73 87.03,53.73 87.46,54.17 88,54.17
+VCHGR on TOP (solid shape): outline of 300 points within 157.57,22.09 176.06,31.98
AUD_OUT_L on TOP (solid shape): 39.16,121.77 39.16,121.57 39.15,121.56 38.43,121.56 37.49,120.63 37.18,120.63 37.04,120.76 37.04,121.04 37.15,121.15 37.48,121.15 38.12,121.78 39.14,121.78
AUD_OUT_R on TOP (solid shape): 39.15,122.14 39.15,121.96 38.12,121.96 37.66,121.5 37.07,121.5 36.99,121.58 36.99,121.93 37.04,121.98 37.55,121.98 37.61,122.04 37.7,122.09 37.76,122.16 39.13,122.16
AUIDO_GND on TOP (solid shape): outline of 734 points within 238.85,101 262.88,122.77
AUIDO_GND on BOTTOM (solid shape): outline of 787 points within 238.85,99.81 262.87,122.77
AUIDO_GND on GND1 (solid shape): outline of 218 points within 238.85,99.81 262.88,122.77
AUIDO_GND on IN1 (solid shape): outline of 1044 points within 238.85,99.81 262.88,122.77
AUIDO_GND on VCC (solid shape): outline of 216 points within 238.85,99.81 262.88,122.77
AUIDO_GND on IN2 (solid shape): 246.57,105.47 246.57,105 245.96,104.39 245.96,104.03 245.94,104 245.94,103.47 245.96,103.44 245.96,100.96 245.83,100.83 245.05,100.83 244.56,100.83 243.54,99.81 243.22,99.81 242.2,100.83 241.82,100.83 241.82,100.83 238.85,100.83 238.85,103.1 239.87,103.1 240.02,102.94 240.02,102.52 240.57,101.97 241.65,101.97 242,102.32 242,103.73 243.49,103.73 243.5,103.68 243.51,103.62 243.54,103.57 243.57,103.52 243.6,103.48 243.64,103.44 243.69,103.41 243.74,103.39 243.79,103.37 243.85,103.37 243.9,103.37 243.96,103.37 244.01,103.39 244.06,103.41 244.11,103.44 244.15,103.48 244.19,103.52 244.22,103.57 244.24,103.62 244.25,103.68 244.26,103.73 244.26,103.79 244.25,103.84 244.23,103.9 244.2,103.95 244.17,103.99 244.13,104.03 244.09,104.07 244.04,104.09 243.99,104.11 243.93,104.13 243.88,104.13 243.82,104.13 243.77,104.11 243.71,104.09 243.67,104.07 243.62,104.03 243.58,103.99 243.55,103.95 243.52,103.9 243.51,103.84 243.5,103.79 243.49,103.73 242,103.73 242,105.38 242.28,105.65 246.39,105.65
AUIDO_GND on IN2 (solid shape): outline of 599 points within 238.85,108.73 262.87,122.77
AUIDO_GND on IN3 (solid shape): outline of 1041 points within 238.84,99.81 262.88,122.77
AUIDO_GND on GND2 (solid shape): outline of 218 points within 238.85,99.81 262.88,122.77
AUIDO_GND on IN4 (solid shape): outline of 1033 points within 238.85,99.81 262.87,122.77
AUIDO_GND on GND3 (solid shape): outline of 218 points within 238.85,99.81 262.88,122.77
BAT_CON_IO on TOP (solid shape): 214.95,104.77 214.95,102.05 214.52,101.62 210.73,101.62 210.1,102.25 210.1,104.89 210.38,105.17 214.54,105.17
BAT_CON_IO on BOTTOM (solid shape): 213.17,106.54 213.51,105.66 214.44,105.49 214.76,105.16 214.76,102.11 213.6,100.96 204.28,100.96 204.25,100.98 204.25,106.42 204.38,106.54
BATTERY_GND on TOP (solid shape): outline of 733 points within 204.24,93.04 215.79,127.77
BATTERY_GND on BOTTOM (solid shape): outline of 457 points within 204.24,93.04 215.79,127.77
BATTERY_GND on IN1 (solid shape): outline of 988 points within 204.24,93.04 215.79,127.77
BATTERY_GND on IN2 (solid shape): outline of 987 points within 204.24,93.04 215.79,127.77
BATTERY_GND on IN3 (solid shape): outline of 988 points within 204.24,93.04 215.79,127.77
BATTERY_GND on IN4 (solid shape): outline of 987 points within 204.24,93.04 215.79,127.77
BST_+1VALWP on TOP (solid shape): 134.02,128.39 134.02,127.75 133.87,127.6 133.87,126.48 133.11,126.48 132.98,126.61 132.98,128.41 133.03,128.46 133.95,128.46
BST_+1VALWP_R on TOP (solid shape): 133.92,129.73 133.92,128.89 133.77,128.74 132.2,128.74 132.17,128.77 132.17,129.7 132.28,129.81 133.84,129.81
CHARGER_SRC on TOP (solid shape): 228.22,36.32 228.22,35.26 225.97,33.01 222.44,33.01 220.41,30.98 215.83,30.98 214.88,30.02 214.88,29.52 214.56,29.2 208.39,29.2 208.14,29.45 207.58,30.37 207.58,31.36 207.52,31.42 207.18,31.76 206.56,31.76 206.56,32.37 206.73,32.54 210.37,32.54 210.45,32.43 210.54,32.34 210.67,32.25 210.82,32.19 210.91,32.17 211,32.16 211.14,32.16 211.28,32.2 211.72,32.6 211.75,33.19 211.75,34.65 212.42,35.33 212.63,35.67 212.63,36.08 212.99,36.44 228.1,36.44
CHG_BST on TOP (solid shape): 233.74,33.11 235.09,33.11 235.11,33.08 235.11,32.93 235.09,32.91 234.43,32.91 234.35,32.83 232.59,32.83 232.43,32.98 232.43,33.63 232.5,33.69 233.16,33.69
CHG_CMSRC on TOP (solid shape): 236.36,31.43 236.36,30.14 236.74,29.76 236.74,29.3 236.66,29.22 235.93,29.22 235.85,29.3 235.85,30.32 236.15,30.62 236.15,31.43 236.18,31.46 236.33,31.46
CHG_HG on TOP (solid shape): 207.02,31.21 207.02,29.91 207.33,29.6 207.33,29.36 207.25,29.29 206.63,29.29 206.27,29.65 206.27,31.2 206.32,31.25 206.98,31.25
CHG_HG on TOP (solid shape): 235.11,32.68 235.11,32.53 235.09,32.5 234.52,32.5 233.64,32.12 232.7,32.12 232.62,32.2 232.62,32.53 232.73,32.63 233.87,32.63 233.88,32.64 234.5,32.7 235.09,32.7
CHG_HG on IN4 (solid shape): 233.87,32.8 233.87,32.14 233.84,32.12 232.86,32.12 232.6,32.38 232.6,32.91 232.67,32.98 233.69,32.98
CHG_LG on TOP (solid shape): 207.03,37.75 207.03,36.34 207,36.31 206.42,36.31 206.32,36.41 206.32,37.67 206.47,37.82 206.96,37.82
CHG_LG on TOP (solid shape): 234.5,33.9 235.09,33.9 235.11,33.87 235.11,33.74 235.09,33.72 234.48,33.72 234.4,33.64 234.18,33.64 233.91,33.76 233.36,34.3 233.36,34.48 233.55,34.66 233.74,34.66
CHG_LG on IN4 (solid shape): 234.53,34.02 234.53,33.92 234.2,33.59 233.67,33.59 233.07,34.19 233.07,34.75 233.23,34.91 233.64,34.91
CHG_LX on TOP (solid shape): 235.11,32.27 235.11,32.14 235.09,32.12 234.53,32.12 233.13,30.98 232.22,30.98 232.09,31.1 232.09,31.87 232.19,31.97 233.69,31.97 234.45,32.3 235.09,32.3
CHG_LX on TOP (solid shape): outline of 210 points within 198.11,29.34 210.5,43.57
CHG_LX on IN4 (solid shape): 232.47,31.74 232.47,30.72 232.34,30.6 231.58,30.6 231.46,30.72 231.46,31.74 231.58,31.87 232.34,31.87
CHG_VCC on TOP (solid shape): 235.11,31.89 235.11,31.05 234.56,30.5 234.28,30.5 232.09,28.31 232.09,28.06 231.96,27.93 231.33,27.93 231.2,28.06 231.2,29.33 231.33,29.45 231.96,29.45 232.6,30.09 232.6,30.6 232.73,30.72 233.68,30.72 234.54,31.59 234.54,31.85 234.61,31.92 235.09,31.92
GT_SW on TOP (solid shape): 66.87,98.29 66.87,95.15 66.84,95.07 66.83,94.99 66.83,93.97 66.87,93.93 66.87,91.68 66.61,91.43 64.7,91.43 64.43,91.71 64.43,92.6 63.85,93.17 63.53,93.17 63.52,93.18 62.67,93.18 62.67,96.08 62.47,96.28 62.47,97.45 62.85,97.83 63.74,97.83 64.45,98.54 66.61,98.54
GT_VIN on TOP (solid shape): 59.24,103.37 59.24,101.21 59.88,100.57 59.88,96.38 60.11,96.16 60.11,93.28 60.03,93.21 59.42,93.21 58.16,94.06 57.82,94.4 57.82,94.71 57.81,94.72 57.42,95.06 57.42,96.43 57.08,96.76 57.08,103.24 57.59,103.75 58.86,103.75
GT_VIN on BOTTOM (solid shape): outline of 459 points within 56.68,83.81 70.45,100.45
INT_SPK_L+ on TOP (solid shape): 33.47,95.95 36.21,95.95 36.28,95.88 36.28,94.99 36.22,94.92 33.3,94.92 33.3,94.92 33,94.92 31.64,96.28 31.64,96.38 32.17,96.92 32.5,96.92
INT_SPK_L+ on TOP (solid shape): 41.63,120.1 41.63,119.43 41.63,119.42 41.63,119.2 41.63,119.2 41.63,119.11 42.07,118.66 42.07,117.23 42,117.16 41.21,117.16 41.08,117.29 41.08,117.9 41.44,118.26 41.44,118.92 41.4,118.96 41.4,120.06 41.46,120.13 41.6,120.13
INT_SPK_L- on TOP (solid shape): 34.3,97.32 36.26,97.32 36.31,97.27 36.31,96.51 36.26,96.46 33.68,96.46 32.58,97.56 32.58,98.57 33.06,98.57
INT_SPK_L- on TOP (solid shape): 42.03,120.07 42.03,119.4 42.08,119.35 42.45,119.35 43.03,118.77 43.03,118.49 43.65,117.87 43.65,116.88 42.86,116.88 42.66,117.08 42.66,117.81 42.32,118.15 42.32,118.75 41.81,119.27 41.81,119.43 41.8,119.44 41.8,120.08 41.84,120.13 41.97,120.13
INT_SPKR_L+ on TOP (solid shape): 37.98,95.27 37.98,94.89 38.34,94.54 38.4,94.46 38.48,94.4 39.97,92.91 43.85,92.91 44.4,92.35 44.4,91.91 44.3,91.81 39.57,91.81 37.19,94.2 37.19,94.67 36.98,94.88 36.98,95.59 37.05,95.67 37.58,95.67
INT_SPKR_L+ on BOTTOM (solid shape): 44.36,92.49 44.36,90.5 43.6,90.5 43.6,92.44 43.7,92.55 44.31,92.55
INT_SPKR_L- on TOP (solid shape): 39.03,96.68 39.03,96.68 39.55,96.16 39.55,95.71 40.66,94.6 41.64,94.6 41.81,94.43 44.38,94.43 45.78,93.04 45.78,91.86 45.61,91.68 44.95,91.68 44.91,91.73 44.91,92.56 44.06,93.42 40.39,93.42 39.05,94.75 38.94,95 38.69,95.11 38.55,95.25 38.55,95.53 37.7,96.38 37.43,96.38 37.43,96.38 37.15,96.38 37.08,96.45 37.08,97.34 37.14,97.4 38.31,97.4
INT_SPKR_L- on BOTTOM (solid shape): 45.63,92.49 45.63,90.5 44.87,90.5 44.87,92.49 44.92,92.55 45.58,92.55
LX_1V_PRIM on BOTTOM (solid shape): 171.38,101.41 171.38,100.78 171.4,100.76 171.6,100.76 171.63,100.79 171.63,101.4 171.65,101.42 171.85,101.42 171.88,101.4 171.88,100.43 172.45,99.86 174.36,99.86 175.09,99.12 175.09,98.34 174.86,98.11 170.37,98.11 170.04,98.44 170.04,99.95 170.55,100.46 171.02,100.46 171.12,100.56 171.12,101.4 171.14,101.42 171.37,101.42
LX_1VS_VCCIO on BOTTOM (solid shape): 174.43,81.65 174.43,80.89 173.67,80.13 172.25,80.13 172.15,80.02 172.15,79.19 172.12,79.16 171.92,79.16 171.89,79.19 171.89,79.79 171.87,79.82 171.66,79.82 171.64,79.79 171.64,79.19 171.61,79.16 171.41,79.16 171.38,79.19 171.38,80 171,80.38 169.35,80.38 169.23,80.51 169.23,81.27 169.73,81.78 174.31,81.78
LX_+1VALWP on TOP (solid shape): 131.76,129.63 131.76,128.72 131.68,128.64 130.06,128.64 129.96,128.74 129.96,129.5 130.19,129.73 131.66,129.73
LX_+1VALWP on TOP (solid shape): 135.75,124.65 135.75,123.56 136.97,122.34 136.97,121.14 137.35,120.77 138.11,120.77 138.36,120.51 138.36,119.93 136.03,119.93 135.34,119.24 131.51,119.24 131.13,119.62 131.13,121.63 131.38,121.88 133.03,121.88 133.16,122.01 133.16,123.43 133.28,123.56 134.51,123.56 134.63,123.69 134.63,124.72 134.66,124.75 135.65,124.75
PBATT+_C on TOP (solid shape): 155.13,31.61 155.13,24.5 154.92,24.29 152.49,24.29 152.29,24.49 152.29,25.56 150.94,26.91 150.94,28.74 152.03,29.83 153.1,29.83 154.37,31.1 154.37,31.61 154.62,31.87 154.87,31.87
PBATT+_C on BOTTOM (solid shape): 153.68,28.82 160.39,28.82 160.39,23.91 160.21,23.74 152.33,23.74 152.08,23.99 152.08,26.15 151.57,26.66 151.06,26.66 150.93,26.79 150.91,27.13 150.73,27.43 150.73,29.07 151,29.34 153.16,29.34
PWM_IA on TOP (solid shape): 110.55,129.12 110.55,128.36 110.5,128.31 110.4,128.31 110.4,128.94 110.39,128.96 109.88,128.96 109.14,128.22 109.04,128.22 108.9,128.36 108.9,129.13 109.03,129.26 110.41,129.26
PWR_SRC_ON on TOP (solid shape): 44.77,108.24 46.37,108.24 46.39,108.22 46.39,107.66 45.98,107.25 43.98,107.25 43.8,107.43 43.8,107.84 43.7,107.94 42.96,107.94 42.86,108.04 42.86,108.37 42.91,108.42 44.59,108.42
RING2 on TOP (solid shape): 37.26,125.55 37.26,124.35 37.83,123.78 39.12,123.78 39.15,123.75 39.15,123.56 39.14,123.55 37.47,123.55 36.52,124.5 36.52,125.58 36.67,125.72 37.09,125.72
RING2 on BOTTOM (solid shape): 37.22,125.92 37.22,124.58 37.09,124.45 36.07,124.45 35.86,124.65 35.86,126.09 35.93,126.15 36.99,126.15
RING2_D on TOP (solid shape): 243.72,107.94 243.72,104.31 243.67,104.26 243.65,104.26 243.43,104.03 243.34,103.75 243.43,103.46 243.67,103.21 243.67,102.4 243.14,102.4 243.09,102.35 243.09,101 243.06,100.98 242.86,100.98 242.83,101 242.83,102.35 242.78,102.4 242.68,102.4 242.61,102.32 242.61,101 242.58,100.98 242.33,100.98 242.33,103.17 241.55,103.94 241.55,108.31 241.84,108.6 243.06,108.6
RING2_D on BOTTOM (solid shape): 242.73,108.37 242.73,106.31 242.58,106.16 242.08,106.16 242.08,106.16 241.08,106.16 241.03,106.21 241.03,108.4 241.04,108.41 241.04,108.48 241.56,109 242.1,109
RING2_D on IN2 (solid shape): 249.64,108.73 248.09,107.18 247.86,107.18 247.84,107.18 246.7,106.03 242.48,106.03 242.15,106.36 242.15,108.34 242.38,108.57 245.35,108.57 245.71,108.22 246.16,108.22 248.7,110.76 249.64,110.76
RING2_L on BOTTOM (solid shape): 34.73,125.29 35.37,125.29 35.42,125.24 35.42,123.97 35.15,123.7 34.62,123.7 34.1,124.22 33.79,124.22 33.67,124.35 33.67,125.59 33.87,125.79 34.22,125.79
RING2_L on BOTTOM (solid shape): 20.03,141.79 20.03,140.48 20.03,140.12 20.21,139.94 20.21,139.51 20.52,139.2 20.52,137.72 20.49,137.68 19.98,137.68 19.93,137.73 19.93,138.99 19.84,139.08 19.63,139.08 19.17,139.55 19.17,140.27 19.42,140.53 19.42,141.72 19.52,141.82 20,141.82
RING2_L on IN2 (solid shape): 20.38,141.57 20.38,139.21 20.05,138.88 19.21,138.88 18.86,139.23 18.86,141.59 19.01,141.75 20.2,141.75
RING2_L on IN2 (solid shape): 35.09,125.92 35.09,124.63 34.81,124.35 33.74,124.35 33.62,124.47 33.62,126.05 33.75,126.19 34.82,126.19
SA_HG on TOP (solid shape): 122.64,124.98 122.64,124.5 122.72,124.42 122.97,124.42 123,124.4 123,123.97 122.97,123.94 122.34,123.94 121.93,124.35 121.93,125.01 122.08,125.16 122.46,125.16
SA_LG on TOP (solid shape): 124.93,126.02 124.93,125.39 125.3,125.02 125.95,125.02 126.01,124.96 126.01,124.63 125.93,124.55 125.26,124.55 124.57,125.24 124.57,125.72 124.55,125.74 124.32,125.74 124.27,125.79 124.27,126.18 124.32,126.23 124.72,126.23
SA_SW on TOP (solid shape): 123.02,126.33 123.02,125.79 122.97,125.74 122.08,125.74 121.6,126.23 120.97,126.23 120.84,126.35 120.84,126.73 120.97,126.86 122.49,126.86
SA_SW on TOP (solid shape): 127.24,124.47 127.9,123.81 128.41,123.81 128.69,123.53 128.69,120.94 128.51,120.77 126.34,120.77 126.26,120.79 126.17,120.8 125.6,120.8 125.56,120.77 124.98,120.77 124.95,120.74 123.26,120.74 123.12,120.88 122.88,120.88 122.77,120.99 122.77,121.48 122.85,121.55 123.45,121.55 123.66,121.76 123.66,122.01 124.52,122.87 124.98,122.87 125.26,123.15 125.26,123.46 126.23,124.42 126.23,126.96 127.24,126.96
SA_SW on BOTTOM (solid shape): 125,122.67 125,120.74 124.9,120.64 122.59,120.64 122.39,120.84 122.39,122.67 122.52,122.8 124.88,122.8
SA_VIN on TOP (solid shape): 129.4,130.87 129.4,125.41 129.35,125.36 128.81,125.36 128.78,125.32 128.27,125.32 128.01,125.07 128.01,124.56 127.93,124.48 127.67,124.48 127.55,124.6 127.55,127.14 127.39,127.3 126.86,127.3 126.43,127.72 126.43,130.7 126.66,130.93 129.35,130.93
SIM_GND on TOP (solid shape): outline of 336 points within 238.84,86.04 262.88,108.19
SIM_GND on BOTTOM (solid shape): 250.31,102.8 250.31,102.77 250.3,102.67 250.32,102.56 250.31,102.47 250.22,102.43 248.45,102.43 248.45,104.16 248.95,104.16
SIM_GND on BOTTOM (solid shape): outline of 382 points within 238.84,86.04 262.88,108.19
SIM_GND on GND1 (solid shape): 262.88,87.02 262.87,86.9 262.62,86.29 262.01,86.04 259.59,86.04 255.57,86.94 252.33,89.49 246.47,95.04 239.38,98.92 238.99,99.24 238.85,99.72 238.85,100.32 240.97,100.32 240.97,100.32 241.99,100.32 242.93,99.38 243.02,99.32 243.11,99.3 243.65,99.3 243.74,99.32 243.83,99.38 244.77,100.32 245.93,100.32 246.03,100.34 246.11,100.39 246.39,100.67 246.45,100.75 246.47,100.85 246.47,104.18 247,104.71 247.06,104.79 247.08,104.89 247.08,105.67 248.07,106.67 248.22,106.67 248.32,106.69 248.4,106.74 249.88,108.19 262.88,108.19
SIM_GND on IN1 (solid shape): outline of 438 points within 238.85,86.04 262.88,108.19
SIM_GND on VCC (solid shape): 262.88,87.02 262.87,86.9 262.62,86.29 262.01,86.04 259.59,86.04 255.57,86.94 252.33,89.49 246.47,95.04 239.38,98.92 238.99,99.24 238.85,99.72 238.85,100.32 240.97,100.32 240.97,100.32 241.99,100.32 242.93,99.38 243.02,99.32 243.11,99.3 243.65,99.3 243.74,99.32 243.83,99.38 244.77,100.32 245.93,100.32 246.03,100.34 246.11,100.39 246.39,100.67 246.45,100.75 246.47,100.85 246.47,104.18 247,104.71 247.06,104.79 247.08,104.89 247.08,105.67 248.07,106.67 248.22,106.67 248.32,106.69 248.4,106.74 249.88,108.19 262.88,108.19
SIM_GND on IN2 (solid shape): outline of 389 points within 238.85,86.04 262.87,108.19
SIM_GND on IN3 (solid shape): outline of 437 points within 238.84,86.04 262.88,108.19
SIM_GND on GND2 (solid shape): 262.88,87.02 262.87,86.9 262.62,86.29 262.01,86.04 259.59,86.04 255.57,86.94 252.33,89.49 246.47,95.04 239.38,98.92 238.99,99.24 238.85,99.72 238.85,100.32 240.97,100.32 240.97,100.32 241.99,100.32 242.93,99.38 243.02,99.32 243.11,99.3 243.65,99.3 243.74,99.32 243.83,99.38 244.77,100.32 245.93,100.32 246.03,100.34 246.11,100.39 246.39,100.67 246.45,100.75 246.47,100.85 246.47,104.18 247,104.71 247.06,104.79 247.08,104.89 247.08,105.67 248.07,106.67 248.22,106.67 248.32,106.69 248.4,106.74 249.88,108.19 262.88,108.19
SIM_GND on IN4 (solid shape): outline of 396 points within 238.85,86.04 262.87,108.18
SIM_GND on GND3 (solid shape): 262.88,87.02 262.87,86.9 262.62,86.29 262.01,86.04 259.59,86.04 255.57,86.94 252.33,89.49 246.47,95.04 239.38,98.92 238.99,99.24 238.85,99.72 238.85,100.32 240.97,100.32 240.97,100.32 241.99,100.32 242.93,99.38 243.02,99.32 243.11,99.3 243.65,99.3 243.74,99.32 243.83,99.38 244.77,100.32 245.93,100.32 246.03,100.34 246.11,100.39 246.39,100.67 246.45,100.75 246.47,100.85 246.47,104.18 247,104.71 247.06,104.79 247.08,104.89 247.08,105.67 248.07,106.67 248.22,106.67 248.32,106.69 248.4,106.74 249.88,108.19 262.88,108.19
SLEEVE on TOP (solid shape): 37.22,123.38 39.13,123.38 39.16,123.35 39.16,123.18 39.14,123.16 37.15,123.16 36.71,122.72 36.31,122.72 36.09,122.94 36.09,123.93 36.16,123.99 36.61,123.99
SLEEVE on TOP (solid shape): 35.88,135.73 35.88,134.43 35.95,134.35 35.95,132.22 36.33,131.51 36.33,131.51 36.33,131.2 36.21,131.08 35.95,131.08 35.95,131.08 35.42,131.61 35.42,135.73 35.44,135.75 35.85,135.75
SLEEVE on BOTTOM (solid shape): 37.3,123.56 37.3,123.18 36.45,122.33 36.45,122.06 36.37,121.98 35.42,121.98 35.32,122.09 35.32,123.11 36.11,123.91 36.95,123.91
SLEEVE on IN2 (solid shape): 36.94,123.64 36.94,122.47 36.6,122.13 35.76,122.13 35.52,122.37 35.52,123.64 35.89,124.01 36.57,124.01
SLEEVE on IN3 (solid shape): 36.37,131.41 36.37,130 36.2,129.83 35.22,129.83 34.81,130.24 34.81,131.59 35.25,132.03 35.75,132.03
SLEEVE on IN3 (solid shape): 37.02,123.81 37.02,122.42 36.89,122.29 34.86,122.29 34.61,122.54 34.61,123.81 34.73,123.94 36.89,123.94
SLEEVE_D on TOP (solid shape): 242.1,102.86 242.1,101 242.07,100.98 241.84,100.98 241.82,101 241.82,102.32 241.74,102.4 241.64,102.4 241.59,102.35 241.59,100.98 241.31,100.98 241.31,102.27 241.21,102.38 240.65,102.38 240.47,102.55 240.47,103.34 240.63,103.49 241.46,103.49
SLEEVE_D on BOTTOM (solid shape): 242.33,104.86 242.33,104.1 241.82,103.59 241.82,102.55 241.56,102.3 240.65,102.3 240.47,102.48 240.47,105.37 241.82,105.37
SLEEVE_D on IN2 (solid shape): outline of 365 points within 238.85,102.35 242.28,116.42
SLEEVE_L on TOP (solid shape): 37.64,132.49 37.64,131.62 37.53,131.51 37.09,131.51 37.08,131.52 37,131.65 36.46,132.5 36.46,133.21 36.51,133.26 36.87,133.26
SLEEVE_L on BOTTOM (solid shape): 21.02,141.82 21.02,140.45 21.16,140.31 21.66,140.31 21.72,140.25 22.77,140.25 24.09,141.57 26.4,141.57 26.63,141.34 26.63,140.73 26.43,140.53 24.19,140.53 22.95,139.28 21.74,139.28 21.53,139.07 21.53,137.68 21.5,137.66 21.02,137.66 20.94,137.73 20.94,139.06 20.43,139.56 20.43,141.8 20.48,141.85 20.99,141.85
SLEEVE_L on IN3 (solid shape): 22.74,140.88 22.74,139.41 22.19,138.85 20.89,138.85 20.56,139.18 20.56,140.5 20.97,140.91 22.72,140.91
SLEEVE_L on IN3 (solid shape): 37.83,132.45 37.83,131.84 37.45,131.46 37.09,131.46 35.7,132.86 35.7,133.16 35.9,133.36 36.92,133.36
SNUB_3V on TOP (solid shape): 191.2,49.26 191.2,48.25 191.07,48.12 190.43,48.12 189.8,48.76 189.16,48.76 189.04,48.88 189.04,49.26 189.16,49.39 191.07,49.39
SNUB_5V on TOP (solid shape): 191.68,71.51 191.68,70.83 191.2,70.35 189.67,70.35 189.55,70.47 189.55,72 189.67,72.12 191.07,72.12
N37735982 on TOP (solid shape): 118.71,126.51 118.71,125.36 118.58,125.24 118.25,125.24 118.12,125.36 118.12,125.4 118.15,125.54 118.12,125.68 118.12,125.74 117.97,125.9 117.9,125.9 117.77,125.92 117.63,125.9 117.46,125.9 117.36,125.79 117.36,124.88 117.23,124.75 116.72,124.75 116.6,124.88 116.6,126.48 116.8,126.68 118.53,126.68
N37888482 on TOP (solid shape): 139.25,122.62 139.25,122.01 138.76,121.51 137.48,121.51 137.35,121.64 137.35,122.92 137.48,123.05 138.82,123.05
N37906747 on TOP (solid shape): 207.73,40.79 208.06,40.73 208.4,40.79 208.99,40.79 209.1,40.68 209.1,38.77 208.9,38.57 207.38,38.57 207.33,38.62 207.33,40.55 207.57,40.79
N37906776 on TOP (solid shape): 231.57,32.59 231.84,32.32 231.84,31.23 231.71,31.1 230.62,31.1 230.3,31.42 230.3,31.9 231.07,32.68 231.07,33.64 231.13,33.69 231.57,33.69
N37907023 on TOP (solid shape): 237.81,39.79 237.81,38.62 237.74,38.31 237.93,38.06 237.93,37.07 237.81,36.95 237.81,35.88 237.17,35.24 237.17,34.58 237.15,34.56 236.99,34.56 236.97,34.58 236.97,35.47 237.2,35.7 237.2,37.43 237.07,37.55 237.07,38.49 236.71,38.85 236.71,39.87 236.84,39.99 237.6,39.99
N40499959 on TOP (solid shape): 183.53,92.85 184.92,92.85 184.95,92.83 184.95,92.7 184.92,92.67 184.16,92.67 184.14,92.65 184.14,92.47 184.16,92.44 184.92,92.44 184.95,92.42 184.95,92.29 184.92,92.27 182.74,92.27 182.56,92.44 182.56,93.21 182.61,93.26 183.12,93.26
N40639272 on BOTTOM (solid shape): 79.28,75.73 79.28,73.44 76.82,70.98 76.56,70.98 75.91,71.79 76.88,72.61 76.88,73.51 77.43,74.05 77.43,75.91 74.38,78.96 73.01,78.96 72.68,78.63 71.66,78.63 71.16,79.13 71.16,79.69 70.93,79.92 70.32,79.92 70.04,80.2 70.04,80.89 70.17,81.01 74,81.01
N40942623 on TOP (solid shape): 110.95,129.95 110.95,128.31 110.83,128.31 110.78,128.36 110.78,129.25 110.37,129.66 109.28,129.66 109.23,129.71 109.23,130.32 109.41,130.49 110.4,130.49
N40942627 on TOP (solid shape): 108.63,129.73 108.48,129.58 107.99,129.58 107.99,131.79 108.63,131.79
N40942629 on TOP (solid shape): 111.44,130.72 111.44,129.68 111.34,129.58 111.34,128.33 111.31,128.31 111.21,128.31 111.19,128.33 111.19,130.24 110.63,130.8 109.41,130.8 109.33,130.87 109.33,131.56 109.48,131.71 110.45,131.71
