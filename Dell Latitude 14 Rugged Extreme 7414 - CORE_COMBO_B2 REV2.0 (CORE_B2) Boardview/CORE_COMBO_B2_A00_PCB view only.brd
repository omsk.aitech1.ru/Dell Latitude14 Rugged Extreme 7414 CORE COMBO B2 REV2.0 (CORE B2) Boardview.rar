# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG_RCOMP: length 3.8
  TOP w0.381: RC114.2 102.17,98.9 102.17,99.8 v5(102.8,100.43) v3(103.85,100.43)
  BOTTOM w0.305: v3(103.85,100.43) 103.85,100.24 UC1.E60
CHARGER_SMBCLK: length 114.1
  TOP w0.108: v1(230.13,60.69) 230.26,60.69 230.5,60.93 U38.B50 ; v1(244.18,34.15) 243.94,33.91 243.76,33.91 PR5239.2 ; v1(228.88,63.35) 228.55,63.68 228.55,63.73 R350.2
  IN1 w0.089: v1(263.21,27.37) 263.8,27.97 264.61,27.97 264.99,28.35 267.31,28.35 269.52,30.55 269.52,38.08 271.42,39.99 271.42,46.85 272.06,47.49 272.06,51.14 271.23,51.98 271.23,55.77 271.92,56.47 271.92,60.22 270.12,62.03 258.09,62.03 257.82,61.75 253.5,61.75 253.26,61.51 245.24,61.51 244.59,62.16 243.04,62.16 241.52,63.68 236.53,63.68 235.94,63.1 235.24,63.1 234.95,62.81 233.84,62.81 232.97,63.67 232.02,63.67 230.13,61.78 v1(230.13,60.69)
  IN3 w0.089: v1(263.21,27.37) 262.86,27.02 260.46,27.02 259.14,28.35 257.36,28.35 254.56,31.14 250.75,31.14 248.68,33.21 245.86,33.21 245.27,33.8 244.54,33.8 v1(244.18,34.15)
  IN4 w0.089: v1(230.13,60.69) 228.88,61.94 v1(228.88,63.35)
  BOTTOM w0.108: v2(262.63,27.94) v1(263.21,27.37)
CHARGER_SMBDAT: length 110.6
  TOP w0.108: R348.2 229.74,63.38 v1(229.95,63.38) 229.95,63.26 230.42,62.78 230.42,62.52 230.75,62.19 U38.A47 ; v1(244.18,33.26) 243.9,33.54 243.72,33.54 PR5238.2
  IN1 w0.089: v1(263.84,27.37) 264.42,27.37 265.11,28.06 267.44,28.06 269.81,30.43 269.81,37.96 271.71,39.87 271.71,46.72 272.36,47.37 272.36,51.26 271.52,52.1 271.52,55.65 272.22,56.34 272.22,60.34 270.24,62.32 257.97,62.32 257.7,62.05 253.23,62.05 252.99,61.81 245.36,61.81 243.19,63.98 236.4,63.98 235.82,63.39 235.12,63.39 234.83,63.1 233.96,63.1 233.1,63.96 231.9,63.96 231.31,63.38 v1(229.95,63.38)
  IN3 w0.089: v1(244.18,33.26) 244.42,33.5 245.15,33.5 245.74,32.91 248.58,32.91 250.63,30.85 254.44,30.85 257.24,28.06 259.01,28.06 260.34,26.73 263.2,26.73 v1(263.84,27.37)
CHARGER_SRC:
  vias: v2(226.55,34.35)
CHG_ACDET: length 5.4
  TOP w0.108: PR5226.1 v1(241.56,29.53)
  TOP w0.203: PU5201.6 237.46,30.81 237.68,30.6 238.39,30.6 238.8,30.19 PC5214.1 238.81,29.54 PR5227.2 240.38,29.54 240.4,29.53 PR5226.1
CHG_ACDRV: length 3
  TOP w0.203: v1(236.87,30.17) 236.66,30.38 PU5201.4
  TOP w0.508: PR5222.1 v1(236.87,30.17)
  BOTTOM w0.108: v2(237.81,30.17) v1(236.87,30.17)
CHG_ACN: length 24.8
  TOP w0.203: PC5202.2 234.33,29.96 234.58,30.21 234.88,30.21 235.46,30.79 PU5201.1
  TOP w0.254: v1(240.19,26.16) 240.19,25.57 239.79,25.16 PQ5205.2 239.14,25.47 238.52,26.1 PR5209.2 ; PQ5207.2 229.11,26.02 229.24,26.15 231.46,26.15 v1(231.96,26.66) 232.17,26.66 232.87,27.36 233.69,27.36 233.87,27.53 233.87,28.23 PC5203.1 233.36,28.86 234.08,29.58 PC5202.2
  IN3 w0.254: v1(240.19,26.16) 239.42,25.39 236.99,25.39 236.58,25.79 234.8,25.79 233.93,26.66 v1(231.96,26.66)
  BOTTOM w0.108: v2(240.19,25.45) v1(240.19,26.16)
CHG_ACP: length 14.4
  TOP w0.203: PC5202.1 235.19,30.01 235.86,30.68 PU5201.2
  TOP w0.254: PR5207.2 236,26.15 235.84,25.99 PQ5204.2 235.37,25.16 235.14,25.39 235.14,25.9 234.88,26.15 233.86,26.15 233.55,25.84 233.55,25.45 233.26,25.16 PQ5206.2 232.54,26.15 v2(233.21,26.82) 233.78,26.82 234.25,27.29 234.25,28.36 234.48,28.6 PC5201.1 235.01,28.94 235.19,29.12 PC5202.1
CHG_BST:
  vias: v2(233.61,33.03)
CHG_CMPIN: length 8.6
  TOP w0.108: 243.98,35.93 244.18,35.93 PR5237.1 245.77,35.21 v2(245.91,35.07)
  TOP w0.127: 243.98,35.93 PR5241.2 243.04,35.4 243.04,35.37 PR5240.1 242.58,34.91 240.93,34.91 PC5234.2 239.93,34.41 239.68,34.15 239.48,34.15 239.14,33.81 PU5201.13
CHG_CMPOUT: length 8.2
  TOP w0.108: PC5237.2 240.42,35.66 239.49,34.74
  TOP w0.127: 239.49,34.74 v1(239.43,34.67) 239.43,34.66 238.98,34.21 PU5201.14 ; PC5237.2 240.88,35.22 242,35.22 PR5241.1 242.76,35.98 PR5243.1 PR5244.2
  BOTTOM w0.108: v2(238.75,34.38) 239.25,34.38 239.43,34.56 v1(239.43,34.67)
CHG_CMSRC:
  vias: v1(236.08,30.19)
CHG_HG: length 27.4
  IN4 w1.016: v4(206.69,29.93) 208.29,29.93 209.71,31.36 214.31,31.36 215.45,32.5 230.78,32.5 231.16,32.88 232.78,32.88 232.83,32.83
  vias: v1(232.85,32.37) v1(233.49,32.37) v2(207.2,29.3)
CHG_LG: length 30
  IN4 w1.016: 233.46,34.41 231.96,34.41 230.62,35.75 213.62,35.75 212.25,34.38 209.76,34.38 v4(206.69,37.45)
  BOTTOM w0.508: v2(232.83,34.41) v1(233.61,34.41)
  vias: v1(234.12,33.9)
CHG_LX: length 29
  IN4 w1.016: 232.09,30.98 224.7,30.98 223.17,29.45 209.96,29.45 208.88,28.37 205.86,28.37 205.12,29.12 v4(205.12,29.78)
  vias: v1(232.22,31.74) v1(232.22,31.1) v2(204.51,30.82)
CHG_SRN: length 79.7
  TOP w0.203: PJP5204.2 176.08,31.1 176.21,31.23 176.21,32.19 v1(175.96,32.43) ; PU5201.19 236.26,35.21 236.08,35.4 236.08,35.8 PC5232.2 236.71,36.89 236.66,36.95 PC5236.1 235.9,38.04 235.87,38.04 235.46,38.45 v1(235.46,38.75)
  BOTTOM w0.108: 179.58,31.26 v2(179.79,31.26)
  BOTTOM w0.203: v1(175.96,32.43) 176.13,32.6 176.13,32.61 176.45,32.93 178.35,32.93 179.58,31.7 179.58,29.48 182.76,26.3 187.92,26.3 189.95,28.33 196.05,28.33 197.52,26.86 209.9,26.86 210.69,27.65 222.29,27.65 225.93,31.29 225.93,34.55 225.93,34.56 225.93,34.57 227.73,36.36 228.92,37.55 230.31,37.55 231.38,38.62 231.38,38.99 231.95,39.56 234.68,39.56 235.46,38.79 v1(235.46,38.75)
CHG_SRP: length 77.8
  TOP w0.203: PU5201.20 235.86,35.18 235.7,35.34 235.7,36.28 PC5232.1 235.85,36.87 235.82,36.89 PC5235.1 234.82,38.33 v1(234.82,38.75) ; v1(176.65,32.41) 176.51,32.27 176.51,31.37 176.78,31.1 PJP5203.2
  BOTTOM w0.108: v2(179.41,28.94) 179.55,29.08
  BOTTOM w0.203: v1(176.65,32.41) 176.87,32.62 178.2,32.62 179.28,31.55 179.28,29.36 182.64,26 188.05,26 190.08,28.03 195.92,28.03 197.4,26.55 210.03,26.55 210.82,27.34 222.16,27.34 222.41,27.34 226.24,31.17 226.24,34.43 226.24,34.43 226.24,34.45 227.85,36.06 229.04,37.25 230.44,37.25 231.68,38.49 231.68,38.86 232.08,39.26 234.32,39.26 234.82,38.75 v1(234.82,38.75)
CHG_VCC:
  vias: v2(233.97,30.61)
CLK_27M_IN: length 5.1
  TOP w0.152: U6.K1 84.61,134.93 84.61,135.34 v2(84.3,135.65) 83.85,136.11 R66.2 83.12,135.88 R107.2
CLK_27M_IN_R: length 4.8
  TOP w0.152: R107.1 80.81,135.88 80.63,135.7 C42.1 80.05,135.7 79.76,135.42 78.11,135.42 77.24,136.28 Y1.1
CLK_27M_OUT: length 7.7
  TOP w0.152: Y1.3 79.56,134.27 C43.1 81.43,134.91 v2(81.6,134.75) 81.9,135.05 83.16,135.05 R66.1 83.67,134.92 83.97,134.92 U6.L1
CLK_CHINA_TPM: length 179.6
  TOP w0.108: v1(141.29,71.11) 139.57,69.4 134.8,69.4 134.67,69.52 130.92,69.52 CC289.2 131.38,70.49 RC619.2 ; R9681.2 v1(271.46,47.99) ; U26.22 269.57,44.49 v1(269.52,44.54)
  IN2 w0.089: v1(141.29,71.11) 141.82,71.64 151.22,71.64 152.1,72.52 164.61,72.52 165.82,71.31 168.45,71.31 171.73,68.03 171.73,65.59 176.07,61.25 177.73,61.25 182.03,56.96 184.44,56.96 184.86,56.53 185.68,56.53 187.32,54.9 188.43,54.9 189.84,53.49 193.19,53.49 194,52.68 205.25,52.68 207.85,50.08 217.52,50.08 218.55,51.12 224.52,51.12 226.26,52.86 227.84,52.86 229.69,54.71 231.73,54.71 231.97,54.46 233.95,54.46 234.75,53.66 235.24,53.66 235.47,53.43 235.47,52.36 235.67,52.16 244.18,52.16 244.92,52.9 245.19,52.9 245.39,53.09 245.72,53.09 247.06,51.75 249.77,51.75 251.11,53.09 251.44,53.09 251.64,52.9 255.97,52.9 256.05,52.98 256.39,52.98 256.47,52.9 257,52.9 257.07,52.97 257.4,52.97 257.47,52.9 258.55,52.9 259.14,53.49 259.14,57.57 259.62,58.05 261.89,58.05 262.39,57.55 262.39,56.43 262.77,56.05 262.77,52.14 263.57,51.35 264.42,51.35 266,49.77 269.68,49.77 v1(271.46,47.99) 269.52,46.05 v1(269.52,44.54)
  BOTTOM w0.108: v2(142.07,71.01) 141.39,71.01 v1(141.29,71.11)
CLK_COM_PCI: length 159.9
  TOP w0.108: v1(258.53,38.8) 258.76,39.03 C9941.1 259.14,38.24 260.22,37.16 U6202.16 ; v1(129.78,70.56) 129.35,70.99 129.35,71.04 CC80.2 128.71,72.58 RC58.2
  IN3 w0.089: v1(143.83,68.95) 145.2,70.33 146.42,70.33 149.04,67.7 152.06,67.7 152.57,67.2 156.42,67.2 159.99,63.64 168.85,63.64 169.55,62.94 178.98,62.94 181.82,60.1 183.79,60.1 184.6,59.29 185.33,59.29 186.49,58.12 186.49,57.66 189.5,54.66 207.73,54.66 209.16,56.09 217.99,56.09 218.88,56.98 229.42,56.98 229.67,57.23 240.62,57.23 242.51,55.34 247.17,55.34 247.57,54.94 248.03,54.94 248.31,54.67 248.31,54.32 249.79,52.85 250.86,52.85 251.11,53.09 251.95,53.09 252.74,52.3 254.18,52.3 254.67,51.8 v1(257.24,51.8)
  IN4 w0.089: v1(257.24,51.8) 257.68,51.36 257.68,49.04 257.51,48.87 257.51,45.24 257.89,44.86 257.89,43.47 256.94,42.52 256.94,41.03 258,39.97 258,39.33 v1(258.53,38.8)
  BOTTOM w0.108: v1(129.78,70.56) 130.35,70.56 130.92,69.99 v2(131.53,69.99) 132.14,69.38 137.29,69.38 137.39,69.48 143.3,69.48 v1(143.83,68.95)
CLK_DBGPCI: length 22.3
  TOP w0.108: RC66.2 130.49,72.38 130.67,72.2 CC25.2 130.06,71.76 v1(129.78,72.04) ; v1(138.01,71.11) 139.24,72.33 142.39,72.33 142.79,72.73 143.75,72.73 143.98,72.96 143.98,75.55 143.53,76 JDEG2.12
  BOTTOM w0.108: v1(138.01,71.11) 137.67,70.76 137.6,70.7 137.6,70.49 137.23,70.12 132.45,70.12 v2(130.74,71.82) 130.52,72.04 v1(129.78,72.04)
CLK_DDC2_CRT: length 30.1
  TOP w0.089: U6.L4 85,131.95 84.22,131.95 v1(83.68,132.48)
  IN3 w0.089: v1(92.57,146.7) 92.37,146.5 90.77,146.5 88.96,148.3 JCRT1.15
  IN4 w0.089: v1(83.34,137.2) 83.42,137.2 83.95,136.67 83.95,132.75 v1(83.68,132.48)
  BOTTOM w0.108: v1(83.34,137.2) 84.21,137.2 84.89,137.88 84.89,138.18 v2(85.01,138.3) 85.46,138.75 85.71,138.75 86.35,139.38 R2748.2 87.09,140.17 89.73,140.17 90.08,140.52 D4.4 90.08,141.95 90.23,142.1 92.62,142.1 93.34,142.82 93.34,145.92 v1(92.57,146.7)
CLK_ITPXDP_N: length 16.9
  TOP w0.102: RC297.1 104.48,109.35 105.1,108.73 ; 105.1,108.73 v6(105.1,108.69) ; 105.1,108.73 105.72,108.12 107.22,108.12 110.55,104.79 110.55,103.32 111.92,101.94 111.92,100.83 112.3,100.45 112.3,100.13 v3(112.78,99.65)
  BOTTOM w0.102: UC1.F43 113.09,99.34 v3(112.78,99.65)
CLK_ITPXDP_N_R: length 31.3
  TOP w0.102: RC297.2 104.78,112.73 104.78,112.87 104.28,113.37 104.28,113.93 104.15,114.06 103.97,114.06 v1(103.8,113.88)
  IN4 w0.102: v1(103.8,113.88) 103.62,113.7 103.34,113.7 103.27,113.78 103.27,113.92 103.43,114.08 103.43,114.22 103.36,114.3 103.13,114.3 102.94,114.11 98.98,114.11 98.32,113.45 90.56,113.45 90.1,113.91 81.33,113.91 79.59,115.65 79,115.65 v1(78.8,115.44)
  BOTTOM w0.102: JXDP1.42 78.8,115.46 78.8,115.46 v1(78.8,115.44)
CLK_ITPXDP_P: length 16.9
  TOP w0.102: 104.68,110.4 104.68,109.44 105.8,108.32 107.31,108.32 110.75,104.87 110.75,103.4 112.13,102.03 112.13,100.92 112.53,100.52 112.53,100.47 v3(112.78,100.21) ; 104.68,110.4 104.68,111.06 104.79,111.16 104.91,111.16 105.01,111.06 105.19,111.06 105.29,111.16 RC298.1 ; 104.68,110.4 v6(104.71,110.4)
  BOTTOM w0.102: v3(112.78,100.21) 113.11,100.21 113.24,100.09 UC1.E43
CLK_ITPXDP_P_R: length 31.3
  TOP w0.102: v1(103.81,114.51) 104.06,114.26 104.24,114.26 104.48,114.01 104.48,113.46 104.98,112.96 104.98,112.75 RC298.2
  IN4 w0.102: v1(78.19,115.64) 78.4,115.85 79.67,115.85 81.41,114.11 90.19,114.11 90.65,113.65 98.23,113.65 98.89,114.31 102.86,114.31 103.05,114.51 v1(103.81,114.51)
  BOTTOM w0.102: v1(78.19,115.64) 78.3,115.75 JXDP1.40
CLK_KBD: length 2.5
  TOP w0.108: U38.A38 235.25,62.73 236.06,63.54 236.13,63.54 R356.2
CLK_MSE: length 2.3
  TOP w0.108: R385.2 235.52,63.62 234.75,62.84 U38.A39
CLK_PCI_5048: length 168.3
  TOP w0.108: U37.A28 266.46,55.33 266.47,55.32 266.48,55.32 266.88,54.93 266.88,54.92 267.21,54.59 v1(267.28,54.59) 267.28,54.24 267.43,54.09 R324.2 ; RC65.2 126.81,72.45 126.81,71.87 126.38,71.44 126.19,71.44 CC57.2 125.6,69.95 126,69.56 127.14,69.56 127.72,68.97 129,68.97 129.65,68.31 v1(130.03,68.31)
  IN3 w0.089: v1(267.28,54.59) 267.82,54.59 268.06,54.34 268.06,52.72 266.55,51.21 253.05,51.21 252.11,52.16 250.15,52.16 249.78,51.79 247.34,51.79 246.98,52.16 246.98,53.08 246.1,53.96 245.99,53.96 245.99,53.96 245.68,53.96 244.5,53.96 242.81,52.27 239.62,52.27 238.82,53.07 237.34,53.07 236.87,53.54 236.87,54.52 235.86,55.53 225.91,55.53 224.95,54.57 220.89,54.57 216.74,50.43 202.95,50.43 199.66,53.72 188.83,53.72 184.75,57.8 182.15,57.8 179.51,60.44 172.91,60.44 172.53,60.82 169.23,60.82 168.72,61.33 165.8,61.33 165.31,61.81 163.28,61.81 162.75,62.35 158.05,62.35 154.6,65.8 152.64,65.8 151.7,66.74 148.55,66.74 147.46,67.83 146.44,67.83 v1(146.42,67.86)
  BOTTOM w0.108: v1(130.03,68.31) 130.12,68.4 v2(130.77,68.4) 136.32,68.4 137.53,67.2 138.42,67.2 139.05,67.83 144.23,67.83 144.94,68.54 145.73,68.54 v1(146.42,67.86)
CLK_PCI_MEC: length 148.8
  TOP w0.108: U38.A29 240.67,58.88 R382.2 242.02,59.22 242.7,59.22 243.27,58.66 246.79,58.66 247.45,58.01 247.45,56.57 247.84,56.17 v1(247.84,54.47) ; v1(129.78,69.94) 129.29,69.46 127.93,69.46 127.06,70.32 127.06,71.17 CC290.2 128.21,72.32 RC64.2
  IN3 w0.089: v1(145.45,69.08) 145.88,69.51 146.57,69.51 148.85,67.23 151.87,67.23 152.37,66.73 155.75,66.73 159.61,62.88 162.88,62.88 162.96,62.8 165.21,62.8 166.05,61.96 179.29,61.96 181.63,59.63 183.6,59.63 189.04,54.19 199.86,54.19 203.15,50.9 216.55,50.9 220.69,55.04 223.72,55.04 224.68,56 236.05,56 236.44,55.61 241.57,55.61 242.32,54.87 246.8,54.87 247.2,54.47 v1(247.84,54.47)
  BOTTOM w0.108: v1(145.45,69.08) 144.71,69.08 144.16,68.52 141.9,68.52 v2(141.84,68.57) 141.43,68.99 137.66,68.99 137.56,68.89 130.83,68.89 v1(129.78,69.94)
CLK_PCIE_N0: length 53.3
  IN3 w0.102: v1(111,136.75) 110.76,136.51 108.16,136.51 106.76,135.12 104.4,135.12 103.72,134.43 103.72,127.73 103.47,127.47 103.47,126.3 102.37,125.21 102.37,123.41 101.36,122.39 101.36,118.88 104.23,116.01 104.23,113.37 104.58,113.01 104.58,109.83 107.6,106.82 111.36,106.82 111.54,106.64 v1(111.54,106.46)
  BOTTOM w0.076: 112.47,105.77 112.62,105.77 113.09,105.29 113.09,103.24 112.94,103.09 112.94,102.58 112.97,102.49 112.97,102.3 112.94,102.18 112.94,101.93 113.03,101.67 113.03,101.1 UC1.D42
  BOTTOM w0.102: v1(111,136.75) 111.5,137.25 112.48,137.25 112.7,137.48 JGFX1.78 ; 112.47,105.77 112.13,105.77 111.84,106.06 111.84,106.17 v1(111.54,106.46)
CLK_PCIE_N1: length 118.6
  IN4 w0.102: v1(21.27,125.34) 21.6,125.34 21.73,125.21 21.73,124.97 22.79,123.91 22.79,119.34 24.88,117.26 24.88,113.34 28.98,109.23 51.22,109.23 51.92,109.93 55.27,109.93 56.11,109.09 59.79,109.09 60.36,108.52 62.53,108.52 63.1,109.09 71.28,109.09 72.82,110.63 77.82,110.63 78.43,110.02 82.03,110.02 82.94,110.94 95.03,110.94 95.36,111.27 101.41,111.27 103.34,109.34 103.34,108.6 105.55,106.39 107.43,106.39 107.8,106.02 107.82,106.02 108,105.83 112.58,105.83 112.99,105.42 113.38,105.42 113.6,105.64 113.6,105.78 v3(113.83,106.01)
  BOTTOM w0.102: JWLAN1.49 22.83,125.02 22.51,125.34 22.06,125.34 ; 22.06,125.34 v1(21.27,125.34) ; 22.06,125.34 v6(22.06,125.31) ; v3(113.83,106.01) 113.83,105.12 113.65,104.94 113.65,102.34 UC1.B42
CLK_PCIE_N2: length 45.8
  IN3 w0.102: v3(114.23,103.42) 114.11,103.54 113.8,103.54 113.55,103.79 113.55,105.15 114.23,105.83 114.23,106.74 113.02,107.96 108.64,107.96 106.84,109.77 106.05,109.77 105.57,110.25 105.57,116.52 106.08,117.03 106.08,118.17 105.6,118.66 104.96,118.66 103.59,120.02 103.59,124.38 104.53,125.32 104.53,126.86 105.01,127.35 105.01,133.41 104.84,133.59 v1(104.58,133.59)
  BOTTOM w0.076: UC1.D41 114.17,101.49 114.26,101.65 114.26,101.84 114.19,101.96 114.18,101.96 113.99,102.14 113.99,103.25 114.16,103.42 v3(114.23,103.42)
  BOTTOM w0.102: JWWAN1.53 105.85,134.58 105.06,133.78 104.77,133.78 v1(104.58,133.59)
CLK_PCIE_N3: length 144
  IN4 w0.102: v1(162.4,55.95) 162.4,55.05 162.65,54.8 163.7,54.8 164.54,53.96 169.77,53.96 171.64,55.83 171.64,69.16 166.83,73.97 166.83,74.8 166.41,75.22 166.41,90.07 167.14,90.81 167.14,93.43 160.16,100.42 160.16,101.89 156.09,105.96 156.09,110.17 154.84,111.42 153.76,111.42 149.73,115.46 147,115.46 145.45,117.01 141.87,117.01 141.46,117.41 137.59,117.41 136.35,118.66 131.26,118.66 130.85,119.06 126.9,119.06 125.81,117.98 125.8,117.98 124.85,117.03 115.73,117.03 113.73,115.03 113.73,107.88 115.28,106.33 115.28,106.06 v3(115.1,105.88)
  BOTTOM w0.076: UC1.D40 114.84,101.1 114.84,101.67 114.93,101.93 114.93,102.18 114.89,102.3 114.89,102.49 114.93,102.58 115.12,102.77 115.12,103.26 115.72,103.86 115.72,105.42 115.52,105.61 115.37,105.61 v3(115.1,105.88)
  BOTTOM w0.102: JSTRG1.20 159.02,55.35 159.41,55.74 159.8,55.74 ; 159.8,55.74 160.89,55.74 161.63,56.48 162.49,56.48 162.63,56.33 162.63,56.19 162.54,56.1 v1(162.4,55.95) ; 159.8,55.74 v6(159.8,55.72)
CLK_PCIE_N4: length 84
  TOP w0.102: v1(115.23,135.09) 115.23,134.15 115.6,133.78 118.2,133.78 ; U21.45 142.26,131.14 142.17,131.23 140.56,131.23 140.48,131.14 138.47,131.14 137.07,132.54 137.07,132.71 137.07,132.71 137.07,133.6 135.39,135.28 133.16,135.28 132.83,134.95 128.01,134.95 127.31,134.25 124.95,134.25 124.48,133.78 118.2,133.78 ; v6(118.2,133.76) 118.2,133.78
  IN3 w0.102: v3(115.12,104.69) 115.34,104.69 115.71,105.06 115.71,106.41 113.34,108.78 109.43,108.78 106.89,111.31 106.89,120.94 106.71,121.12 105.24,121.12 104.53,121.83 104.53,124.05 105.21,124.73 106.69,124.73 106.92,124.96 106.92,125.57 106.61,125.87 106.61,133.34 108.77,135.5 113.47,135.5 114.44,134.53 115.1,134.53 115.23,134.66 v1(115.23,135.09)
  BOTTOM w0.076: UC1.B40 114.5,102.21 114.23,102.48 114.23,102.87 114.59,103.23 114.59,104.21 114.75,104.37 114.88,104.37 115.12,104.62 v3(115.12,104.69)
CLK_PCIE_N5: length 123.2
  IN4 w0.102: v3(114.59,100.24) 114.79,100.04 114.89,100.04 114.98,100.13 114.98,100.63 116.17,101.82 116.17,106.53 115.02,107.68 115.02,115.14 115.88,115.99 121.74,115.99 122.05,116.29 129.47,116.29 130.08,115.69 132.24,115.69 132.73,115.2 137.48,115.2 138.19,114.49 142.04,114.49 142.93,115.38 144.78,115.38 146.63,113.53 149.36,113.53 154.09,108.8 154.09,108.05 154.44,107.69 154.44,105.14 157.41,102.17 157.41,100.27 157.54,100.14 162.75,94.93 162.75,94.22 165.72,91.25 165.72,74.94 166.15,74.51 166.15,72.92 167.09,71.97 167.7,71.97 169.43,70.24 169.43,69.13 170.24,68.31 170.24,67.91 170.34,67.81 170.52,67.81 170.65,67.68 v1(170.65,67.41)
  BOTTOM w0.102: v6(172.62,65.62) 172.59,65.62 ; 172.59,65.62 171.52,66.69 170.71,66.69 170.42,66.98 170.42,67.18 v1(170.65,67.41) ; 172.59,65.62 177.83,60.38 177.83,58.31 177.91,58.23 178.06,58.23 178.13,58.17 JEPC1.10 ; UC1.E40 115.07,100.2 115.02,100.24 v3(114.59,100.24)
CLK_PCIE_P0: length 53.3
  IN3 w0.102: v1(112.2,106.46) 112.2,106.85 112.08,106.97 111.87,106.97 111.79,106.89 111.65,106.89 111.47,107.07 107.7,107.07 104.84,109.94 104.84,113.12 104.48,113.48 104.48,116.11 101.61,118.98 101.61,122.29 102.63,123.31 102.63,125.1 103.72,126.2 103.72,127.37 103.97,127.62 103.97,134.33 104.51,134.86 106.87,134.86 108.27,136.26 111.39,136.26 111.66,136.53 v1(111.66,136.75)
  BOTTOM w0.076: 112.55,105.97 112.56,105.96 112.66,105.96 113.26,105.36 113.26,103.18 113.1,103.02 113.1,102.61 113.14,102.52 113.14,102.27 113.1,102.15 113.1,101.96 113.19,101.7 113.19,101.59 UC1.C42
  BOTTOM w0.102: v1(111.66,136.75) 111.66,136.95 111.76,137.05 112.56,137.05 113.2,137.69 JGFX1.76 ; 112.55,105.97 112.22,105.97 112.04,106.15 112.04,106.3 v1(112.2,106.46)
CLK_PCIE_P1: length 118.6
  IN4 w0.102: v1(21.27,125.97) 21.93,125.31 21.93,125.06 23,123.99 23,119.43 25.08,117.34 25.08,113.42 29.07,109.44 51.13,109.44 51.83,110.14 55.36,110.14 56.2,109.3 59.88,109.3 60.45,108.73 62.45,108.73 63.02,109.3 71.19,109.3 72.73,110.83 77.91,110.83 78.52,110.22 81.94,110.22 82.86,111.14 94.95,111.14 95.28,111.47 101.49,111.47 103.54,109.42 103.54,108.68 105.63,106.59 107.51,106.59 107.88,106.22 107.9,106.22 108.09,106.03 112.67,106.03 113.07,105.63 113.29,105.63 113.4,105.73 113.4,105.88 v3(113.24,106.03)
  BOTTOM w0.102: UC1.A42 113.45,102.79 113.45,105.03 113.63,105.2 113.63,105.58 113.55,105.65 113.32,105.65 113.24,105.72 v3(113.24,106.03) ; v1(21.27,125.97) 21.38,126.08 21.62,126.08 21.75,125.95 21.75,125.65 21.85,125.54 22.59,125.54 22.91,125.22 24.51,125.22 24.6,125.31 24.6,125.37 24.74,125.52 JWLAN1.47
CLK_PCIE_P2: length 45.9
  IN3 w0.102: v1(104.58,134.23) 105.27,133.54 105.27,127.24 104.79,126.76 104.79,125.21 103.85,124.27 103.85,120.13 105.07,118.91 105.7,118.91 106.34,118.28 106.34,116.93 105.83,116.42 105.83,110.35 106.16,110.02 106.94,110.02 108.75,108.22 113.12,108.22 114.49,106.85 114.49,105.72 113.8,105.04 113.8,103.89 113.9,103.8 114.06,103.8 v3(114.23,103.98)
  BOTTOM w0.076: UC1.C41 113.93,101.97 113.83,102.07 113.83,103.52 114.23,103.92 v3(114.23,103.98)
  BOTTOM w0.102: v1(104.58,134.23) 104.83,133.98 104.97,133.98 105.77,134.78 106.15,134.78 106.45,135.08 JWWAN1.55
CLK_PCIE_P3: length 143.9
  IN4 w0.102: v1(163.02,55.95) 163.25,55.72 163.25,55.54 163.11,55.4 162.95,55.4 162.81,55.54 162.69,55.54 162.6,55.45 162.6,55.13 162.73,55 163.79,55 164.62,54.17 169.68,54.17 171.44,55.92 171.44,69.08 166.63,73.89 166.63,74.71 166.2,75.14 166.2,90.16 166.94,90.89 166.94,93.35 159.95,100.34 159.95,101.81 155.89,105.87 155.89,110.09 154.76,111.22 153.68,111.22 149.65,115.25 146.92,115.25 145.37,116.8 141.79,116.8 141.38,117.21 137.51,117.21 136.26,118.45 131.18,118.45 130.77,118.86 126.98,118.86 125.9,117.77 125.88,117.77 124.94,116.83 115.81,116.83 113.93,114.95 113.93,107.96 115.48,106.41 115.48,105.88 115.62,105.74 115.62,105.49 115.43,105.3 v3(115.1,105.3)
  BOTTOM w0.076: UC1.C40 114.67,101.59 114.67,101.7 114.76,101.96 114.76,102.15 114.73,102.27 114.73,102.52 114.79,102.67 114.96,102.84 114.96,103.33 115.56,103.93 115.56,105.35 115.45,105.45 115.25,105.45 v3(115.1,105.3)
  BOTTOM w0.102: JSTRG1.19 156.57,55.85 156.65,55.77 156.65,55.66 156.76,55.55 158.93,55.55 159.32,55.94 160.81,55.94 161.55,56.68 162.02,56.68 ; 162.02,56.68 162.57,56.68 162.85,56.4 162.85,56.12 v1(163.02,55.95) ; 162.02,56.68 v6(162.02,56.71)
CLK_PCIE_P4: length 84
  TOP w0.102: v1(115.89,135.11) 116.06,134.93 116.06,134.74 115.99,134.66 115.48,134.66 115.43,134.61 115.43,134.23 115.68,133.98 116.43,133.98 ; 116.43,133.98 v6(116.43,134) ; 116.43,133.98 124.39,133.98 124.87,134.46 127.23,134.46 127.93,135.15 132.75,135.15 133.07,135.48 135.48,135.48 137.28,133.68 137.28,132.62 138.55,131.35 140.39,131.35 140.48,131.43 142.17,131.43 142.28,131.54 U21.44
  IN3 w0.102: v1(115.89,135.11) 115.89,134.85 115.81,134.78 115.55,134.78 115.48,134.71 115.48,134.55 115.2,134.28 114.33,134.28 113.37,135.24 108.88,135.24 106.87,133.23 106.87,125.98 107.17,125.67 107.17,124.85 106.79,124.47 105.32,124.47 104.79,123.94 104.79,121.94 105.35,121.37 106.82,121.37 107.15,121.04 107.15,111.42 109.54,109.03 113.45,109.03 115.96,106.52 115.96,104.95 v3(115.13,104.12)
  BOTTOM w0.076: v3(115.13,104.12) 115.05,104.2 114.82,104.2 114.76,104.14 114.76,103.16 114.5,102.9 UC1.A40
CLK_PCIE_P5: length 123.2
  IN4 w0.102: v3(114.6,99.59) 114.86,99.84 114.98,99.84 115.18,100.04 115.18,100.21 115.18,100.21 115.18,100.54 116.37,101.73 116.37,106.62 115.23,107.76 115.23,115.05 115.96,115.79 121.83,115.79 122.13,116.09 129.39,116.09 130,115.48 132.16,115.48 132.64,115 137.39,115 138.1,114.29 142.12,114.29 143.01,115.18 144.69,115.18 146.55,113.32 149.28,113.32 153.88,108.72 153.88,107.96 154.24,107.61 154.24,105.06 157.21,102.09 157.21,100.18 157.46,99.94 162.55,94.85 162.55,94.14 165.52,91.17 165.52,74.85 165.94,74.43 165.94,72.83 167.01,71.77 167.18,71.77 167.62,71.77 169.23,70.16 169.23,69.04 170.04,68.23 v1(170.04,67.41)
  BOTTOM w0.076: UC1.E38 115.66,99.67 114.68,99.67 v3(114.6,99.59)
  BOTTOM w0.102: 171,66.49 170.62,66.49 170.22,66.89 170.22,67.23 v1(170.04,67.41) ; 171,66.49 171.44,66.49 177.63,60.29 JEPC1.9 ; 171,66.49 v6(171,66.46)
CLK_TP_SIO: length 181.8
  TOP w0.108: R444.1 v1(152.72,63.62) ; U38.A37 v1(235.75,62.65)
  IN1 w0.089: v1(168.26,32.78) 167.39,31.91 164.29,31.91 163.68,32.53 163.68,34.57 163,35.24 158.85,35.24 151.52,42.58 151.52,49.4 150.52,50.39 150.52,50.93 150.07,51.38 150.07,60.97 150.87,61.77 152.08,61.77 152.21,61.9 152.21,63.11 v1(152.72,63.62)
  IN4 w0.089: v1(168.26,32.78) 168.9,32.78 169.18,33.07 178.47,33.07 179.48,32.06 201.85,32.06 203.1,30.81 203.1,28.04 204.09,27.04 220.86,27.04 224.3,23.6 240.69,23.6 247.61,30.52 247.61,34.43 247.28,34.76 v1(247.28,34.81)
  BOTTOM w0.108: v1(235.75,62.65) 235.75,62.06 235.65,61.96 235.27,61.96 235.12,62.11 235.12,63.01 236.29,64.18 239.1,64.18 239.29,64 241.28,64 243.52,61.76 243.52,60.75 244.57,59.7 244.57,54.67 245.52,53.72 245.8,53.72 246.97,52.55 246.97,46.98 247.13,46.83 247.13,44.08 247.36,43.85 247.36,41.42 247.85,40.93 247.85,38.7 247.98,38.57 247.98,36.15 247.28,35.45 v1(247.28,34.81) ; v1(152.72,63.62) 153.25,63.62 v2(153.4,63.46)
CLKDET#: length 13
  TOP w0.076: v3(141.01,80.05) 140.63,80.43 139.81,80.43 T7149.1
  BOTTOM w0.076: v3(141.01,80.05) 141.01,79.85 140.03,78.87 138.53,78.87 138.11,78.44 135.23,78.44 134.53,79.15 134.14,79.15 133.39,79.9 133.39,80.68 133.2,80.87 133.2,81.21 133.21,81.23 133.21,81.4 UC1.AY8
CLKREQ_PCIE#0: length 171.8
  TOP w0.076: v3(131.98,84.17) 132.38,83.78 132.38,82.65 136.3,78.73 140.88,78.73
  TOP w0.108: 140.88,78.73 140.97,78.82 142.69,78.82 143.31,78.21 148.03,78.21 148.77,78.95 155.44,78.95 155.81,78.58 RC585.2
  IN1 w0.076: 133.43,81.58 132.36,82.65 132.36,83.79 v3(131.98,84.17) ; 136.14,78.88 138.32,76.7 141.16,76.7
  IN1 w0.089: 133.43,81.58 133.44,81.58 136.14,78.88 ; v1(154.62,89.9) 155.41,89.9 156.67,88.64 156.67,82.25 156.17,81.74 155.4,81.74 153.7,80.05 152.48,80.05 151.9,79.46 150.05,79.46 148.37,77.79 143.19,77.79 142.1,76.7 141.16,76.7
  IN3 w0.089: v1(130.11,143.24) 130.94,142.42 133.1,142.42 134.05,141.47 134.05,140.92 140.47,134.5 147.06,134.5 147.56,134 156.85,134 157.54,133.31 157.54,131.43 156.57,130.46 155.86,130.46 152.66,127.26 152.66,120.84 154.99,118.51 154.99,112.37 153.5,110.88 153.5,99.74 152.28,98.52 152.28,92.82 152.68,92.42 152.68,90.95 153.26,90.38 153.64,90.38 154.11,89.9 v1(154.62,89.9)
  BOTTOM w0.076: UC1.AR10 132.31,84.5 132.07,84.26 v3(131.98,84.17)
  BOTTOM w0.108: v1(130.11,143.24) 129.19,144.16 126.65,144.16 122.24,148.58 117.31,148.58 117.03,148.3 117.03,146.04 117.43,145.63 117.43,145.05 v2(117.82,144.67) 118.2,144.28 JGFX1.55
CLKREQ_PCIE#1: length 349.7
  TOP w0.076: 140.96,80.91 140.4,80.91 140.28,80.8 137.84,80.8 137.12,80.07 136.76,80.07 135.02,81.82 135.02,81.99 134.17,82.83 134.17,83.17 v3(133.81,83.53)
  TOP w0.108: RC47.2 155.99,82.95 152.24,82.95 151.67,82.38 150.77,82.38 150.03,83.12 v5(150.03,83.6) 150.03,84.21 146.98,87.26 143.76,87.26 141.41,84.91 141.41,81.37 140.96,80.91
  IN3 w0.089: v1(27.62,124.93) 28.1,124.45 28.1,116.65 29.98,114.77 33.32,114.77 33.68,114.41 40.37,114.41 44.25,118.29 44.99,118.29 46.29,119.59 47.71,119.59 50.44,122.31 50.91,122.31 52.28,123.69 57.01,123.69 57.56,124.24 61.81,124.24 62.14,124.24 66.71,128.82 66.71,128.82 66.78,128.89 66.78,136.66 70.22,140.09 73.42,140.09 74.89,141.57 77.33,141.57 78.74,142.98 85.16,142.98 85.93,142.22 93.47,142.22 v1(96.99,145.73) ; v3(133.81,83.53) 133.41,83.13 133.41,81.04 139.38,75.07 139.38,74.92 140.5,73.79 142.71,73.79 142.94,73.57 142.94,72.26 143.01,72.18 147.78,72.18 148.39,71.57 151,71.57 151.36,71.93 152.68,71.93 152.91,72.17 156.51,72.17 157.39,71.29 157.39,69.52 160.25,66.66 168.45,66.66 169.05,67.27 169.05,68.52 v1(169.86,69.33)
  IN4 w0.089: v1(96.99,145.73) 98.04,144.69 114.61,144.69 117.31,147.39 124.16,147.39 125.87,145.68 132.48,145.68 133.45,144.72 133.95,144.72 136.28,142.39 136.28,142.2 139.7,138.78 141.88,138.78 142.56,139.45 143.09,139.45 144.17,138.37 147.56,138.37 147.84,138.09 151.11,138.09 152.69,136.51 154.78,136.51 157.88,133.41 157.88,131.32 159.68,129.53 159.68,127.64 162.63,124.69 162.63,124.11 163.18,123.55 164.75,123.55 169.4,118.9 171.14,118.9 175.15,114.89 175.15,113.68 177.36,111.47 179.95,111.47 181.75,109.67 183.12,109.67 184.97,107.81 184.97,106.8 187.01,104.76 187.01,80.32 187.27,80.06 187.27,75.44 186.04,74.22 185.47,74.22 181.29,70.04 181.29,68.19 v1(182.18,67.3)
  BOTTOM w0.108: v1(182.18,67.3) 178.85,67.3 176.44,69.71 174.94,69.71 174.56,69.33 v1(169.86,69.33) ; UC1.AT7 133.95,83.53 v3(133.81,83.53) ; v1(27.62,124.93) 26.71,124.02 JWLAN1.53
CLKREQ_PCIE#2: length 180.2
  TOP w0.076: 141.16,79.23 140.99,79.23 140.98,79.23 139.83,79.23 139.63,79.03 136.23,79.03 132.54,82.72 132.54,83.17 v3(132.9,83.53)
  TOP w0.108: RC50.2 153.41,79.41 v1(153.4,79.42) 153.34,79.36 148.6,79.36 147.86,78.62 143.48,78.62 142.86,79.23 141.16,79.23 ; v2(104.27,138.42) v1(103.68,137.83)
  IN1 w0.089: v1(168.97,76.44) 169.75,77.22 169.75,80.11 168.21,81.65 168.21,88.97 168.74,89.5 168.74,92.8 167.97,93.57 167.97,96.04 169.85,97.92 169.85,100.99 168.66,102.18 168.66,102.56 168.66,104.07 168.37,104.36 168.07,104.36 167.81,104.62 167.81,116.65 154.94,129.52 154.94,129.52 151.64,132.82 151.64,135.23 150.21,136.65 144.73,136.65 144.23,137.15 141.75,137.15 140.91,137.99 139.21,137.99 138.62,138.59 138.4,138.81 138.4,140.13 134.37,144.15 133.01,144.15 132.44,144.72 125.07,144.72 124.97,144.83 106.12,144.83 103.8,142.5 103.8,142.4 104.44,141.76 104.44,141.2 105.55,140.09 105.55,139.07 104.79,138.32 104.78,138.32 104.62,138.15 104,138.15 v1(103.68,137.83)
  IN3 w0.089: v1(153.4,79.42) 153.65,79.42 156.52,76.55 158.25,76.55 158.98,75.82 166.44,75.82 166.66,76.04 167.38,76.04 167.78,76.44 v1(168.97,76.44)
  BOTTOM w0.108: JWWAN1.52 102.4,134.33 103.68,135.61 103.68,137.83 v1(103.68,137.83) ; v3(132.9,83.53) 133.03,83.53 UC1.AT8
CLKREQ_PCIE#3: length 99.7
  TOP w0.076: 140.9,78.5 136.18,78.5 132.4,82.28 132.06,82.28 131.63,82.72 131.63,83.17 v3(131.98,83.53)
  TOP w0.108: 140.9,78.5 140.99,78.41 142.52,78.41 143.13,77.79 148.2,77.79 148.94,78.53 155.25,78.53 155.71,78.07 156.36,78.07 RC59.2
  IN3 w0.089: v1(163.26,44.79) 162.71,44.79 159.43,48.06 159.43,48.83 156.82,51.45 155,51.45 154.77,51.69 154.77,51.96 151.86,54.86 148.02,54.86 v1(146.33,56.55)
  IN4 w0.089: v1(146.33,56.55) 145.75,57.14 145.7,57.14 145.49,57.35 141.74,57.35 140.31,58.78 140.31,62.82 137.62,65.51 137.62,66.8 138.15,67.34 138.92,67.34 140.85,69.27 140.85,72.56 140.22,73.19 140.22,74.62 138.87,75.96 138.87,76.29 132.95,82.21 132.13,82.21 131.62,82.72 131.62,83.16 v3(131.98,83.53)
  BOTTOM w0.076: v3(131.98,83.53) 132.08,83.62 132.2,83.75 132.31,83.85 UC1.AT10
  BOTTOM w0.108: v1(163.26,44.79) 161.7,46.34 160.97,46.34 159.9,47.41 v2(159.9,47.61) 159.17,48.35 JSTRG1.34
CLKREQ_PCIE#4: length 165.9
  TOP w0.076: 141.16,79.65 141.04,79.53 139.19,79.53 138.92,79.79 137.89,79.79 137.63,79.53 136.24,79.53 v3(132.9,82.87)
  TOP w0.108: 141.16,79.65 143.04,79.65 143.65,79.03 147.69,79.03 148.43,79.77 152.58,79.77 152.91,80.1 153.29,80.1 153.55,79.84 153.57,79.84 156.34,79.84 156.65,80.15 RC51.2 ; R169.1 138.46,128.15 137.83,128.15 137.58,128.41 137.58,130.63 v2(137.92,130.97) v1(136.79,132.09)
  IN3 w0.089: v3(132.9,82.87) 133.28,83.25 133.28,86.35 133.67,86.73 135.06,86.73 138.49,83.3 140.53,83.3 141.7,82.13 141.7,81.58 143.91,79.38 147.06,79.38 150.01,82.32 152.62,82.32 153.25,81.69 154.7,81.69 156.35,80.04 156.35,79.39 157.39,78.35 158.84,78.35 159.19,78.7 166.45,78.7 168.72,80.97 176.93,80.97 v1(178.62,82.67)
  IN4 w0.089: v1(136.79,132.09) 137.06,132.36 141.82,132.36 142.76,131.41 144.99,131.41 145.45,130.95 145.45,130.38 145.95,129.88 150.13,129.88 154.68,125.34 155,125.34 155.85,124.49 155.85,122.95 160.56,118.24 162.19,118.24 175.37,105.06 175.37,98.21 176.41,97.17 176.41,85.56 178.03,83.94 178.03,83.26 v1(178.62,82.67)
  BOTTOM w0.108: v3(132.9,82.87) 133.02,82.87 UC1.AU8
CLKREQ_PCIE#5: length 93
  TOP w0.076: v3(133.81,82.87) 133.81,82.19 136.21,79.79 137.25,79.79 138.09,80.63 141.16,80.63
  TOP w0.108: 141.16,80.63 142.63,80.63 143.76,79.5 147.57,79.5 148.26,80.19 152.41,80.19 152.74,80.52 153.46,80.52 153.73,80.25 155.73,80.25 156.25,80.77 156.25,81.03 RC190.2 ; C9886.1 173.1,65.62 173.29,65.62 v1(174.28,64.63)
  IN3 w0.089: v3(133.81,82.87) 133.81,81.12 140.72,74.21 143.39,74.21 144.22,73.38 149.59,73.38 150.14,72.82 150.14,72.81 150.63,72.33 152.51,72.33 152.75,72.56 156.72,72.56 157.82,71.46 157.82,69.81 160.58,67.06 166.11,67.06 167.5,68.44 168.08,68.44 169.48,69.84 169.99,69.84 170.72,69.1 v1(170.72,68.44)
  BOTTOM w0.108: JEPC1.12 179.13,60.57 175.07,64.63 v1(174.28,64.63) 173.29,65.62 173.29,67.86 v2(173.01,68.14) 172.71,68.44 v1(170.72,68.44) ; UC1.AU7 133.94,82.87 v3(133.81,82.87)
CLKRUN#: length 205.5
  TOP w0.108: U6202.15 260.72,37.53 v1(260.59,37.66) ; U37.B20 264.57,50.58 264.36,50.79 v1(264.35,50.79) ; v1(244.82,61.23) 243.7,61.23 242.71,60.24 241.17,60.24 241.03,60.38 U38.A32
  IN3 w0.089: v1(150.58,80.77) 151.17,80.18 153.95,80.18 156.57,77.56 159.31,77.56 159.68,77.93 160.86,77.93 161.66,77.13 162.84,77.13 163.64,77.93 166.77,77.93 168.81,79.97 172.67,79.97 183.93,68.7 183.93,65.58 186.3,63.21 189.73,63.21 190.74,62.2 190.74,61.81 192.29,60.26 194.5,60.26 195.6,59.16 203.1,59.16 204.02,60.08 205.45,60.08 206.34,60.97 207.2,60.97 208.82,62.59 214.13,62.59 214.99,63.45 215.94,63.45 216.61,64.11 223.2,64.11 223.98,64.9 230.76,64.9 231.02,65.16 231.02,65.89 231.87,66.73 233.07,66.73 233.34,67 240.62,67 244.03,63.59 244.03,62.02 v1(244.82,61.23) 246.98,61.23 247.28,61.53 251.29,61.53 251.57,61.81 268.84,61.81 269.49,61.16 269.49,56.31 268.92,55.74 268.92,52 266.85,49.93 265.2,49.93 v1(264.35,50.79)
  IN4 w0.089: v1(260.59,37.66) 260.59,38.49 261.31,39.21 261.31,42.31 263.22,44.22 263.22,44.78 263.73,45.28 264.05,45.28 265.05,46.28 265.05,50.08 v1(264.35,50.79)
  BOTTOM w0.076: UC1.AW11 131.67,81.89 131.99,81.57 131.99,79.53 132.72,78.8 134.65,78.8 135.17,78.28 138.18,78.28 138.6,78.7 140.37,78.7 140.86,79.19 141.16,79.19
  BOTTOM w0.108: v2(260.2,38.16) 260.2,38.05 v1(260.59,37.66) ; 141.16,79.19 142.02,79.19 143.24,77.97 148.52,77.97 149.41,78.86 149.41,80.84 149.74,81.17 150.18,81.17 v1(150.58,80.77) 151.04,81.23 151.43,81.23 151.52,81.14 RC27.1
CLOCKI: length 5.1
  TOP w0.108: U6202.1 267.72,37.19 268.46,37.94 v2(268.46,38.04) 268.46,38.42 267.78,39.1 266.96,39.1 266.81,39.26 C9433.1 R9388.2
CLOCKI_R: length 4.6
  TOP w0.108: OCS4801.3 265.48,43.33 264.53,42.38 v2(264.53,40.22) 264.62,40.13 R9388.1
COEX1: length 105.2
  TOP w0.108: v1(102.2,137.85) 102.2,138.43 v2(102.45,138.67)
  IN1 w0.089: v1(102.2,137.85) 100.89,139.17 100.45,139.17 99.02,140.6 87.5,140.6 86.98,140.08 75.15,140.08 67.47,132.4 67.47,129.58 64.07,126.18 64.07,124.82 56.46,117.21 54.48,117.21 53.29,116.02 48.62,116.02 45.96,113.36 33.65,113.36 33.26,112.97 30.92,112.97 28.36,115.52 28.36,124.15 v1(29.47,125.27)
  BOTTOM w0.108: v1(102.2,137.85) 101.68,137.33 JWWAN1.64 ; JWLAN1.48 v1(29.47,125.27)
COEX2: length 108
  TOP w0.108: v2(102.8,134.74) 102.2,135.34 v1(102.2,137.16)
  IN1 w0.089: v1(102.2,137.16) 98.94,140.42 87.57,140.42 87.05,139.9 75.38,139.9 67.73,132.25 67.73,129.58 64.25,126.1 64.25,124.75 56.53,117.03 56.39,117.03 56.39,117.03 54.55,117.03 53.36,115.84 48.69,115.84 46.03,113.18 33.72,113.18 33.33,112.79 30.84,112.79 28.18,115.45 28.18,124.61 v1(29.45,125.87)
  BOTTOM w0.108: JWLAN1.46 29.56,125.77 v1(29.45,125.87) ; JWWAN1.62 101.88,136.83 102.22,137.16 v1(102.2,137.16)
COEX3: length 108.6
  TOP w0.108: v2(102.8,136.51) v1(102.8,137.15)
  IN1 w0.089: v1(102.8,137.15) 102.42,136.76 102.03,136.76 98.6,140.2 87.6,140.2 87.12,139.72 75.56,139.72 68.03,132.19 68.03,129.64 64.45,126.06 64.45,124.7 55.42,115.66 48.77,115.66 46.11,113 33.79,113 33.4,112.61 30.77,112.61 28.01,115.37 28.01,115.52 28.01,124.75 28.02,124.76 28.02,125.06 v1(29.45,126.48)
  BOTTOM w0.108: JWLAN1.44 29.67,126.27 v1(29.45,126.48) ; v1(102.8,137.15) 102.8,137.1 102.03,136.33 JWWAN1.60
CONTACTLESS_DET#: length 110.2
  IN1 w0.089: v1(146.49,91.68) 146.49,92.32 147.38,93.21 147.38,93.34 149.03,94.98 155.18,94.98 157.52,97.32 157.52,98.64 158.05,99.18 v1(159.37,99.18) ; v1(166.48,91.28) 165.53,90.33 165.53,67.82 168.34,65.01 170.3,65.01 171.21,64.1 171.21,45.3 v1(171.89,44.62)
  IN3 w0.089: v1(166.48,91.28) 166.13,90.93 163.83,90.93 161.07,93.69 161.07,96.44 159.37,98.13 v1(159.37,99.18)
  IN4 w0.076: 141.16,92.7 140.32,93.54 132.62,93.54 v3(132.27,93.18)
  IN4 w0.089: 141.16,92.7 141.64,92.22 146.21,92.22 146.49,91.94 v1(146.49,91.68)
  BOTTOM w0.076: UC1.W11 132.27,93 v3(132.27,93.18)
  BOTTOM w0.108: v1(171.89,44.62) 172.95,45.67 176.78,45.67 177.48,44.97 177.48,42.89 v2(177.43,42.84) 177.03,42.44 176.66,42.44 175.69,41.47 JSEC1.23 ; RC468.1 146.95,91.68 v1(146.49,91.68)
CORE_VID0: length 74.5
  TOP w0.108: v2(161.61,101.28) 162.69,100.2 v1(162.86,100.2)
  IN1 w0.076: 140.67,74.79 139.83,75.63 139.14,75.63 133.36,81.41 132.22,81.41 131.63,82 131.63,84.92 v3(131.07,85.48)
  IN1 w0.089: v1(162.86,100.2) 162.42,99.76 162.42,97.94 160.87,96.39 160.87,95.39 160.5,95.02 160.5,95.02 160.27,94.79 160.27,93.82 161.62,92.46 161.62,85.67 161.39,85.44 159.85,85.44 158.71,86.58 157.88,86.58 157.07,85.77 157.07,82.08 154.8,79.82 154.8,76.95 153.32,75.48 149.85,75.48 148.75,74.38 141.08,74.38 140.67,74.79
  IN3 w0.089: v1(162.86,100.2) 162.86,102.8 164.29,104.23 164.83,104.23 165.8,103.26 167.83,103.26 v1(168.21,102.88)
  BOTTOM w0.076: UC1.AN11 131.21,85.48 v3(131.07,85.48)
  BOTTOM w0.108: v1(168.21,102.88) PR5614.1
CORE_VID1: length 71
  TOP w0.108: v1(167.19,88.51) 166.97,88.51 v2(166.23,87.77) 163.66,85.2 161.75,85.2 v1(161.35,84.8)
  IN1 w0.076: v3(130.16,85.48) 130.62,85.03 130.62,82.55 132.58,80.58 133.72,80.58 139,75.3 139.51,75.3 140.02,74.79
  IN1 w0.089: v1(161.35,84.8) 158.3,84.8 157.42,83.92 157.42,81.94 155.15,79.67 155.15,76.8 153.42,75.07 149.97,75.07 148.87,73.97 140.83,73.97 140.02,74.79 ; v1(168.2,103.96) 167.81,103.57 167.81,100.77 169.16,99.42 169.16,97.79 167.57,96.21 167.57,93.41 168.35,92.63 168.35,89.66 v1(167.19,88.51)
  BOTTOM w0.076: UC1.AN13 130.29,85.48 v3(130.16,85.48)
  BOTTOM w0.108: v1(168.2,103.96) 167.99,103.75 PR5613.1
CPU_DP1_CTRL_CLK: length 153.9
  TOP w0.102: v1(80.79,124.77) 80.64,124.62 80.64,124.59 79.92,123.87 79.92,122.19 80.71,121.4 80.71,120.45 81.26,119.9 82.08,119.9 82.64,119.34 82.64,118.41 87.74,113.31 87.74,108.34 89.54,106.54 90.1,106.54 v2(90.26,106.39) 91.02,105.63 91.02,103.87 90.04,102.9 v1(89.21,102.9) ; Q122.1 v1(21.51,122.78)
  IN3 w0.089: v1(62.71,120.63) 59.91,120.63 57.2,117.92 50.82,117.92 47.75,114.85 46.21,114.85 42.48,111.12 35.55,111.12 34.96,110.53 28.61,110.53 28.02,111.12 27.01,111.12 24.49,113.65 21.87,113.65 20.78,114.73 20.78,122.51 21.05,122.78 v1(21.51,122.78)
  IN4 w0.089: v3(130.89,96.25) 130.69,96.45 130.69,97.04 130.29,97.44 125.43,97.44 124.9,97.97 121.17,97.97 121.03,97.84 102.36,97.84 102.17,97.64 99.05,97.64 96.68,100.01 94.89,100.01 94.65,100.26 94.65,100.75 94.18,101.23 93.89,101.23 93.73,101.38 90.99,101.38 90.33,102.05 89.66,102.05 89.21,102.5 v1(89.21,102.9) ; v1(80.79,124.77) 80.79,124.3 79.86,123.37 66.75,123.37 64.02,120.63 v1(62.71,120.63)
  BOTTOM w0.076: v3(130.89,96.25) 130.89,96.41 UC1.L13
  BOTTOM w0.102: R9677.2 88.59,103.52 v1(89.21,102.9)
CPU_DP1_CTRL_DATA: length 159
  TOP w0.102: v1(80.16,124.79) 79.44,124.07 79.44,121.99 80.23,121.2 80.23,120.25 81.06,119.42 81.46,119.42 81.88,119.42 82.15,119.14 82.15,118.21 87.26,113.11 87.26,108.14 89.34,106.06 89.9,106.06 90.52,105.44 90.52,104.06 89.9,103.44 89.05,103.44 v1(88.5,102.9) ; Q122.4 18.86,124.08 19.06,123.88 v1(19.62,123.88)
  IN3 w0.089: v1(63.11,121.23) 62.99,121.1 59.71,121.1 57,118.39 50.62,118.39 47.55,115.32 46.02,115.32 45.6,114.9 44.86,114.9 41.54,111.59 35.36,111.59 34.77,111 28.81,111 28.22,111.59 27.21,111.59 24.68,114.12 22.06,114.12 21.25,114.93 21.25,121.41 21.98,122.14 21.98,122.88 20.78,124.08 19.82,124.08 v1(19.62,123.88)
  IN4 w0.089: v3(131.54,96.25) 131.23,95.94 131.09,95.94 131.03,95.89 130.74,95.89 130.49,96.14 130.49,96.99 130.22,97.26 125.36,97.26 124.82,97.8 121.32,97.8 121.18,97.65 102.42,97.65 102.24,97.47 98.98,97.47 96.61,99.84 94.82,99.84 94.47,100.18 94.47,100.63 94.22,100.88 90.84,100.88 90.14,101.58 89.47,101.58 88.74,102.3 88.74,102.66 v1(88.5,102.9) ; v1(63.11,121.23) 63.95,121.23 66.56,123.84 79.54,123.84 80.16,124.46 v1(80.16,124.79)
  BOTTOM w0.076: UC1.L12 131.21,96.57 v3(131.54,96.25)
  BOTTOM w0.102: v1(88.5,102.9) 87.91,102.9 R9678.2 ; v1(19.62,123.88) 20.18,124.44 v2(20.18,125.16)
CPU_DP1_HPD: length 221.2
  TOP w0.108: v1(17.33,119.75) 17.33,120.13 17.2,120.26 R475.1 ; v3(133.49,96.25) 133.87,95.87 RC480.1 ; QZ22.1 21.38,119.86 21.52,119.72 21.52,119.39 21.37,119.24 v1(20.38,119.24)
  IN1 w0.089: v1(17.33,119.75) 17.87,120.28 19.52,120.28 20.38,119.42 v1(20.38,119.24) 20.38,119.08 27.21,112.26 33.69,112.26 34.08,112.65 46.35,112.65 46.8,113.09 47.92,113.09 49.77,114.95 55.21,114.95 64.97,124.71 64.97,126.04 68.64,129.71 68.64,131.84 76.1,139.3 90.88,139.3 92.26,137.91 95.06,137.91 96.45,136.51 96.45,135.91 96.86,135.5 99.56,135.5 100.36,136.3 102.84,136.3 104.3,137.76 104.79,137.76 105.94,138.91 105.94,142.98 106.71,143.75 124.36,143.75 124.47,143.64 131.86,143.64 132.44,143.07 133.92,143.07 137.32,139.68 137.32,138.32 139.56,136.07 143.22,136.07 143.85,135.45 147.71,135.45 148.35,134.81 149.23,134.81 150.35,133.69 150.35,131.23 v1(150.79,130.8)
  IN3 w0.076: v3(133.49,96.25) 134.13,96.89 135.08,96.89 138.85,100.65 138.85,102.09 138.42,102.52 138.42,104.88 139.69,106.16
  IN3 w0.089: v1(143.83,114.16) 144.28,113.7 144.28,112.56 143.47,111.75 143.47,110.81 141.62,108.95 141.62,108.08 139.69,106.16
  BOTTOM w0.108: v1(143.83,114.16) 141.94,116.04 141.94,120.12 143.09,121.27 143.82,121.27 144.07,121.53 149.36,121.53 150.25,122.41 150.25,124.6 152.47,126.82 152.47,128.53 150.79,130.21 v1(150.79,130.8) ; v1(20.38,119.24) 20.56,119.42 v2(20.56,120) ; UC1.L9 133.16,96.58 133.49,96.26 v3(133.49,96.25)
CPU_DP1_N0: length 110.5
  TOP w0.102: C272.2 22.19,110.14 23.39,110.14 24.04,110.79 24.04,111.14 v1(23.81,111.37)
  IN4 w0.102: v1(23.81,111.37) 24.24,110.94 24.24,110.6 24.69,110.15 26.05,110.15 28.41,107.79 49.83,107.79 55.03,102.58 55.03,99.49 55.88,98.64 57.66,98.64 57.99,98.32 68.8,98.32 69.74,99.26 69.74,107.08 70.15,107.48 71.9,107.48 73.68,109.26 76.43,109.26 77.04,108.65 83.2,108.65 84.09,109.54 99.25,109.54 102.32,106.46 103.41,106.46 105.22,104.66 105.22,103.46 106.75,101.93 106.75,100.38 106.67,100.31 v3(106.43,100.31)
  BOTTOM w0.102: v3(106.43,100.31) 106.6,100.31 106.74,100.45 106.95,100.45 107.05,100.35 107.05,100.2 UC1.E55
CPU_DP1_N1: length 113.7
  TOP w0.102: v1(22.54,112.76) 22.33,112.55 22.19,112.55 C270.2
  IN4 w0.102: v1(22.54,112.76) 22.19,112.76 22.09,112.67 22.09,112.43 21.99,112.33 21.88,112.33 21.37,111.82 21.37,107.23 24.22,104.38 28,104.38 28.79,105.17 40.36,105.17 40.58,105.39 40.58,106.03 40.73,106.19 41.84,106.19 42.03,105.99 42.03,105.39 42.25,105.17 48.14,105.17 53.45,99.85 53.45,98.35 55.68,96.13 57.34,96.13 57.53,96.32 69.96,96.32 71.31,97.67 71.31,105.57 71.85,106.11 72.54,106.11 73.88,107.46 76.05,107.46 76.23,107.28 86.22,107.28 86.73,107.79 97.47,107.79 100.21,105.04 102.75,105.04 103.24,104.56 103.24,103.03 104.84,101.43 104.84,100.32 104.77,100.25 v3(104.53,100.25)
  BOTTOM w0.089: UC1.E58 104.79,99.99 v3(104.53,100.25)
CPU_DP1_N2: length 107.2
  TOP w0.102: v1(22.95,117.72) 22.87,117.64 22.31,117.64 C209.2
  IN4 w0.102: v3(107.29,99.6) 107.41,99.6 107.55,99.74 107.55,100.07 108.14,100.66 108.14,101.78 106.13,103.79 106.13,104.71 102.53,108.32 102.53,108.79 101.09,110.22 83.28,110.22 82.39,109.34 77.4,109.34 76.8,109.94 73.12,109.94 71.42,108.24 68.55,108.24 68.13,107.83 68.13,105.49 66.74,104.1 63.54,104.1 61.45,106.2 52.57,106.2 50.3,108.47 28.73,108.47 23.68,113.52 23.68,115.02 22.08,116.62 22.08,117.01 22.36,117.29 22.43,117.29 22.55,117.4 22.55,117.62 22.65,117.72 v1(22.95,117.72)
  BOTTOM w0.089: v3(107.29,99.6) 107.49,99.6 UC1.F53
CPU_DP1_N3: length 112.1
  TOP w0.102: v1(22.54,115.18) 22.41,115.05 22.23,115.05 C191.2
  IN4 w0.102: v1(22.54,115.18) 22.08,114.72 22.08,114.08 23.53,112.63 23.53,112.01 23.07,111.55 23.07,109.94 23.99,109.03 26.17,109.03 28.1,107.1 49.16,107.1 54.27,101.99 54.27,98.59 55.23,97.63 69.16,97.63 70.62,99.09 70.62,105.86 71.56,106.8 72.25,106.8 73.6,108.14 76.38,108.14 76.56,107.96 85.93,107.96 86.44,108.47 97.9,108.47 98.74,107.63 99.75,107.63 101.68,105.7 103.08,105.7 104.2,104.59 104.2,103.11 105.85,101.46 105.85,100 v3(105.47,99.61)
  BOTTOM w0.089: UC1.F56 105.74,99.34 v3(105.47,99.61)
CPU_DP1_P0: length 110.6
  TOP w0.102: v6(22.86,109.92) 22.86,109.93 ; 22.86,109.93 22.19,109.93 C271.2 ; 22.86,109.93 23.47,109.93 24.24,110.7 24.24,111.17 v1(24.44,111.37)
  IN4 w0.102: v3(106.43,99.66) 106.43,99.74 106.95,100.26 106.95,102.02 105.42,103.54 105.42,104.74 103.49,106.67 102.41,106.67 99.33,109.74 84.01,109.74 83.12,108.85 77.13,108.85 76.52,109.46 73.59,109.46 71.82,107.68 70.06,107.68 69.54,107.16 69.54,99.35 68.71,98.52 58.08,98.52 57.75,98.84 55.97,98.84 55.24,99.58 55.24,102.66 49.91,107.99 28.49,107.99 26.13,110.35 24.77,110.35 24.44,110.68 v1(24.44,111.37)
  BOTTOM w0.102: v3(106.43,99.66) 106.56,99.53 106.65,99.53 UC1.F55
CPU_DP1_P1: length 113.7
  TOP w0.102: C269.2 22.19,112.35 22.32,112.35 v1(22.54,112.13)
  IN4 w0.102: v3(104.53,99.64) 105.04,100.16 105.04,101.51 103.44,103.11 103.44,104.64 102.84,105.25 100.3,105.25 97.56,107.99 86.64,107.99 86.13,107.48 76.31,107.48 76.13,107.66 73.8,107.66 72.45,106.31 71.77,106.31 71.11,105.65 71.11,97.75 69.88,96.53 57.45,96.53 57.25,96.33 55.76,96.33 53.66,98.44 53.66,99.94 48.22,105.37 42.33,105.37 42.23,105.47 42.23,106.08 41.92,106.39 40.65,106.39 40.38,106.12 40.38,105.47 40.28,105.37 28.7,105.37 27.92,104.59 24.3,104.59 21.58,107.31 21.58,111.74 21.96,112.13 v1(22.54,112.13)
  BOTTOM w0.102: v3(104.53,99.64) 104.87,99.64 105.01,99.5 UC1.F58
CPU_DP1_P2: length 107.2
  TOP w0.102: C199.2 22.07,117.43 22.6,117.43 v1(22.95,117.08)
  IN4 w0.102: v1(22.95,117.08) 22.45,117.08 22.29,116.92 22.29,116.7 23.89,115.1 23.89,113.6 28.81,108.67 50.38,108.67 52.66,106.4 61.53,106.4 63.62,104.31 66.66,104.31 67.93,105.58 67.93,107.91 68.46,108.45 71.33,108.45 73.04,110.15 76.88,110.15 77.49,109.54 82.31,109.54 83.2,110.43 101.18,110.43 102.73,108.88 102.73,108.4 106.34,104.8 106.34,103.87 108.34,101.87 108.34,100.57 107.76,99.99 107.76,99.49 v3(107.29,99.03)
  BOTTOM w0.089: UC1.G53 107.64,98.69 v3(107.29,99.03)
CPU_DP1_P3: length 112.1
  TOP w0.102: C103.2 22.06,114.76 22.32,114.76 v1(22.54,114.54)
  IN4 w0.102: v1(22.54,114.54) 22.28,114.29 22.28,114.16 23.73,112.71 23.73,111.93 23.28,111.47 23.28,110.03 24.07,109.23 26.26,109.23 28.19,107.3 49.24,107.3 54.47,102.08 54.47,98.68 55.31,97.83 69.07,97.83 70.42,99.18 70.42,105.94 71.48,107 72.17,107 73.51,108.34 76.46,108.34 76.64,108.17 85.85,108.17 86.36,108.67 97.99,108.67 98.83,107.84 99.83,107.84 101.76,105.91 103.17,105.91 104.4,104.67 104.4,103.2 106.06,101.55 106.06,99.92 105.85,99.71 105.85,99.29 105.76,99.2 105.63,99.2 v3(105.47,99.03)
  BOTTOM w0.089: v3(105.47,99.03) 105.81,98.69 UC1.G56
CPU_DP2_CTRL_CLK: length 21
  TOP w0.108: v2(141.21,99.36) v3(140.54,98.69)
  IN4 w0.089: v3(140.54,98.69) 141.42,97.8 149.11,97.8 v1(149.54,97.37)
  BOTTOM w0.076: v3(140.54,98.69) 140.54,98.65 139.85,97.97 139.11,97.97 138.78,97.64 138.78,97.28 138.16,96.66 138.16,96.4 138.01,96.25 137.82,96.25 137.65,96.32 137.41,96.32 137.29,96.28 137.09,96.28 136.99,96.32 136.75,96.32 136.63,96.28 136.26,96.28 arc(136.09,96.25) 135.95,96.15 135.28,95.48 134.78,95.48 UC1.N7
  BOTTOM w0.108: R9679.2 151.62,96.94 150,96.94 149.57,97.37 v1(149.54,97.37)
CPU_DP2_CTRL_DATA: length 20.9
  IN4 w0.089: v3(141.09,98.72) 141.78,98.03 149.56,98.03 v1(150.23,97.36)
  BOTTOM w0.076: UC1.N8 134.3,95.31 135.35,95.31 135.58,95.54 136.36,95.54 136.56,95.74 136.56,95.97 arc(136.57,96.02) 136.6,96.06 136.65,96.12 136.77,96.15 136.96,96.15 137.06,96.12 137.31,96.12 137.44,96.15 137.62,96.15 137.78,96.08 138.08,96.08 138.33,96.33 138.33,96.55 138.95,97.17 138.95,97.57 139.18,97.8 139.99,97.8 140.51,98.32 140.7,98.32 v3(141.09,98.72)
  BOTTOM w0.108: R9680.2 151.09,97.63 v2(150.91,97.45) 150.83,97.36 v1(150.23,97.36)
CPU_DP2_HPD: length 180.3
  TOP w0.089: 85.82,134.86 85.82,134.37 U6.J1
  TOP w0.108: 85.82,134.86 85.82,135.03 85.45,135.4 85.45,135.8 84.28,136.97 84.19,136.97 83.55,137.61 83.55,141.47 v2(82.92,142.1) 82.64,142.38 v1(82.18,142.38)
  IN1 w0.089: v1(82.18,142.38) 82.19,142.39 84.36,142.39 84.98,141.76 97.76,141.76 98.65,142.66 102.28,142.66 105.63,146.01 114.21,146.01 115.15,146.95 124.63,146.95 125.68,145.9 132.97,145.9 133.54,145.33 134.86,145.33 140.38,139.81 143.07,139.81 143.92,138.96 144.23,138.96 144.46,138.72 145.2,138.72 145.56,138.37 150.17,138.37 152.82,135.72 152.82,133.31 154.88,131.26 158.27,131.26 159.95,129.58 159.95,126.32 162.99,123.28 163.95,123.28 167.08,120.15 167.08,119.07 168.73,117.42 168.99,117.16 168.99,105.76 169.86,104.89 169.86,102.86 170.24,102.48 171.26,102.48 171.45,102.29 171.45,97.84 v1(169.35,95.75)
  IN2 w0.089: v1(146.26,96.08) 147.27,95.07 157.88,95.07 158.36,95.55 159.62,95.55 160.04,95.14 162.11,95.14 162.34,94.91 168.26,94.91 169.1,95.75 v1(169.35,95.75)
  IN4 w0.089: v3(134.82,96.25) 135.18,95.89 136.89,95.89 137.75,96.76 141.51,96.76 141.88,97.13 146.42,97.13 146.65,96.9 146.65,96.47 v1(146.26,96.08)
  BOTTOM w0.108: RC156.1 146.84,96.66 v1(146.26,96.08) ; v3(134.82,96.25) 134.82,96.38 UC1.L7
CPU_DP2_N0: length 61.6
  TOP w0.102: C156.2 87.36,141.15 87.36,141.47 87.64,141.75 91.1,141.75 v6(91.11,141.77) 91.12,141.75 96.38,141.75 99.72,138.41 99.72,127.4 99.2,126.87 99.2,120.87 99.93,120.13 99.93,119.59 v1(100.1,119.43)
  BOTTOM w0.076: UC1.C50 109.54,101.62 109.62,101.7 109.68,101.7 109.73,101.75 109.81,101.96 109.81,102.15 109.77,102.27 109.77,102.52 109.82,102.65 109.82,103.39 110.06,103.63
  BOTTOM w0.102: 110.06,103.63 110.17,103.74 110.17,107.09 108.82,108.44 108.82,117.05 106.38,119.5 101.76,119.5 101.31,119.95 99.96,119.95 99.86,119.85 99.86,119.66 v1(100.1,119.43)
CPU_DP2_N0_C: length 7.5
  TOP w0.102: 87.34,135.78 v6(87.32,135.78) ; 87.34,135.78 87.34,134.7 87.59,134.45 87.59,134.36 87.59,133.45 U6.G2 ; 87.34,135.78 87.34,136.85 87.34,137.09 87.14,137.29 87.14,138.99 87.36,139.21 87.36,139.46 C156.1
CPU_DP2_N1: length 58
  TOP w0.102: v1(100.19,117.29) 100.06,117.41 100.06,117.95 98.84,119.16 98.84,119.6 98.61,119.83 98.61,120.42 98.36,120.67 98.36,127.42 99.04,128.1 99.04,132.87 ; 99.04,132.87 99.04,137.85 96.03,140.86 89.83,140.86 88.56,139.59 88.56,139.09 C158.2 ; 99.04,132.87 v6(99.05,132.87)
  BOTTOM w0.076: UC1.C52 108.21,101.77 108.15,101.96 108.15,102.15 108.18,102.27 108.18,102.52 108.15,102.61 108.15,102.87 108.32,103.04 108.32,103.18
  BOTTOM w0.102: 108.32,103.18 108.32,105.99 106.97,107.34 106.97,116.2 106.5,116.68 100.24,116.68 100.09,116.83 100.09,117.18 v1(100.19,117.29)
