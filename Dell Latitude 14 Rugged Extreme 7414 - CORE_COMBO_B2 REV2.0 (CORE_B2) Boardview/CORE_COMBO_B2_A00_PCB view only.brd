# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D59: length 71.5
  IN1 w0.089: v1(144.77,31.48) 144.36,31.88 144.36,33.02 144.5,33.15 144.89,33.15 145.02,33.28 145.02,33.47 144.89,33.6 144.5,33.6 144.36,33.73 144.36,33.91 144.5,34.04 144.89,34.04 145.02,34.17 145.02,34.36 144.89,34.49 144.5,34.49 144.36,34.62 144.36,37.48 146.16,39.28 146.16,40.88 146.03,41.01 145.94,41.01 145.81,41.14 145.81,41.33 145.94,41.46 146.03,41.46 146.16,41.59 146.16,42.36 146.06,42.46 145.83,42.46 145.73,42.56 145.73,42.76 145.83,42.86 146.06,42.86 146.18,42.98 146.18,43.13 146.06,43.24 145.86,43.24 145.73,43.37 145.73,43.9 145.83,44.01 146.06,44.01 146.16,44.11 146.16,44.36 146.06,44.46 145.78,44.46 145.65,44.59 145.65,44.82 145.78,44.95 146.06,44.95 146.16,45.05 146.16,45.66 146.04,45.78 145.5,45.78 145.35,45.93 145.35,46.11 145.48,46.24 146.01,46.24 146.14,46.37 146.14,46.6 146.01,46.72 145.5,46.72 145.24,46.98 145.24,48.3 145.22,48.32 145.22,48.32 143.49,50.05 143.49,53.62 134,63.11 134,74.78 133.81,74.97 133.21,74.97 131.99,76.19 131.99,77.85 130.96,78.87 130.96,79.24 130.03,80.18 129.06,80.18 128.02,81.22 127.25,81.22 126.05,82.43 126.05,83.07 v3(125.58,83.54)
  BOTTOM w0.108: JDIMM2.245 144.27,31.98 v1(144.77,31.48) ; UC1.AT21 125.73,83.54 v3(125.58,83.54)
DDR_B_D60: length 75
  TOP w0.076: v3(124.67,85.48) 124.52,85.48 124.09,85.92 v2(124.09,85.92)
  IN1 w0.076: 128.71,77 128.71,77.98 128.43,78.26 128.43,78.71 127.09,80.06 126.51,80.06 125.51,81.06 124.81,81.06 123.98,81.89 123.98,83.25 124.11,83.38 124.11,84.92 v3(124.67,85.48)
  IN1 w0.089: 128.71,77 130.44,75.27 130.44,74.84 131.56,73.72 131.56,62.1 141.05,52.62 141.05,46.83 141.36,46.51 141.36,43.98 141.91,43.43 141.91,39.64 140.08,37.81 140.08,36.07 140.06,36.05 140.06,30.32 139.93,30.19 139.18,30.19 139.05,30.06 139.05,29.88 139.19,29.74 139.61,29.74 139.71,29.64 139.71,29.42 139.58,29.3 139.18,29.3 139.05,29.17 139.05,28.99 139.19,28.85 139.83,28.85 140.22,28.46 140.22,27.42 140.47,27.17 v1(141.52,27.17)
  BOTTOM w0.108: UC1.AN22 124.81,85.48 v3(124.67,85.48) ; v1(141.52,27.17) 141.02,26.67 JDIMM2.232
DDR_B_D61: length 73.4
  IN1 w0.076: 130.92,74.79 130.87,74.84 130.87,75.43 129.69,76.61 129.69,77.24 128.6,78.33 128.6,78.78 127.15,80.23 126.58,80.23 125.57,81.24 124.87,81.24 124.15,81.96 124.15,83.18 124.29,83.32 124.29,84.44 v3(124.67,84.82)
  IN1 w0.089: v1(141.52,27.8) 141.26,27.55 140.78,27.55 140.63,27.7 140.63,28.69 140.36,28.95 140.36,35.93 140.39,35.95 140.39,36.99 140.92,37.53 140.92,37.66 140.71,37.87 140.71,38 140.84,38.12 140.96,38.12 141.18,37.91 141.3,37.91 141.43,38.04 141.43,38.16 141.21,38.37 141.21,38.5 141.34,38.62 141.47,38.62 141.68,38.41 141.8,38.41 141.98,38.59 141.98,38.74 141.9,38.82 141.9,38.9 142.04,39.04 142.19,39.04 142.25,38.98 142.37,38.98 142.91,39.52 142.91,41.16 142.27,41.8 142.27,48.17 141.36,49.09 141.36,52.74 131.87,62.23 131.87,73.84 130.92,74.79
  BOTTOM w0.108: v3(124.67,84.82) 124.8,84.82 UC1.AP22 ; v1(141.52,27.8) 142.02,27.3 JDIMM2.236
DDR_B_D62: length 72.6
  IN1 w0.089: v7(143.52,28.46) 143.8,28.46 144.28,28.94 144.71,28.94 145.35,29.58 145.35,38.04 146.77,39.46 146.77,46.49 145.55,47.72 145.55,48.43 145.53,48.45 145.53,48.45 143.8,50.18 143.8,53.75 134.31,63.24 134.31,74.81 133.97,75.15 133.32,75.15 132.17,76.3 132.17,77.92 131.14,78.95 131.14,79.32 130.1,80.36 129.14,80.36 128.09,81.4 127.32,81.4 126.22,82.5 126.22,83.15 125.96,83.41 125.96,84.46 v3(125.59,84.83)
  BOTTOM w0.108: v3(125.59,84.83) 125.72,84.83 UC1.AP21 ; JDIMM2.246 144.52,26.55 144.03,27.04 144.03,27.95 v7(143.52,28.46)
DDR_B_D63: length 73.1
  IN1 w0.089: v3(125.59,85.49) 126.14,84.94 126.14,83.61 129.21,80.54 130.17,80.54 131.32,79.39 131.32,79.02 132.37,77.97 132.37,76.34 133.39,75.32 134.17,75.32 134.61,74.89 134.61,74.13 134.61,63.37 144.1,53.88 144.1,50.31 145.83,48.58 145.83,48.57 145.85,48.55 145.85,47.9 147.08,46.67 147.08,39.18 145.65,37.76 145.65,29.38 144.89,28.61 144.66,28.61 144.11,28.06 144.11,27.32 144.25,27.17 v7(144.85,27.17)
  BOTTOM w0.108: v3(125.59,85.49) 125.73,85.49 UC1.AN21 ; v7(144.85,27.17) 145.52,26.51 JDIMM2.250
DDR_B_DQS0: length 74.8
  IN1 w0.076: 93.73,84.39 94.13,84.79 94.9,84.79 95.58,85.47 96.91,85.47 98.96,87.52 101.01,87.52 v3(101.36,87.87)
  IN1 w0.095: 93.73,84.39 92.64,83.3 92.64,81.53 93.75,80.42 93.75,57.6 93.21,57.06 93.21,51.92 92.84,51.56 92.84,49.63 91.95,48.73 91.95,48.22 89.95,46.23 89.95,41.71 89.4,41.16 89.4,38.06 89.32,37.98 89.32,30.31 89.48,30.14 89.84,30.14 90.08,29.9 90.08,29.34 89.84,29.1 88.6,29.1 88.46,28.96 88.46,28.66 88.6,28.52 89.39,28.52 89.62,28.28 89.62,27.9 89.32,27.6 89.32,27.45 v1(89.6,27.17)
  BOTTOM w0.076: v3(101.36,87.87) 101.12,88.11 UC1.AH65
  BOTTOM w0.108: v1(89.6,27.17) 89.37,26.94 89.37,26.25 89.52,26.1 JDIMM2.34
DDR_B_DQS1: length 82.3
  IN1 w0.095: v1(83.39,30.72) 83.28,30.72 82.75,31.26 82.75,32.86 82.98,33.09 84.16,33.09 84.35,33.28 84.35,33.84 84.22,33.97 82.54,33.97 82.25,34.26 82.25,35.3 82.52,35.56 84.22,35.56 84.36,35.7 84.36,36.14 84.12,36.38 83.61,36.38 83.37,36.63 83.37,45.45 87.46,49.54 87.46,51.83 87.81,52.19 87.81,54.83 88.43,55.45 88.43,60.02 90.03,61.62 90.03,73.38 89.3,74.12 89.3,79.28 88.9,79.67 88.9,88.26 91.8,91.15 93.61,91.15 93.79,90.97 v1(93.79,90.68)
  BOTTOM w0.076: 95.07,89.28 95.34,89.02 96.07,89.02 96.43,88.66 97.36,88.66 97.44,88.63 97.62,88.63 97.75,88.66 97.96,88.66 UC1.AG70
  BOTTOM w0.102: v1(93.79,90.68) 93.89,90.58 93.89,89.72 94.32,89.28 95.07,89.28
  BOTTOM w0.108: JDIMM2.13 84.27,31.37 83.79,30.89 83.56,30.89 v1(83.39,30.72)
DDR_B_DQS2: length 63.7
  IN1 w0.095: v3(100.9,84.18) 100.54,83.82 100.54,82.66 98.21,80.34 98.21,79.08 97.32,78.19 97.32,50.96 96.41,50.05 96.41,46.38 95.65,45.62 95.65,43.83 96.07,43.4 96.07,42.43 95.77,42.13 94.94,42.13 94.68,41.87 94.68,36.7 94.81,36.57 95.14,36.57 95.42,36.29 95.42,35.75 95.14,35.47 94.18,35.47 93.89,35.18 93.89,34.83 94,34.73 94.4,34.73 94.64,34.49 94.64,33.12 94.4,32.88 94.4,32.6 94.64,32.36 94.64,31.29 94.28,30.93 93.97,30.93 v1(93.77,30.72)
  BOTTOM w0.108: v3(100.9,84.18) 101.04,84.18 UC1.AR65 ; JDIMM2.55 94.77,32.37 94.62,32.22 94.62,31.26 94.33,30.97 94.01,30.97 v1(93.77,30.72)
DDR_B_DQS3: length 62.5
  IN1 w0.095: v1(100.15,27.1) 99.84,27.41 99.84,28.45 99.34,28.95 99.13,28.95 98.99,29.09 98.99,29.49 99.17,29.66 99.41,29.66 99.96,30.21 99.96,42.19 100.86,43.09 100.86,74.92 101.89,75.95 101.89,78.75 102.31,79.17 102.31,79.97 103.44,81.1 103.44,82.21 103.3,82.36 103.3,82.67 103.3,82.67 103.3,83.12 103.3,83.12 103.3,83.82 v3(103.66,84.18)
  BOTTOM w0.108: v1(100.15,27.1) 99.87,26.82 99.87,26.4 99.87,26.34 100.02,26.19 JDIMM2.76 ; UC1.AR60 103.78,84.18 v3(103.66,84.18)
DDR_B_DQS4: length 66.6
  IN1 w0.076: 116.09,81.29 116.07,81.31 116.07,83.82 115.91,83.98 115.68,83.98 v3(115.52,84.14)
  IN1 w0.095: 116.09,81.29 118.18,79.2 118.88,79.2 120.08,78.01 120.08,77.39 119.55,76.87 119.55,75.26 119.64,75.18 119.64,72.93 120,72.57 120,61.81 120.64,61.17 120.64,58.84 127.87,51.61 127.87,44.31 128.33,43.84 128.33,43.16 127.63,42.46 127.63,38.71 127.4,38.49 126.71,38.49 126.56,38.34 126.56,37.63 127.15,37.04 127.15,34.94 126.91,34.7 126.68,34.7 126.56,34.58 126.56,33.66 126.75,33.47 127.31,33.47 127.54,33.23 127.54,31.36 127.03,30.85 v1(126.93,30.85)
  BOTTOM w0.076: UC1.AR38 115.62,84.14 v3(115.52,84.14)
  BOTTOM w0.108: JDIMM2.179 127.77,32.44 128.05,32.16 128.05,31.1 127.8,30.85 v1(126.93,30.85)
DDR_B_DQS5: length 67.3
  IN1 w0.095: v3(119.18,84.17) 119.18,84.07 118.63,83.52 118.63,82.33 119.87,81.09 120.42,81.09 122.08,79.42 122.08,79.07 123,78.15 123,74.37 123.36,74.01 123.36,72.93 123.87,72.42 123.87,62.69 124.91,61.65 124.91,59.31 133.19,51.04 133.19,39 132.34,38.16 132.34,32.68 132.01,32.35 v1(132.01,27.8)
  BOTTOM w0.108: UC1.AR32 119.31,84.17 v3(119.18,84.17) ; v1(132.01,27.8) 132.44,27.38 132.77,27.38 133.02,27.13 JDIMM2.200
DDR_B_DQS6: length 68.9
  IN1 w0.076: v3(121.93,84.18) 122.3,83.81 122.3,82.64 122.9,82.04 122.9,81.53 124.46,79.97 125.2,79.97 125.8,79.38 125.8,79.14 126.36,78.58 126.81,78.13 126.81,77.95 126.79,77.93 126.79,77.81
  IN1 w0.095: 126.79,77.81 126.79,76.78 128.2,75.36 128.2,71.61 128.35,71.45 128.35,69.27 128.02,68.94 128.02,68.22 128.27,67.96 128.27,67.12 128.02,66.87 128.02,66.08 128.27,65.82 128.27,65.09 128.02,64.83 128.02,64.18 129.27,62.94 129.27,61.44 138.83,51.88 138.83,51.36 138.65,51.18 138.39,51.18 138.11,50.9 138.11,50.5 138.39,50.22 138.77,50.22 138.93,50.06 138.93,49.84 138.77,49.68 138.39,49.68 138.11,49.4 138.11,49 138.39,48.72 138.77,48.72 138.93,48.57 138.93,40.94 138.39,40.41 138.39,39.13 136.79,37.53 136.79,36.52 137.06,36.26 137.06,35.7 136.79,35.43 136.79,34.71 137.06,34.44 137.06,33.88 136.79,33.62 136.79,31.34 137.06,31.08 137.15,31.08 v1(137.41,30.82)
  BOTTOM w0.108: v1(137.41,30.82) 137.61,31.02 137.89,31.02 138.12,31.25 138.12,32.22 138.27,32.37 JDIMM2.221 ; UC1.AR27 122.07,84.18 v3(121.93,84.18)
DDR_B_DQS7: length 71.9
  IN1 w0.076: 127.85,80.63 127.75,80.73 127.73,80.73 127.57,80.89 127.04,80.89 125.21,82.72 125.21,83.8 v3(125.58,84.17)
  IN1 w0.095: v1(143.57,27.42) 143.32,27.67 143.32,27.86 142.48,28.7 142.48,32.34 142.1,32.71 142.1,33.74 142.38,34.02 143.17,34.02 143.53,34.38 143.53,37.83 144.71,39.01 144.71,39.25 144.71,41.54 144.24,42.01 143.9,42.01 143.57,42.34 143.57,43.71 143.76,43.9 144.1,43.9 144.41,44.21 144.41,47.95 142.66,49.7 142.66,53.28 133.17,62.77 133.17,74.47 131.59,76.05 131.59,77.61 130.12,79.08 129.41,79.08 127.85,80.63
  BOTTOM w0.108: UC1.AR21 125.71,84.17 v3(125.58,84.17) ; v1(143.57,27.42) 143.37,27.22 143.37,26.34 143.52,26.19 JDIMM2.242
DDR_B_DQS#0: length 74.8
  IN1 w0.076: v3(100.8,87.88) 100.61,87.69 98.89,87.69 96.84,85.64 95.51,85.64 94.83,84.95 94.06,84.95 93.69,84.58 93.66,84.58
  IN1 w0.095: v1(88.96,27.17) 89.13,27.34 89.13,27.67 89.44,27.98 89.44,28.21 89.31,28.33 88.53,28.33 88.28,28.58 88.28,29.04 88.53,29.29 89.77,29.29 89.9,29.41 89.9,29.83 89.77,29.95 89.41,29.95 89.13,30.23 89.13,38.05 89.21,38.13 89.21,41.23 89.77,41.79 89.77,46.3 91.76,48.3 91.76,48.81 92.66,49.71 92.66,51.63 93.03,52 93.03,57.14 93.56,57.68 93.56,80.35 92.46,81.45 92.46,83.38 93.66,84.58
  BOTTOM w0.076: v3(100.8,87.88) 100.44,87.88 100.34,87.97 100.34,88.21 UC1.AH66
  BOTTOM w0.108: JDIMM2.32 89.02,26.28 89.16,26.42 89.16,26.97 v1(88.96,27.17)
DDR_B_DQS#1: length 82.4
  IN1 w0.095: v1(83.39,31.36) 83.24,31.2 83.06,31.2 82.93,31.33 82.93,32.78 83.06,32.91 84.24,32.91 84.53,33.2 84.53,33.92 84.29,34.15 82.62,34.15 82.43,34.34 82.43,35.22 82.59,35.38 84.3,35.38 84.54,35.62 84.54,36.22 84.19,36.56 83.69,36.56 83.55,36.7 83.55,45.37 87.64,49.46 87.64,51.75 88,52.11 88,54.75 88.62,55.37 88.62,59.94 90.22,61.54 90.22,73.46 89.48,74.2 89.48,79.35 89.09,79.74 89.09,88.18 91.87,90.96 92.87,90.96 v1(93.15,90.68)
  BOTTOM w0.076: 94.95,89.09 95.03,89.09 95.27,88.85 96.01,88.85 96.36,88.5 97.32,88.5 97.4,88.46 97.65,88.46 97.78,88.5 98.22,88.5 98.33,88.61 98.65,88.61 UC1.AG69
  BOTTOM w0.102: 94.95,89.09 94.24,89.09 93.67,89.66 ; 93.67,90.22 93.66,90.24
  BOTTOM w0.108: v1(93.15,90.68) 93.15,90.09 93.21,90.04 93.36,90.04 93.4,90.08 93.4,90.23 93.48,90.31 93.59,90.31 93.66,90.24 ; v1(83.39,31.36) 83.39,31.33 83.56,31.16 83.76,31.16 84.06,31.46 84.06,32.1 83.77,32.39 JDIMM2.11 ; 93.67,89.66 93.67,90.22
DDR_B_DQS#2: length 63.8
  IN1 w0.095: v1(93.77,31.36) 94.01,31.12 94.2,31.12 94.45,31.37 94.45,32.29 94.21,32.52 94.21,32.96 94.45,33.2 94.45,34.42 94.33,34.54 93.92,34.54 93.7,34.76 93.7,35.25 94.1,35.65 95.07,35.65 95.24,35.82 95.24,36.22 95.07,36.39 94.73,36.39 94.5,36.62 94.5,41.95 94.86,42.31 95.69,42.31 95.89,42.51 95.89,43.32 95.46,43.75 95.46,45.69 96.23,46.46 96.23,50.13 97.13,51.03 97.13,78.27 98.02,79.16 98.02,80.41 100.35,82.74 100.35,83.9 100.49,84.04 100.49,84.19 100.37,84.32 100.13,84.32 v3(99.98,84.17)
  BOTTOM w0.108: UC1.AR66 100.44,84.23 100.38,84.17 v3(99.98,84.17) ; v1(93.77,31.36) 93.94,31.18 94.25,31.18 94.41,31.34 94.41,32.22 94.26,32.37 JDIMM2.53
DDR_B_DQS#3: length 62.7
  IN1 w0.095: v1(99.38,27.1) 99.66,27.37 99.66,28.38 99.27,28.77 99.06,28.77 98.81,29.01 98.81,29.56 99.09,29.85 99.34,29.85 99.78,30.29 99.78,42.27 100.68,43.16 100.68,74.99 101.71,76.02 101.71,78.83 102.13,79.25 102.13,80.05 103.26,81.18 103.26,82.14 103.11,82.28 103.11,82.74 103.11,82.74 103.11,83.05 103.11,83.05 103.11,84.01 102.94,84.18 v3(102.74,84.18)
  BOTTOM w0.108: v1(99.38,27.1) 99.66,26.82 99.66,26.49 99.66,26.34 99.52,26.19 JDIMM2.74 ; UC1.AR61 102.86,84.18 v3(102.74,84.18)
DDR_B_DQS#4: length 66.6
  IN1 w0.076: 115.91,81.21 115.91,83.75 115.84,83.82 115.74,83.82 115.67,83.75 115.67,83.64 v3(115.52,83.5)
  IN1 w0.095: 115.91,81.21 118.1,79.02 118.8,79.02 119.89,77.93 119.89,77.47 119.37,76.94 119.37,75.19 119.46,75.1 119.46,72.85 119.81,72.5 119.81,61.73 120.45,61.09 120.45,58.76 127.68,51.53 127.68,44.23 128.15,43.77 128.15,43.24 127.44,42.53 127.44,38.79 127.32,38.67 126.63,38.67 126.38,38.42 126.38,37.55 126.96,36.97 126.96,35.01 126.84,34.89 126.6,34.89 126.38,34.66 126.38,33.58 126.68,33.28 127.23,33.28 127.35,33.16 127.35,31.43 127.25,31.33 127.09,31.33 v1(126.93,31.48)
  BOTTOM w0.076: UC1.AT38 116.08,83.75 116.08,83.61 116,83.53 115.81,83.53 115.79,83.5 v3(115.52,83.5)
  BOTTOM w0.108: v1(126.93,31.48) 127.19,31.48 127.29,31.38 127.29,31.19 127.42,31.06 127.72,31.06 127.84,31.19 127.84,32.07 127.61,32.3 127.37,32.3 127.27,32.4 JDIMM2.177
DDR_B_DQS#5: length 67.2
  IN1 w0.095: v1(132.01,27.17) 132.42,27.58 132.42,28 132.2,28.23 132.2,32.28 132.52,32.6 132.52,38.08 133.37,38.93 133.37,51.11 125.09,59.39 125.09,61.73 124.05,62.77 124.05,72.5 123.54,73.01 123.54,74.09 123.18,74.45 123.18,78.23 122.27,79.14 122.27,79.5 120.49,81.28 119.95,81.28 118.82,82.41 118.82,83.44 118.9,83.53 v3(119.18,83.53)
  BOTTOM w0.108: v3(119.18,83.53) 119.32,83.53 UC1.AT32 ; JDIMM2.198 132.52,26.19 132.6,26.28 132.7,26.28 132.81,26.38 132.81,27.04 132.68,27.17 v1(132.01,27.17)
DDR_B_DQS#6: length 69
  IN1 w0.076: v3(122.84,84.18) 122.61,84.42 122.39,84.42 122.31,84.34 122.31,84.04 122.47,83.88 122.47,82.71 123.07,82.11 123.07,81.6 124.53,80.13 125.27,80.13 125.96,79.45 125.96,79.2 126.52,78.64 126.97,78.2 126.97,77.89
  IN1 w0.095: 126.97,77.89 126.97,76.85 128.38,75.44 128.38,71.68 128.53,71.53 128.53,69.2 128.2,68.87 128.2,68.29 128.46,68.04 128.46,67.04 128.2,66.79 128.2,66.16 128.46,65.9 128.46,65.01 128.2,64.76 128.2,64.26 129.45,63.01 129.45,61.52 139.01,51.95 139.01,51.28 138.73,51 138.47,51 138.29,50.82 138.29,50.58 138.47,50.41 138.85,50.41 139.11,50.14 139.11,49.76 138.85,49.5 138.47,49.5 138.29,49.33 138.29,49.08 138.47,48.91 138.85,48.91 139.11,48.64 139.11,40.87 138.58,40.33 138.58,39.06 136.98,37.46 136.98,36.6 137.25,36.33 137.25,35.63 136.98,35.36 136.98,34.78 137.25,34.52 137.25,33.81 136.98,33.54 136.98,31.42 137.13,31.27 137.25,31.27 v1(137.41,31.43)
  BOTTOM w0.108: UC1.AR25 122.98,84.18 v3(122.84,84.18) ; v1(137.41,31.43) 137.61,31.23 137.8,31.23 137.91,31.33 137.91,32.22 137.77,32.37 JDIMM2.219
DDR_B_DQS#7: length 71.9
  IN1 w0.076: 127.67,80.56 127.51,80.72 126.98,80.72 125.05,82.65 125.05,83.81 v3(124.67,84.18)
  IN1 w0.095: v1(142.94,27.42) 143.13,27.62 143.13,27.78 142.3,28.62 142.3,32.26 141.92,32.64 141.92,33.82 142.3,34.2 143.09,34.2 143.35,34.46 143.35,37.91 144.53,39.09 144.53,39.33 144.53,41.46 144.16,41.82 143.83,41.82 143.39,42.26 143.39,43.79 143.69,44.09 144.02,44.09 144.22,44.29 144.22,47.88 142.48,49.62 142.48,53.2 132.98,62.69 132.98,74.39 131.4,75.97 131.4,77.53 130.04,78.89 129.34,78.89 127.67,80.56
  BOTTOM w0.108: v3(124.67,84.18) 124.81,84.18 UC1.AR22 ; v1(142.94,27.42) 143.16,27.2 143.16,26.34 143.02,26.19 JDIMM2.240
DDR_B_MA0: length 64.6
  IN1 w0.076: 110.38,74.79 110.38,75.68 111.01,76.32 111.01,76.5 v3(111.43,76.92)
  IN1 w0.14: v1(116.52,27.42) 116.94,27 116.94,25.3 116.75,25.11 116.04,25.11 115.87,25.27 115.87,28.07 114.5,29.44 114.5,34.48 114.06,34.91 114.06,38.21 113.98,38.29 113.98,41.88 113.06,42.8 113.06,45.65 112.86,45.86 112.86,53.75 110.86,55.75 110.86,68.8 110.38,69.28 110.38,74.79
  BOTTOM w0.076: UC1.BA46 112.07,80.56 112.33,80.29 112.33,77.82 v6(112.04,77.53) v3(111.43,76.92)
  BOTTOM w0.171: JDIMM2.144 117.02,26.93 v1(116.52,27.42)
DDR_B_MA1: length 65.6
  IN1 w0.076: 109.54,74.79 109.54,75.42 110.68,76.56 110.68,77 111.02,77.35 111.02,77.75 v3(111.44,78.17)
  IN1 w0.14: 109.54,74.79 109.54,61.75 110.02,61.27 110.02,55.92 109.54,55.44 109.54,52.15 109.84,51.86 109.84,51.04 110.02,50.86 110.22,50.86 110.32,50.97 110.32,51.55 110.5,51.73 110.65,51.73 110.8,51.58 110.8,50.1 111.49,49.42 111.9,49.42 112.02,49.3 112.02,48.34 111.85,48.17 111.44,48.17 111.34,48.07 111.34,47.78 111.46,47.66 111.87,47.66 112.02,47.52 112.02,47.28 111.87,47.13 111.44,47.13 111.31,47 111.31,46.73 111.47,46.57 111.87,46.57 112.02,46.42 112.02,46.11 111.92,46.01 111.43,46.01 111.31,45.89 111.31,43.83 111.49,43.65 112.02,43.65 112.2,43.47 112.2,43.22 112.05,43.07 111.59,43.07 111.4,42.87 111.4,42.15 111.52,42.03 112.1,42.03 112.22,41.91 112.22,41.23 112.15,41.16 111.59,41.16 111.4,40.96 111.4,39.7 112.35,38.74 112.35,38.35 112.53,38.16 112.93,38.16 113.14,37.96 113.14,37.78 113.02,37.66 112.51,37.66 112.41,37.55 112.41,37.3 112.48,37.22 112.99,37.22 113.14,37.08 113.14,33.9 113.64,33.39 113.64,31.4 113.78,31.26 v1(114.07,31.26)
  BOTTOM w0.076: UC1.AY46 111.97,81.13 111.87,81.03 111.8,80.84 111.8,80.65 111.84,80.52 111.84,80.27 111.8,80.19 111.8,79.93 112,79.72 112,79.08 111.9,78.98 111.9,78.56 111.51,78.17 v3(111.44,78.17)
  BOTTOM w0.171: JDIMM2.133 114.27,32.37 114.61,32.02 114.61,31.57 114.31,31.26 v1(114.07,31.26)
DDR_B_MA2: length 66.2
  IN1 w0.076: 109.12,74.79 109.12,75.68 110.86,77.41 110.86,78.24 v3(111.44,78.83)
  IN1 w0.14: v1(115.02,27.91) 115.45,27.47 115.45,26.02 115.1,25.67 114.74,25.67 114.58,25.83 114.58,28.65 113.8,29.43 113.65,29.43 113.22,29.85 113.22,33.22 111.89,34.56 111.89,38.61 110.98,39.52 110.98,43.3 110.89,43.38 110.89,49.36 109.4,50.84 109.4,51.7 109.12,51.98 109.12,55.62 109.61,56.1 109.61,61.09 109.12,61.57 109.12,74.79
  BOTTOM w0.076: v3(111.44,78.83) 111.46,78.83 111.83,79.19 111.83,79.67 111.64,79.86 111.64,80.23 111.65,80.26 111.67,80.31 111.67,80.49 111.63,80.64 111.63,80.84 111.67,80.97 arc(111.69,81.14) 111.63,81.3 arc(111.5,81.5) UC1.AY47
  BOTTOM w0.171: v1(115.02,27.91) 114.02,26.91 JDIMM2.132
DDR_B_MA3: length 62.9
  IN1 w0.076: v3(111.44,77.53) 110.85,76.94 110.85,76.49 109.96,75.6 109.96,74.79
  IN1 w0.14: v1(114.07,31.9) 114.07,33.56 113.64,33.98 113.64,38.04 112.64,39.04 112.64,45.48 112.44,45.68 112.44,52.48 112.3,52.62 111.36,52.62 111.22,52.76 111.22,53.04 111.36,53.18 111.99,53.18 112.13,53.32 112.13,53.6 111.99,53.74 111.36,53.74 111.22,53.88 111.22,54.79 111.06,54.96 110.68,54.96 110.55,54.83 110.55,52.3 110.42,52.17 110.12,52.17 109.96,52.33 109.96,55.21 110.44,55.69 110.44,61.64 110.3,61.78 110.1,61.78 109.96,61.92 109.96,62.2 110.1,62.34 110.3,62.34 110.44,62.48 110.44,62.76 110.3,62.9 110.1,62.9 109.96,63.04 109.96,63.32 110.1,63.46 110.3,63.46 110.44,63.6 110.44,63.88 110.3,64.02 110.1,64.02 109.96,64.16 109.96,64.59 110.06,64.68 110.33,64.68 110.44,64.8 110.44,68.07 110.3,68.21 110.09,68.21 109.96,68.35 109.96,74.79
  BOTTOM w0.076: v3(111.44,77.53) 111.43,77.53 112.07,78.17 112.07,78.92 112.17,79.01 112.17,79.98 UC1.BB46
  BOTTOM w0.171: JDIMM2.131 113.77,32.2 v1(114.07,31.9)
DDR_B_MA4: length 64.3
  IN1 w0.076: 108.27,74.79 108.27,75.51 110.3,77.53 v3(110.3,77.84)
  IN1 w0.14: v1(113.52,27.19) 112.96,26.64 112.96,26.25 113.45,25.77 113.73,25.77 114.08,26.12 114.08,28.18 113.42,28.84 112.69,28.84 112.39,29.15 112.39,32.87 111.05,34.21 111.05,38.05 109.62,39.47 109.62,44.38 109.62,44.39 109.62,45.38 109.62,45.38 109.62,48.67 108.56,49.73 108.56,51.35 108.27,51.65 108.27,56.08 108.77,56.57 108.77,60.74 108.27,61.24 108.27,74.79
  BOTTOM w0.076: v3(110.3,77.84) 111.06,78.61 111.06,79.56 arc(111.07,79.65) 111.09,79.73 111.13,79.83 arc(111.17,79.97) 111.18,80.12 arc(111.17,80.22) 111.13,80.31 arc(111.11,80.4) 111.13,80.49 arc(111.18,80.63) 111.2,80.77 arc(111.26,80.94) UC1.BA47
  BOTTOM w0.171: v1(113.52,27.19) 113.47,27.19 113.02,26.73 JDIMM2.128
DDR_B_MA5: length 66.6
  IN1 w0.076: v3(110.3,78.42) 109.54,77.66 109.54,77.08 107.85,75.39 107.85,74.79
  IN1 w0.14: v1(113.52,27.82) 112.91,27.82 112.53,27.45 112.53,26.43 112.15,26.05 111.77,26.05 111.44,26.38 111.44,26.73 111.97,27.26 111.97,32.69 110.07,34.59 110.07,36.78 110.21,36.92 110.46,36.92 110.6,37.06 110.6,37.34 110.46,37.48 110.21,37.48 110.07,37.62 110.07,38.08 108.59,39.56 108.59,40.54 109.2,41.15 109.2,45.55 109.21,45.56 109.21,48.49 108.15,49.55 108.15,51.18 107.85,51.47 107.85,56.25 108.35,56.75 108.35,60.57 107.85,61.07 107.85,74.79
  BOTTOM w0.076: v3(110.3,78.42) 110.9,79.02 110.9,79.56 arc(110.91,79.68) 110.94,79.79 110.98,79.88 arc(111.01,80) 111.02,80.12 arc(111.01,80.18) 110.99,80.24 arc(110.94,80.4) 110.98,80.57 arc(111.02,80.67) 111.04,80.78 arc(110.97,81.12) UC1.AY48
  BOTTOM w0.171: JDIMM2.126 112.52,26.82 v1(113.52,27.82)
DDR_B_MA6: length 64.7
  IN1 w0.14: v1(111.54,30.72) 111.14,30.72 111.06,30.8 111.06,31.08 110.95,31.19 110.43,31.19 110.27,31.35 110.27,31.59 110.39,31.71 110.59,31.71 110.69,31.81 110.69,32.7 110.56,32.83 110.09,32.83 109.93,32.99 109.93,33.47 109.8,33.6 109.32,33.6 109.19,33.73 109.19,33.93 109.29,34.03 109.29,34.21 109.09,34.4 108.88,34.4 108.79,34.32 108.6,34.32 108.3,34.62 108.3,36 108.19,36.11 107.95,36.11 107.83,36.23 107.83,37.81 107.68,37.96 107.68,38.32 107.53,38.47 107.22,38.47 107.09,38.6 107.09,38.8 107.22,38.93 107.54,38.93 107.68,39.07 107.68,39.28 107.58,39.38 107.28,39.38 107.09,39.57 107.09,40.72 107.31,40.94 107.31,41.42 107.45,41.56 108.3,41.56 108.36,41.61 108.36,42.03 108.24,42.15 107.43,42.15 107.31,42.28 107.31,42.54 107.45,42.69 107.94,42.69 108.03,42.78 108.03,43.26 108.03,43.26 108.03,43.61 108.03,46.71 107.91,46.83 107.43,46.83 107.31,46.95 107.31,47.33 107.47,47.5 108.06,47.5 108.19,47.62 108.19,48.24 107.31,49.12 107.31,50.83 107.01,51.12 107.01,76.13 107.53,76.65 108.29,76.65 108.65,77 108.65,77.97 110.3,79.62 v7(110.3,79.64)
  BOTTOM w0.076: UC1.BA48 110.74,80.5 110.13,79.89 110.13,79.78 110.27,79.64 v7(110.3,79.64)
  BOTTOM w0.171: JDIMM2.127 112.77,31.92 111.57,30.72 v1(111.54,30.72)
DDR_B_MA7: length 67.1
  IN1 w0.076: v3(110.04,84.77) 110.06,84.77 110.39,84.44 110.39,82.63 107.53,79.77 107.53,77.05 106.6,76.12 106.6,74.79
  IN1 w0.14: v1(110.58,27.93) 110.86,27.93 110.98,27.8 110.98,27.45 111.11,27.32 111.39,27.32 111.55,27.48 111.55,29.48 109.79,31.24 109.79,32.53 107.88,34.44 107.88,35.59 107.41,36.06 107.41,37.64 106.67,38.38 106.67,40.89 106.89,41.11 106.89,42.72 107.61,43.44 107.61,45.78 106.89,46.5 106.89,50.66 106.6,50.95 106.6,74.79
  BOTTOM w0.076: v3(110.04,84.77) 110.06,84.8 110.14,84.8 UC1.AP48
  BOTTOM w0.171: JDIMM2.122 111.52,26.99 v1(110.58,27.93)
DDR_B_MA8: length 63.4
  IN1 w0.14: v3(110.3,78.98) 108.98,77.66 108.98,76.92 107.43,75.38 107.43,60.61 107.55,60.49 107.84,60.49 107.93,60.4 107.93,59.98 107.79,59.84 107.57,59.84 107.43,59.7 107.43,51.3 107.73,51.01 107.73,49.3 108.78,48.24 108.78,46.73 108.64,46.59 108.59,46.59 108.45,46.45 108.45,46.17 108.59,46.03 108.64,46.03 108.78,45.89 108.78,45.61 108.64,45.47 108.59,45.47 108.45,45.33 108.45,45.05 108.59,44.91 108.64,44.91 108.78,44.77 108.78,44.49 108.64,44.35 108.59,44.35 108.45,44.21 108.45,43.93 108.59,43.79 108.64,43.79 108.78,43.65 108.78,43.37 108.64,43.23 108.59,43.23 108.45,43.09 108.45,42.81 108.59,42.68 108.64,42.68 108.78,42.54 108.78,41.32 108.6,41.14 108.21,41.14 108.01,40.93 108.01,39.54 108.1,39.46 108.1,38.13 108.27,37.97 109.5,37.97 109.65,37.81 109.65,37.48 109.53,37.36 108.37,37.36 108.25,37.24 108.25,37.06 108.44,36.87 109.49,36.87 109.65,36.7 109.65,36.4 109.53,36.28 108.84,36.28 108.72,36.15 108.72,35.98 108.84,35.86 109.53,35.86 109.65,35.74 109.65,35.56 109.53,35.44 108.84,35.44 108.72,35.32 108.72,35.05 108.8,34.96 109.59,34.96 109.65,34.9 109.65,34.41 111.12,32.95 111.12,31.81 v1(111.54,31.38)
  BOTTOM w0.076: v3(110.3,78.98) 110.68,79.36 110.68,80.02 UC1.BB48
  BOTTOM w0.171: JDIMM2.125 112.27,32.11 v1(111.54,31.38)
DDR_B_MA9: length 63.6
  IN1 w0.076: v3(109.13,85.41) 109.48,85.05 109.48,82.33 107.66,80.51 106.87,80.51 105.76,79.39 105.76,75.66 105.76,75.65
  IN1 w0.14: v7(109.64,30.19) 109.19,30.65 109.18,30.65 108.95,30.87 108.95,32.19 106.57,34.57 106.57,37.25 105.83,37.99 105.83,41.24 106.05,41.46 106.05,50.31 105.76,50.6 105.76,75.65
  BOTTOM w0.076: v3(109.13,85.41) 109.32,85.41 UC1.AP50
  BOTTOM w0.171: JDIMM2.121 111.27,32.47 111.06,32.26 111.06,31.6 v7(109.64,30.19)
DDR_B_MA10: length 64.7
  IN1 w0.076: 110.8,74.79 110.8,75.72 v3(111.44,76.36)
  IN1 w0.14: v1(120.02,27.4) 118.99,26.38 117.77,26.38 117.49,26.66 117.49,27.06 114.98,29.56 114.98,37.88 114.4,38.46 114.4,42.06 113.9,42.56 113.9,45.41 113.28,46.03 113.28,53.93 111.28,55.92 111.28,68.97 110.8,69.45 110.8,74.79
  BOTTOM w0.076: v3(111.44,76.36) 111.95,76.87 112.14,76.87 112.5,77.23 112.5,80.72 112.33,80.9 arc(112.3,80.93) 112.27,80.97 arc(112.23,81.12) 112.28,81.27 arc(112.31,81.41) 112.25,81.55 arc(112.09,81.78) UC1.AW46
  BOTTOM w0.171: JDIMM2.146 119.52,26.9 v1(120.02,27.4)
DDR_B_MA11: length 67.4
  IN1 w0.076: 106.18,74.79 106.18,76.22 105.92,76.47 105.92,79.29 106.68,80.05 107.44,80.05 109.66,82.27 109.66,85.05 v7(110.04,85.43)
  IN1 w0.14: v1(110.55,27.29) 110.15,27.69 110.15,28.39 110.3,28.54 110.91,28.54 111.06,28.69 111.06,29.05 110.93,29.17 110.27,29.17 110.07,29.38 110.07,30.36 109.37,31.06 109.37,32.36 107.46,34.27 107.46,35.42 106.99,35.89 106.99,37.42 106.25,38.16 106.25,41.07 106.47,41.29 106.47,42.89 107.19,43.61 107.19,45.6 106.47,46.32 106.47,50.49 106.18,50.78 106.18,74.79
  BOTTOM w0.076: UC1.AN48 110.13,85.43 v7(110.04,85.43)
  BOTTOM w0.171: JDIMM2.120 111.02,26.83 v1(110.55,27.29)
DDR_B_MA12: length 67.4
  IN1 w0.076: v3(109.13,86.07) 108.73,85.67 108.73,83.29 108.72,83.28 108.72,82 107.48,80.76 106.74,80.76 105.59,79.61 105.59,76.2 104.9,75.5 104.9,74.79
  IN1 w0.14: v1(109.64,29.47) 109.35,29.17 108.98,29.17 108.53,29.62 108.53,32.01 106.15,34.39 106.15,35.87 105.41,36.61 105.41,41.42 105.63,41.63 105.63,50.12 104.91,50.84 104.91,63.21 105.34,63.63 105.34,71.07 104.9,71.52 104.9,74.79
  BOTTOM w0.076: UC1.AN50 109.31,86.07 v3(109.13,86.07)
  BOTTOM w0.171: JDIMM2.119 110.77,31.98 109.15,30.37 109.15,29.96 v1(109.64,29.47)
DDR_B_MA13: length 61.8
  IN1 w0.076: 114.26,74.79 114.26,75.36 114.11,75.51 113.64,75.51 113.22,75.93 113.22,78.64 v3(113.52,78.94)
  IN1 w0.14: v1(123.01,27.15) 122.16,28 121.27,28 121.02,28.26 120.38,28.26 120,28.64 120,31.46 119.49,31.97 119.49,32.95 119.16,33.29 119.16,44.91 119.37,45.13 119.37,46.18 118.38,47.17 118.38,53.93 114.84,57.48 114.84,61.18 114.51,61.51 114.51,70.9 114.26,71.15 114.26,74.79
  BOTTOM w0.076: v3(113.52,78.94) 113.33,79.13 113.33,79.52 arc(113.34,79.57) 113.36,79.61 arc(113.42,79.69) 113.46,79.77 113.48,79.83 arc(113.52,79.97) 113.54,80.12 arc(113.52,80.22) 113.49,80.31 arc(113.46,80.4) 113.48,80.49 arc(113.53,80.63) 113.56,80.77 arc(113.62,80.94) UC1.BA43
  BOTTOM w0.171: v1(123.01,27.15) 122.52,26.65 JDIMM2.158
DDR_B_MA14: length 67
  IN1 w0.076: 115.54,74.79 115.54,75.2 114.04,76.7 v3(113.74,76.7)
  IN1 w0.14: v1(121.27,31.44) 121.47,31.23 121.73,31.23 121.85,31.35 121.85,32.58 121.75,32.68 121.42,32.68 121.27,32.83 121.27,33.32 121.38,33.43 121.67,33.43 121.79,33.55 121.79,33.72 121.67,33.85 121.38,33.85 121.26,33.97 121.26,34.14 121.38,34.27 121.71,34.27 121.8,34.36 121.8,34.63 121.65,34.79 121.42,34.79 121.26,34.95 121.26,35.95 121.42,36.12 121.42,36.73 121.26,36.89 121.26,39.01 121.09,39.18 121.09,41.54 121.27,41.72 121.7,41.72 121.85,41.88 121.85,42.05 121.76,42.15 121.23,42.15 121.09,42.29 121.09,42.49 121.21,42.61 121.8,42.61 121.92,42.73 121.92,42.91 121.8,43.03 121.21,43.03 121.09,43.15 121.09,43.37 121.22,43.5 121.78,43.5 121.92,43.64 121.92,45.79 121.78,45.93 121.23,45.93 121.14,46.01 121.14,46.37 121.27,46.5 121.75,46.5 121.92,46.67 121.92,46.95 121.57,47.3 121.38,47.3 120.78,46.71 120.62,46.71 120.41,46.92 120.41,47.12 120.98,47.7 120.98,47.89 120.78,48.09 120.59,48.09 120.11,47.62 119.92,47.62 119.74,47.8 119.74,48.03 120.19,48.49 120.19,48.68 119.64,49.24 119.64,54.46 116.1,58 116.1,61.78 115.76,62.12 115.76,71.42 115.54,71.65 115.54,74.79
  BOTTOM w0.076: v3(113.74,76.7) 113.74,76.7 113.16,77.28 113.16,79.52 arc(113.18,79.64) 113.25,79.73 arc(113.28,79.78) 113.31,79.83 113.33,79.88 arc(113.36,80) 113.37,80.12 arc(113.36,80.18) 113.34,80.24 113.34,80.24 arc(113.3,80.4) 113.34,80.57 arc(113.37,80.67) 113.39,80.78 arc(113.39,80.92) 113.35,81.07 113.35,81.23 UC1.AY44
  BOTTOM w0.171: v1(121.27,31.44) 120.77,31.94 JDIMM2.151
DDR_B_MA15: length 67.1
  IN1 w0.076: 114.68,74.79 114.68,75.21 114.21,75.68 113.71,75.68 113.39,76 113.39,78.07 v3(113.73,78.41)
  IN1 w0.14: 114.68,74.79 114.68,71.32 114.93,71.08 114.93,61.77 115.26,61.44 115.26,57.65 118.8,54.11 118.8,47.34 120.25,45.89 120.25,44.82 120.17,44.74 119.82,44.74 119.64,44.57 119.64,44.21 119.8,44.06 120.08,44.06 120.25,43.88 120.25,43.08 120.19,43.02 119.75,43.02 119.59,42.86 119.59,42.65 119.71,42.53 120.1,42.53 120.23,42.41 120.23,42.12 120.16,42.05 119.67,42.05 119.58,41.96 119.58,37.12 119.7,37 120.25,37 120.42,36.83 120.42,35.02 120.28,34.88 119.84,34.88 119.7,34.74 119.7,34.46 120.08,34.08 120.08,33.9 119.95,33.77 119.95,33.77 119.84,33.77 119.7,33.63 119.7,33.35 119.84,33.21 120.28,33.21 120.42,33.07 120.42,29.03 120.76,28.69 121.35,28.69 121.54,28.49 122.34,28.49 122.93,27.91 v1(123.01,27.91)
  BOTTOM w0.076: UC1.AY43 114.03,81.53 114.03,81.19 arc(114.05,81.08) 114.03,80.97 113.99,80.87 113.99,80.61 114.03,80.49 114.03,80.31 114,80.26 113.99,80.23 113.99,79.75 114.08,79.66 114.08,79.31 113.87,79.1 113.87,78.75 113.73,78.6 v3(113.73,78.41)
  BOTTOM w0.171: JDIMM2.156 122.01,26.91 v1(123.01,27.91)
DDR_B_MA16: length 64.6
  IN1 w0.076: v3(111.44,75.8) 111.14,75.8 111.06,75.73 111.06,75.02 111.24,74.85 111.24,74.79
  IN1 w0.14: v1(121.01,27.04) 120.2,27.85 119.67,27.85 118.68,26.86 118.27,26.86 115.4,29.74 115.4,38.68 114.82,39.26 114.82,42.23 114.32,42.73 114.32,45.58 113.69,46.2 113.69,54.1 111.7,56.09 111.7,69.15 111.24,69.61 111.24,74.79
  BOTTOM w0.076: v3(111.44,75.8) 112.66,77.03 112.66,80.72 112.87,80.93 arc(112.93,81.03) 112.92,81.15 112.87,81.33 arc(112.87,81.5) 112.96,81.64 arc(113.11,81.82) UC1.AW44
  BOTTOM w0.171: v1(121.01,27.04) JDIMM2.152
DDR_B_ODT0: length 66.4
  IN1 w0.076: v3(115,76.95) 115.56,76.39 116.01,76.39 116.64,75.76 116.76,75.76 117.25,75.27 117.25,74.83 117.24,74.82 117.24,74.79
  IN1 w0.14: 117.24,74.79 117.24,72.32 117.87,71.69 117.87,58.59 122.39,54.07 122.39,52.83 122.53,52.69 122.95,52.69 123.1,52.54 123.1,52.27 122.96,52.13 122.53,52.13 122.39,51.99 122.39,50.81 124.41,48.8 124.41,41.46 124.44,41.44 124.44,39.82 123.23,38.6 123.23,37.03 124.27,35.99 124.27,30.54 124.52,30.29 125.13,30.29 125.26,30.17 125.26,29.17 124.83,28.74 123.73,28.74 123.38,29.1 123,29.1 122.77,29.34 v1(122.77,30.11)
  BOTTOM w0.076: v3(115,76.95) 114.41,77.53 114.41,78.94 114.69,79.21 114.69,80.15 arc(114.67,80.23) 114.63,80.3 114.42,80.5 UC1.BA42
  BOTTOM w0.171: JDIMM2.155 121.77,31.11 v1(122.77,30.11)
DDR_B_ODT1: length 67.3
  IN1 w0.076: 116.83,74.79 116.83,75.17 115.89,76.11 115.33,76.11 114.64,76.8 114.64,77.19 v3(115,77.54)
  IN1 w0.14: v1(122.77,30.74) 123.09,30.74 123.23,30.6 123.23,29.72 123.37,29.58 123.61,29.58 124,29.18 124.59,29.18 124.73,29.32 124.73,29.7 124.63,29.8 124.42,29.8 123.84,30.38 123.84,32.35 123.45,32.73 123.45,32.98 123.84,33.36 123.84,35.83 122.78,36.88 122.78,39.09 123.51,39.82 123.51,41.36 123.92,41.77 123.92,46.79 123.6,47.11 123.6,47.31 123.79,47.5 123.79,47.81 123.69,47.91 123.41,47.91 123.21,47.7 123.01,47.7 122.81,47.9 122.81,48.1 123.15,48.44 123.15,48.63 122.95,48.83 122.75,48.83 122.42,48.49 122.22,48.49 121.98,48.74 121.98,53.9 117.45,58.42 117.45,71.51 116.83,72.14 116.83,74.79
  BOTTOM w0.076: UC1.AW42 114.42,81.81 114.71,81.52 114.71,80.5 114.79,80.42 arc(114.81,80.33) 114.86,80.26 114.86,79.15 114.58,78.87 114.58,77.96 v3(115,77.54)
  BOTTOM w0.171: JDIMM2.161 123.27,31.24 v1(122.77,30.74)
DDR_B_PARITY: length 67.4
  IN1 w0.076: 113.7,74.79 113.7,75.22 112.84,76.08 112.84,79.24 113.22,79.62 113.22,84.36 v3(112.78,84.77)
  IN1 w0.14: 113.7,74.79 113.7,70.52 114.09,70.14 114.09,61.34 114.42,61 114.42,57.3 117.96,53.76 117.96,46.99 118.74,46.22 118.74,33.11 119.07,32.78 119.07,31.79 119.58,31.29 119.58,28.91 118.98,28.31 118.58,28.31 118.3,28.59 118.3,29.15 118.57,29.43 118.57,31.62 v1(118.45,31.74)
  BOTTOM w0.076: UC1.AP43 112.86,84.77 v3(112.78,84.77)
  BOTTOM w0.171: v1(118.45,31.74) 117.56,31.74 116.77,32.54 JDIMM2.143
DDR_VTT_CTRL: length 75.9
  TOP w0.076: v3(93.95,81.58) 94.54,80.99 97.98,80.99 99.12,79.85 99.12,77.59 v3(99.63,77.08)
  TOP w0.108: v1(80.81,38.55) 81.19,38.16 R34.2 81.14,37.45 v2(81.14,37.1) 81.14,36.21 81.47,35.88 U5.2
  BOTTOM w0.076: v3(99.63,77.08) 99.26,77.44 99.26,78.92 100.06,79.71 100.06,80.23 100.05,80.26 100.04,80.27 100.04,80.55 100.06,80.61 100.06,80.87 100.02,80.97 100.02,81.12 99.88,81.58 99.51,81.95 UC1.AW67
  BOTTOM w0.108: v1(80.81,38.55) 80.39,38.96 80.39,41.07 81.45,42.13 81.45,43.18 79.2,45.43 79.2,48.48 79.77,49.05 81.37,49.05 82.04,49.71 82.04,51.05 83.6,52.62 83.6,55.02 83.08,55.54 83.08,61.89 83.84,62.65 88.61,62.65 89.38,63.42 89.38,79.76 91.55,81.93 93.6,81.93 v3(93.95,81.58)
DDR_XDP_WAN_SMBCLK: length 312.3
  TOP w0.108: QC1.1 152.2,94.5 152.3,94.4 154.2,94.4 154.62,94.81 157.33,94.81 v2(157.72,94.43) 158.32,95.02 158.32,95.13 158.8,95.62 159,95.62 159.7,96.32 159.7,96.86 160.69,97.85 162.58,97.85 163.74,96.69 166.42,96.69 167.85,98.12 v1(168.26,98.12) ; v1(104.27,121.32) 104,121.58 104,125.06 104.85,125.9 104.85,126.66 105.75,127.57 106.36,127.57 107.05,128.25 107.05,131.26 105.39,132.91 105.39,138.5 104.66,139.23 v1(104.66,142.66) ; v1(188.28,48.38) 188.28,47.72 182.3,41.75 179.69,41.75 177.1,39.16 177.1,36.46 v1(177.38,36.18)
  IN1 w0.089: v1(177.38,36.18) 177.38,37.09 176.1,38.38 176.1,44.64 172.48,48.26 172.48,67.72 167.57,72.64 167.57,80.82 166.75,81.64 166.75,89.08 167.96,90.28 167.96,92.47 167.18,93.24 167.18,96.41 167.5,96.74 167.5,97.8 167.82,98.12 v1(168.26,98.12) 168.61,98.47 168.61,99.41 167.42,100.61 167.42,116.48 151.24,132.66 151.24,133.8 149.54,135.5 148.63,135.5 148,136.13 144.29,136.13 143.66,136.76 141.58,136.76 140.78,137.57 139.04,137.57 138,138.6 138,139.96 134.21,143.76 132.85,143.76 132.28,144.33 124.83,144.33 124.72,144.44 106.42,144.44 104.66,142.67 v1(104.66,142.66)
  IN4 w0.089: v1(104.27,121.32) 102.64,119.69 101.48,119.69 100.75,120.41 99.68,120.41 98.98,121.12 96.73,121.12 95.76,120.15 85.46,120.15 84.34,121.27 81.9,121.27 v1(81.8,121.37) ; v1(147.8,43.28) 146.16,41.64 146.16,37.37 145.22,36.44 145.22,30.67 v1(144.77,30.22) ; v1(151.98,33.72) 152.06,33.72 152.19,33.85 154,35.66 175.59,35.66 176.31,36.39 177.18,36.39 v1(177.38,36.18)
  BOTTOM w0.108: v1(188.28,48.38) 188.28,48.04 R123.2 189.6,47.74 189.86,48.01 U15.1 ; v1(147.8,43.28) 147.79,43.28 146.26,44.81 JDIMM1.253 ; v1(81.8,121.37) JXDP1.53 ; JDIMM2.253 146.27,31.18 145.3,30.22 v1(144.77,30.22) 144.97,30.02 147.54,30.02 151,33.47 151.73,33.47 v1(151.98,33.72)
DDR_XDP_WAN_SMBDAT: length 316.6
  TOP w0.108: QC1.4 153.5,96.85 153.71,96.64 154.11,96.64 154.34,96.4 154.34,95.39 154.61,95.12 157.7,95.12 158.5,95.93 158.87,95.93 159.39,96.45 159.39,96.99 160.56,98.16 163.03,98.16 v2(163.64,97.55) 164.19,97 166.29,97 168.03,98.74 v1(168.21,98.74) ; v1(104.25,120.71) 103.69,121.27 103.69,124.27 103.69,125.18 104.54,126.03 104.54,126.84 105.57,127.88 106.23,127.88 106.74,128.38 106.74,131.13 105.08,132.78 105.08,138.37 104.35,139.1 104.35,142.13 104.15,142.33 104.15,142.81 104.46,143.12 104.88,143.12 v1(105.39,142.61) ; v1(176.79,35.99) 176.79,39.28 179.56,42.06 182.18,42.06 187.8,47.69 187.8,48.48 188.11,48.78 188.5,48.78 v1(188.91,48.38)
  IN1 w0.089: v1(176.79,35.99) 176.79,37.27 175.8,38.25 175.8,44.52 172.19,48.14 172.19,67.6 167.28,72.52 167.28,80.7 166.46,81.52 166.46,89.2 167.64,90.38 167.64,92.37 166.8,93.21 166.8,96.44 167.21,96.86 167.21,97.92 167.74,98.45 167.92,98.45 v1(168.21,98.74) 168.21,99.4 167.12,100.48 167.12,116.36 150.86,132.62 150.86,133.76 149.42,135.2 148.51,135.2 147.88,135.84 144.17,135.84 143.54,136.47 141.46,136.47 140.66,137.27 138.92,137.27 137.71,138.48 137.71,139.84 134.08,143.47 132.72,143.47 132.15,144.04 124.63,144.04 124.52,144.15 106.55,144.15 105.39,142.99 v1(105.39,142.61)
  IN4 w0.089: v1(144.74,29.6) 144.89,29.6 145.51,30.23 145.51,36.32 146.45,37.25 146.45,41.29 v1(147.8,42.65) ; v1(176.79,35.99) 176.33,35.99 175.71,35.37 154.27,35.37 v1(152.59,33.69) ; v1(81.14,121.37) 81.54,120.97 84.23,120.97 85.34,119.86 95.88,119.86 96.85,120.83 98.86,120.83 99.56,120.12 100.63,120.12 101.36,119.39 102.76,119.39 104.07,120.71 v1(104.25,120.71)
  BOTTOM w0.108: JDIMM2.254 146.52,26.33 146.34,26.51 146.34,28 v1(144.74,29.6) 144.84,29.71 147.67,29.71 151.13,33.16 152.07,33.16 v1(152.59,33.69) ; v1(81.14,121.37) 81.3,121.53 JXDP1.51 ; JDIMM1.254 146.51,41.36 v1(147.8,42.65) ; v1(188.91,48.38) 188.58,48.71 R122.2 189.08,49.51 U15.4
DEVICE_DET#: length 106.3
  TOP w0.108: v1(266.66,46.88) 267.02,46.88 267.22,46.67 267.22,46.44 R9591.2 267.73,46.34 267.73,46.98 266.79,47.92 266.17,47.92 265.59,48.5 265.59,48.99 265,49.58 U37.B18
  IN2 w0.089: v1(199.42,49.06) 202.98,49.06 206.26,45.79 208.68,45.79 208.83,45.94 216.83,45.94 217.83,46.95 227.65,46.95 233.82,40.78 239.5,40.78 241.33,42.61 241.56,42.61 241.61,42.66 241.62,42.66 244.41,45.45 247.18,45.45 249.59,47.87 250.84,47.87 251.78,48.81 254.14,48.81 255.59,47.37 255.59,46.47 255.77,46.29 266.07,46.29 v1(266.66,46.88)
  BOTTOM w0.108: JODD1.9 196.48,31.45 194.37,33.56 194.37,37.48 194.68,37.78 R2672.2 195.33,42.63 v2(195.33,44.76) 195.94,45.36 195.94,46.79 197.42,48.27 198.66,48.27 199.42,49.03 v1(199.42,49.06)
DGPU_CORE_EN: length 99.2
  IN3 w0.089: v1(134.2,139.77) 134.2,138.61 137.88,134.93 137.88,131.15 146.16,122.87 146.16,113.96 146.57,113.55 146.57,110.43 145.86,109.72 v1(145.86,108.83)
  BOTTOM w0.076: UC1.P4 136.16,94.96 138.83,94.96 140.52,96.64 140.52,97.52 140.91,97.91 141.16,97.91
  BOTTOM w0.108: RC305.1 145.22,109.46 v1(145.86,108.83) 146.67,108.01 148.83,108.01 151.08,105.77 151.08,102.79 151.08,101.3 148.29,98.52 147.76,98.52 147.51,98.26 142.69,98.26 142.34,97.91 141.16,97.91 ; JGFX1.69 114.7,142.9 114.87,143.07 114.87,144.06 v2(114.11,144.82) 114.11,146.76 114.25,146.9 114.25,147.82 115.84,149.41 122.58,149.41 126.97,145.02 131.11,145.02 134.49,141.65 134.49,140.06 v1(134.2,139.77)
DGPU_HOLD_RST#: length 129.4
  IN1 w0.089: v1(160.19,96.59) 160.19,95.07 160.03,94.91 160.03,93.79 158.07,91.83 153.92,91.83 151.95,89.87 151.95,84.57 v1(150.94,83.56)
  IN2 w0.089: v3(139.86,97.42) 140.35,97.9 141.72,97.9 142.09,97.54 147.27,97.54 148.91,95.9 151.52,95.9 152.38,96.76 154.39,96.76 155.55,95.6 157.66,95.6 158.18,96.12 159.72,96.12 v1(160.19,96.59)
  IN3 w0.076: 140.34,106.16 138.58,104.4 138.58,102.7 139.18,102.1 139.18,100.11 138.7,99.64 138.7,98.58 v3(139.86,97.42)
  IN3 w0.089: 140.34,106.16 142.96,108.78 142.96,108.9 143.77,109.72 144.39,109.72 145.68,111.01 145.68,111.88 144.97,112.59 144.97,117.62 145.62,118.28 145.62,122.84 137.53,130.93 137.53,134.78 133.18,139.12 v1(133.18,139.64)
  BOTTOM w0.076: UC1.P3 136.86,95.54 138.35,95.54 139.05,96.25 139.05,96.61 v3(139.86,97.42)
  BOTTOM w0.108: v1(133.18,139.64) 134.04,140.5 134.04,141.48 130.95,144.57 126.82,144.57 122.41,148.99 117.14,148.99 116.24,148.1 v2(116.24,147.49) 116.24,145.56 116.49,145.3 116.49,144.16 117.2,143.45 JGFX1.59 ; RP9.3 v1(150.94,83.56)
DGPU_PWR_EN: length 97.3
  IN3 w0.089: v1(145.22,108.83) 145.22,109.46 146.39,110.63 146.39,113.45 145.88,113.96 145.88,122.9 137.7,131.08 137.7,134.85 133.77,138.79 v1(133.77,139.29)
  BOTTOM w0.076: 141.16,98.14 141.15,98.13 140.89,98.13 140.35,97.59 140.35,96.71 138.86,95.22 UC1.P1
  BOTTOM w0.108: 141.16,98.14 142.26,98.14 142.59,98.47 147.42,98.47 147.68,98.73 148.2,98.73 150.87,101.39 150.87,102.7 150.87,102.7 150.87,105.68 148.74,107.8 146.25,107.8 v1(145.22,108.83) RC306.1 RC620.2 ; v1(133.77,139.29) 133.77,139.92 134.25,140.4 134.25,141.59 131.06,144.78 126.91,144.78 122.49,149.2 115.93,149.2 114.79,148.07 v2(114.79,146.42) 114.79,144.56 115.08,144.28 115.08,143.54 115.2,143.42 JGFX1.67
DGPU_PWROK: length 269.9
  TOP w0.108: U37.A56 254.57,53.83 254.42,53.68 254.42,53.4 253.71,52.69 CC281.2 252.39,52.24 250.28,52.24 R354.2 249.82,53.28 249.54,53.56 249.41,53.56 249.41,53.55 249.07,53.55 249.06,53.56 249.06,53.56 248.83,53.79 248.83,57.37 v1(248.55,57.65)
  IN2 w0.076: 133.77,106.16 133.77,104.55 v3(134.74,103.58) 138.19,100.14 140.81,100.14 141.16,99.78
  IN2 w0.089: 141.16,99.78 142.97,97.97 150.51,97.97 151.37,97.11 154.54,97.11 155.65,96.01 157.14,96.01 158.36,97.23 160.3,97.23 160.53,97.23 161.91,95.85 162.41,95.85 162.64,95.62 167.89,95.62 168.95,96.68 172.61,96.68 177,92.29 177,84.97 178.38,83.59 178.97,83.59 179.4,83.15 179.4,65.92 184.3,61.02 185.46,61.02 188.7,57.78 189.58,57.78 190.98,56.38 194.37,56.38 195.21,55.54 206.6,55.54 208.58,57.52 212.8,57.52 212.92,57.4 219,57.4 219.28,57.12 224.14,57.12 226.44,59.42 228.72,59.42 229.41,58.73 232.04,58.73 232.25,58.95 232.43,58.95 232.44,58.96 236.97,58.96 237,58.99 237.82,58.99 239.51,57.3 243.61,57.3 244.61,56.31 247.21,56.31 v1(248.55,57.65) ; 133.77,106.16 133.77,108 134.22,108.45 137.91,108.45 138.05,108.59 141.34,108.59 141.69,108.24 147.08,108.24 v1(149.35,105.97)
  IN3 w0.089: v1(149.35,105.97) 149.6,106.22 149.6,109.69 149.34,109.95 149.34,117.15 146.34,120.16 146.34,122.94 138.06,131.22 138.06,135.57 134.7,138.93 v1(134.7,139.42)
  BOTTOM w0.076: UC1.C8 134.05,102.02 134.05,102.89 v3(134.74,103.58)
  BOTTOM w0.108: v2(248.55,58.34) v1(248.55,57.65) ; v3(134.74,103.58) 134.74,103.98 135.47,104.71 135.47,107.18 134.83,107.81 134.83,108.5 RC476.1 ; v1(134.7,139.42) 134.7,139.42 134.7,141.73 131.2,145.23 127.05,145.23 122.67,149.62 115.75,149.62 114.04,147.91 114.04,146.99 113.29,146.24 113.29,142.99 113.2,142.9 JGFX1.75
DIMM1_SA0: length 4
  TOP w0.108: v2(145.17,36.36) RD62.2
  TOP w0.305: RD62.2 RD66.1 147,36.95 v1(147.01,36.96)
  BOTTOM w0.305: v1(147.01,36.96) JDIMM1.256
DIMM1_SA1: length 4
  TOP w0.108: v2(149.74,36.36) RD63.2
  TOP w0.305: RD63.2 RD67.1 v1(147.89,36.95)
  BOTTOM w0.305: v1(147.89,36.95) 148.01,37.07 JDIMM1.260
DIMM1_SA2: length 5.6
  TOP w0.305: RD64.2 RD68.1 124.7,39.1 v2(124.7,39.79) 124.7,40.37 124.45,40.63 v1(124.01,40.63)
  BOTTOM w0.108: v1(124.01,40.63) 124.51,40.13 JDIMM1.166
DIMM2_SA0: length 4.6
  TOP w0.381: RD72.1 RD69.2 147.64,27.24 147.64,26.74 v2(147.56,26.66) 147.53,26.63 v1(146.92,26.63)
  BOTTOM w0.305: JDIMM2.256 147.02,26.54 v1(146.92,26.63)
DIMM2_SA1: length 7.8
  TOP w0.381: v1(148.26,26.61) 148.27,26.61 148.27,27.8 148.76,28.29 149.62,28.29 v2(149.64,28.31) 150.05,28.72 150.05,29.17 150.43,29.55 RD73.1 150.12,30.04 149.57,30.6 RD70.2
  BOTTOM w0.305: v1(148.26,26.61) 148.26,26.6 148.02,26.35 JDIMM2.260
DIMM2_SA2: length 5.9
  TOP w0.254: v2(122.31,24.78) 122.41,24.88 RD74.1
  TOP w0.305: v1(124.01,27.16) 123.76,27.16 123.51,26.91 123.51,26.1 RD71.2 123.18,24.91 RD74.1
  BOTTOM w0.108: v1(124.01,27.16) 124.52,26.66 JDIMM2.166
DIS_BAT_PROCHOT#: length 38.3
  TOP w0.108: PR5251.1 240.4,41.24 241.18,42.03 243.95,42.03 v1(244.69,42.76) ; U37.B51 256.28,57.23 256.6,56.91 256.6,56.58 v1(257.06,56.12)
  IN3 w0.089: v1(254.93,46.83) 254.63,47.12 253.21,47.12 251.52,45.43 251.52,44.74 251.09,44.31 246.85,44.31 246.62,44.08 246.01,44.08 v1(244.69,42.76)
  BOTTOM w0.108: v1(257.06,56.12) 257.06,56.12 257.06,55.16 255.74,53.84 255.74,49.26 255.38,48.9 255.38,47.81 255.53,47.65 255.53,46.47 v2(255.52,46.45) 255.3,46.45 v1(254.93,46.83)
DISP_ON: length 16.3
  BOTTOM w0.108: D21.3 53.65,92.2 53.13,92.72 48.83,92.72 48.32,93.23 48.32,95.79 48.96,96.43 R96.2 49.39,97.4 49.39,98.11 v2(49.88,98.61) 50.33,99.05 50.33,100.75 50.53,100.96 JEDP1.15
DMIC0: length 24.4
  TOP w0.108: v1(46.34,114.31) 46.34,114.95 v2(46.26,115.02) 46.19,115.1 45.48,115.1 R9626.2 ; v1(33.03,100.32) 32.83,100.52 CE2.1
  IN3 w0.089: v1(46.34,114.31) 46.34,112.38 38.04,104.07 36.36,104.07 33.54,101.25 33.54,100.83 v1(33.03,100.32)
  BOTTOM w0.108: JEDP1.50 v1(33.03,100.32)
DMIC0_L: length 5.4
  TOP w0.108: R9626.1 v2(44.41,115.86) 44.41,115.96 44.35,116.02 44.35,118.82 43.83,119.34 43.65,119.34 43.52,119.48 U17.47
DMIC_CLK0: length 30.3
  TOP w0.108: CE1.1 v1(33.72,100.32) ; C139.1 R9625.2 49.26,118.43 v2(48.88,118.05) 48.88,118.04 48.88,116.56 48.58,116.26 v1(48.58,114.82)
  IN3 w0.089: v1(48.58,114.82) 48.14,114.38 47.15,114.38 46.52,113.75 46.52,112.3 38.11,103.9 36.66,103.9 36.44,103.9 33.72,101.18 v1(33.72,100.32)
  BOTTOM w0.108: v1(33.72,100.32) 33.53,100.51 JEDP1.49
DMIC_CLK_L: length 4.3
  TOP w0.108: U17.2 45.42,120.87 46.54,119.75 v2(47.03,119.75) R9625.1
DOCK_DCIN_GC: length 52.8
  TOP w0.108: PR5212.1 251.83,31.53 v1(252.03,31.74) ; v1(246.11,29.78) 246.44,29.45 246.44,28.62 245.88,28.06 244.41,28.06 244.16,27.8 244.16,24.75 243.65,24.25 242.88,24.25 242.57,23.94 PQ5211.1 ; U38.B23 237.63,55.13 v1(237.57,55.19)
  IN1 w0.089: v1(252.03,31.74) 250.89,30.6 246.44,30.6 246.11,30.26 v1(246.11,29.78)
  BOTTOM w0.108: v1(237.57,55.19) 237.86,55.48 241.03,55.48 241.9,54.62 241.9,53.44 242.4,52.94 243.61,52.94 245.34,51.2 245.34,49.35 244.84,48.84 244.84,45.49 243.31,43.96 243.31,42.07 245.54,39.84 v2(245.54,39.65) 245.3,39.41 245.3,38.5 245.71,38.09 245.71,33.16 245.86,33.01 245.86,30.04 v1(246.11,29.78)
DOCK_DCIN_GC_R: length 13.6
  TOP w0.108: PQ5202.5 251.01,26.23 250.84,26.4 250.84,26.84 250.51,27.17 250,27.17 249.65,27.52 PQ5212.1 250.39,29.65 PR5211.1 PR5212.2 250.38,31.69 250.38,32.5 250.1,32.78 250.1,34.25 250.27,34.42 PQ5214.6 251.44,34.55 251.16,34.83 v2(251.16,35.65)
DOCK_DCIN_IS+: length 147
  TOP w0.254: PQ5204.3 236.79,23.38 237.26,23.85 v1(237.26,24.17)
  IN4 w0.254: v1(237.26,24.17) 238.61,25.52 241.07,25.52 241.51,25.96 241.51,28 240.45,29.07 240.45,35.37 238.39,37.43 229.35,37.43 228.28,38.49 228.28,41.44 227.46,42.25 225.18,42.25 225.02,42.09 217.5,42.09 214.09,45.49 197.08,45.49 196.13,44.55 189.77,44.55 189.42,44.89 184.45,44.89 174.41,54.93 172.32,54.93 170.44,53.05 164.27,53.05 163.6,52.38 160.29,52.38 159.28,53.38 159.28,56.72 157.19,58.81 156.84,58.81 155.73,59.92 155.73,66.5 156.68,67.45 156.68,76.04 156.76,76.13 156.76,77.98 155.69,79.06 155.69,81.5 156.27,82.08 156.27,82.82 156.11,82.98 155.94,82.98 155.39,83.54 v1(155.39,84.44)
  BOTTOM w0.108: v2(237.26,24.85) v1(237.26,24.17)
  BOTTOM w0.254: v1(155.39,84.44) 155.39,84.82 156.22,85.65 JDOCK1.37
DOCK_DCIN_IS-: length 147.9
  TOP w0.254: PQ5205.3 238.47,23.08 237.99,23.56 v1(237.99,24.12)
  IN4 w0.254: v1(237.99,24.12) 238.98,25.11 241.15,25.11 241.86,25.82 241.86,28.15 240.79,29.21 240.79,35.51 238.47,37.83 229.43,37.83 228.62,38.64 228.62,41.73 227.67,42.69 225,42.69 224.75,42.43 217.66,42.43 214.26,45.84 196.94,45.84 195.99,44.89 190.1,44.89 189.76,45.23 184.59,45.23 174.49,55.33 172.15,55.33 170.2,53.39 164.13,53.39 163.46,52.72 160.43,52.72 159.65,53.5 159.65,56.84 157.32,59.17 156.97,59.17 156.07,60.07 156.07,66.36 157.02,67.31 157.02,75.9 157.11,75.99 157.11,78.12 156.04,79.19 156.04,81.37 156.61,81.94 156.61,82.96 156.25,83.33 156.08,83.33 155.79,83.62 155.79,84.15 156.02,84.38 v1(156.02,84.44)
  BOTTOM w0.108: v2(237.99,23.27) v1(237.99,24.12)
  BOTTOM w0.254: JDOCK1.38 156.34,85.15 156.02,84.82 v1(156.02,84.44)
DOCK_DET#: length 229.2
  TOP w0.108: v1(261.88,57.49) 261.67,57.49 261.28,57.88 U37.B41
  IN1 w0.089: v1(163.89,103.24) 164.29,102.84 164.29,102.44 164.07,102.22 164.07,100.91 164.58,100.4 164.58,94.87 164.75,94.71 164.75,68.01 159.29,62.55 159.29,47.44 165.7,41.03 165.7,38.66 169.38,34.98 174.54,34.98 176.31,33.21 185.11,33.21 188.48,29.84 197.45,29.84 198.97,28.33 209.45,28.33 210.11,28.99 210.34,28.99 210.34,28.99 210.49,28.99 211.6,28.99 212.28,28.31 212.28,27.51 216.19,23.6 242.63,23.6 244.11,25.09 254.49,25.09 257.61,21.97 264.8,21.97 v1(265.26,22.43)
  BOTTOM w0.108: C9458.1 155.7,103.33 155.69,103.34 R272.2 156.28,103.87 156.5,103.65 JDOCK1.1 157.98,103.65 158.31,103.32 163.81,103.32 v1(163.89,103.24) ; v1(265.26,22.43) 265.47,22.63 265.47,23.56 266.94,25.03 266.94,27.5 268.41,28.97 268.41,33.28 v2(267.9,33.8) 267.9,34.03 266.38,35.55 266.38,41.54 265.27,42.66 265.27,48.4 264.93,48.73 264.93,55.45 264.54,55.84 263.53,55.84 v1(261.88,57.49)
DOCK_LAN_WAKE#: length 2.6
  BOTTOM w0.108: R9640.2 155.71,100.06 v2(155.79,99.99) 156.45,100.65 JDOCK1.7
DOCK_PSID: length 196.4
  TOP w0.108: PU1.1 253.19,41.74 v1(254.06,42.61) 254.39,42.28 PT5101.1
  IN1 w0.089: v1(163.89,102.6) 163.89,100.84 164.4,100.33 164.4,94.8 164.57,94.63 164.57,68.09 159.11,62.63 159.11,47.36 165.52,40.96 165.52,38.58 169.3,34.8 174.47,34.8 176.23,33.03 184.89,33.03 185.03,33.03 188.4,29.66 197.38,29.66 198.89,28.15 209.76,28.15 210.42,28.81 211.53,28.81 212.1,28.24 212.1,27.44 216.11,23.43 242.75,23.43 244.24,24.91 253.04,24.91 v1(253.81,24.14)
  BOTTOM w0.108: v1(163.89,102.6) 163.38,103.11 158.18,103.11 158.14,103.15 JDOCK1.2 ; v1(254.06,42.61) 253.65,42.2 253.65,36.55 254.62,35.58 254.62,34.68 253.57,33.62 253.57,31.99 253.21,31.64 253.21,27.91 253.63,27.5 253.63,24.32 v1(253.81,24.14)
DOCK_PWR_BTN#: length 157.7
  TOP w0.108: R330.2 224.85,49.21 v1(224.5,48.86) 224.85,48.5 C342.2
  IN1 w0.089: v1(163.26,102.63) 163.69,102.2 163.69,100.79 164.22,100.25 164.22,94.73 164.39,94.56 164.39,68.16 158.86,62.63 158.86,47.36 165.34,40.88 165.34,38.51 169.23,34.62 174.39,34.62 176.16,32.86 184.96,32.86 188.33,29.49 197.31,29.49 198.82,27.97 209.99,27.97 210.42,28.41 v1(211.36,28.41)
  BOTTOM w0.108: v1(163.26,102.63) 163.06,102.83 157.73,102.83 157.65,102.76 157.25,102.76 JDOCK1.3 ; v1(224.5,48.86) 224.5,46.8 224.64,46.66 224.64,45.94 226.2,44.38 226.2,43.95 225.55,43.3 222.79,43.3 v2(222.78,43.28) 221.62,43.28 212.41,34.07 212.41,29.45 v1(211.36,28.41)
DOCK_PWR_SW#: length 7
  TOP w0.108: U38.A63 228.1,53.38 227.77,53.05 227.77,51.96 227.39,51.58 227.39,50.8 v2(226.99,50.39) C344.1 225.35,50.39 225.31,50.43 R330.1 R328.1
