# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Nets (continued)
+1.0V_VCCSTG: C9609.1 RC357.2 RC361.1 RC363.1 RC364.1 RC365.1 RC366.1 RC367.1 RC405.1 RC415.2 RC416.1 RC456.2 RC457.2
+1.0V_VCCSTG_R1: RC415.1 UC1.G20
+1.0V_VCCSTG_R2: RC416.2 UC1.A22
+1.0V_VMM_VDD: C25.1 C3084.1 C3085.1 C3086.1 C3087.1 C3093.1 C3094.1 C9947.1 L78.2 U6.C8 U6.C9 U6.D3 U6.E3 U6.E6 U6.E7 U6.E8 U6.E9 U6.F12 U6.G3 U6.G12 U6.H6 U6.H7 U6.H8 U6.H9
+1.0V_VMM_VDDLP: C9943.1 C9944.1 C9945.1 C9946.1 L7107.2 L7108.2 U6.E5 U6.J3
+1.0V_VMM_VDDTX: C21.1 C22.1 C23.1 C24.1 L77.2 U6.C6 U6.C7 U6.D12 U6.E12 U6.F3 U6.J2 U6.J10 U6.K8 U6.K9 U6.K10
+1.0VO_DSW: C9627.1 UC1.AL1
+1.0VS_VCCIO: C9657.1 C9658.1 C9659.1 C9660.1 C9663.1 C9664.1 C9665.1 C9666.1 C9888.1 C9889.1 L7108.1 PJP5602.2 Q4215.3 R374.2 R9687.1 RC134.1 RC381.2 RC420.1 UC1.AK28 UC1.AK30 UC1.AL30 UC1.AL42 UC1.AM28 UC1.AM30 UC1.AM42
+1.2V_MEM: C9612.1 C9613.1 C9614.1 C9615.1 C9616.1 C9617.1 C9618.1 C9619.1 C9620.1 C9621.1 C9622.1 C9623.1 C9624.1 C9983.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 CD62.1 CD63.1 CD64.1 CD65.1 CD66.1 CD67.1 CD68.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD93.1 CD95.1 CD96.1 CD97.1 CD98.1 CD99.1 CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP5401.2 PJP5404.2 RC67.1 RC130.1 RC417.1 RC453.1 RD3.1 U5.5 U6222.1 U6222.2 U6222.9 UC1.AU23 UC1.AU28 UC1.AU35 UC1.AU42 UC1.BB23 UC1.BB32 UC1.BB41 UC1.BB47 UC1.BB51
+1.2V_MEM_CPUCLK: C9606.1 C9607.1 RC417.2 UC1.AM40
+1.2V_MEN_P: PC5410.1 PC5413.1 PC5414.1 PJP5401.1 PJP5402.1 PJP5404.1 PL5402.1 PR5405.2 PU5401.5
+1.2VP_+VLDOIN: PC5416.1 PJP5402.2 PU5401.19
+1.2VP_B+: PC5401.1 PC5402.1 PC5403.1 PC5404.1 PL5401.2 PQ5401.2 PR5406.1
+1.2VP_B+_R: PR5406.2 PU5401.9
+1.2VP_BOOT: PR5401.2 PU5401.18
+1.2VP_BOOT_R: PC5405.2 PR5401.1
+1.2VP_CS: PR5402.2 PU5401.13
+1.2VP_DH: PQ5401.1 PU5401.17
+1.2VP_DL: PQ5401.8 PU5401.15
+1.2VP_FB: PC5413.2 PR5405.1 PR5408.1 PU5401.6
+1.2VP_S3: PR5409.2 PU5401.7
+1.2VP_SNUB: PC5412.1 PR5403.2
+1.2VP_SW: PC5405.1 PL5402.2 PQ5401.9 PR5403.1 PU5401.16
+1.2VP_VDD: PC5409.1 PR5402.1 PR5404.2 PU5401.11
+1.5V_EN: PC5704.1 PR5701.2 PR5703.1 PU5701.7
+1.5V_FB: PC5708.1 PR5704.1 PR5705.1 PU5701.1
+1.5V_LX: PL5701.1 PR5702.2 PU5701.6
+1.5V_RUN: C635.1 JEPC1.25 JEPC1.26 JEPC1.27 L37.2 PJP5702.1 R9444.2
+1.5V_RUN_AUDIO: C150.1 L37.1 U17.40
+1.5V_VIN: PC5701.1 PC5702.1 PC5703.1 PJP5701.1 PU5701.3
+1.5VSP: PC5705.1 PC5706.1 PC5707.1 PC5708.2 PJP5702.2 PL5701.2 PR5705.2
+1.8V_ATS: RC452.1 UC1.AA1
+1.8V_EN: PC5716.1 PR5706.2 PR5708.1 PU5702.7
+1.8V_FB: PC5717.1 PR5709.1 PR5710.1 PU5702.1
+1.8V_LX: PL5702.1 PR5707.2 PU5702.6
+1.8V_PGPPF: RC430.2 UC1.AF16
+1.8V_PRIM: C9641.1 PJP5704.1 RC388.1 RC430.1 RC431.1 RC432.1 RC452.2
+1.8V_VIN: PC5710.1 PC5711.1 PC5712.1 PJP5703.1 PU5702.3
+1.8VALWP: PC5713.1 PC5714.1 PC5715.1 PC5717.2 PJP5704.2 PL5702.2 PR5710.2
+1VALWP: PC5506.2 PC5507.1 PC5508.1 PC5509.1 PC5510.1 PJP5501.1 PJP5502.1 PL5502.2 PR5504.2
+1VALWP_VIN: PC5501.1 PC5503.1 PC5504.1 PC5505.1 PL5501.2 PU5501.8
+1VS_VCCIOP: PC5606.1 PC5607.1 PC5608.1 PJP5602.1 PL5601.2 PR5604.2 PU5601.1
+2.5V_EN: PC5722.1 PR5711.2 PR5713.1 PU5703.7
+2.5V_FB: PC5729.1 PR5714.1 PR5715.1 PU5703.1
+2.5V_LX: PL5703.1 PR5712.2 PU5703.6
+2.5V_MEM: CD85.1 CD86.1 CD89.1 CD90.1 CD134.1 CD135.1 CD136.1 CD137.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP5706.1
+2.5V_VIN: PC5719.1 PC5720.1 PC5721.1 PJP5705.1 PU5703.3
+2.5VS: PC5723.1 PC5724.1 PC5727.1 PC5729.2 PJP5706.2 PL5703.2 PR5715.2
+3.0V_RTC: C9644.1 C9645.1 RC434.2 UC1.AK19 UC1.BB14
+3.3V_1.8V_PGPPA: RC428.2 RC432.2 UC1.AK15
+3.3V_1.8V_PGPPG: RC429.2 RC431.2 UC1.AD15
+3.3V_ALW: C328.1 C348.1 C376.1 C452.1 C1002.1 C1189.1 C3083.1 C9441.1 C9457.1 C9653.1 C9919.1 C9982.1 C9985.1 CC94.1 JCSW2.2 JEDP1.40 JGFX1.43 JIOR1.12 JIOR1.13 JKB1.4 JLID1.2 JSEC1.14 JSEC1.15 JSEC1.16 PC5238.2 PJP6.1 PJP7.1 PJP5302.2 PJP5308.2 PJP5703.2 PJP5705.2 PR5102.2 PR5105.1 PR5118.2 PR5211.2 PR5218.2 PR5223.2 PR5244.1 PR5250.1 PR5254.2 PR5255.2 PR5262.2 PR5304.2 PR5601.1 PR5606.1 PR5611.2 PR5616.1 PR5617.1 PR5622.2 PU5202.5 R36.2 R196.1 R272.1 R282.1 R286.1 R288.1 R292.1 R298.1 R302.1 R322.1 R339.1 R340.1 R343.1 R344.1 R345.1 R348.1 R350.1 R359.2 R361.2 R364.2 R380.1 R386.1 R388.2 R391.1 R392.1 R393.1 R395.2 R396.2 R397.2 R398.2 R402.2 R428.1 R432.2 R454.2 R455.2 R478.2 R479.1 R2736.1 R9398.1 R9399.1 R9405.1 R9407.1 R9408.1 R9416.2 R9418.1 R9463.1 R9466.1 R9485.1 R9489.1 R9493.1 R9497.2 R9500.1 R9588.1 R9591.1 R9592.1 R9668.2 R9688.1 R9695.1 RC409.2 RC443.1 RC487.2 RC623.2 RP2.2 RP2.4 RP2.6 RP2.8 RP4810.2 RP4810.4 RP4810.8 RP4811.6 U9.1 U18.6 U18.7 U22.2 U43.1 U43.2 U43.6 U43.7 U46.1 U46.2 U46.6 U46.7 U51.1 U51.2 U51.6 U51.7 U6218.5 UC9.5 UC10.5 UC11.5 UC12.5 UC13.5 UC14.5
+3.3V_ALW2: C9921.1 PJP5306.2 PR5253.2 PR5260.1 PR7405.2 R367.2 R9575.1
+3.3V_ALW2_R: JSEC1.2 R9575.2 R9694.2 R9695.2
+3.3V_ALW_5048: C329.1 C330.1 C331.1 C332.1 C334.1 PJP6.2 U37.A17 U37.A43 U37.A54 U37.B5 U37.B30
+3.3V_ALW_DSW: C9654.1 C9655.1 C9958.1 JAPS1.3 JAPS1.7 R176.1 R9536.1 RC443.2 RC618.2 RP4808.2 RP4808.4 RP4808.6 RP4808.8 UC1.AD17 UC1.AD18 UC1.AJ17
+3.3V_ALW_PCH: C393.2 C9634.1 C9637.1 JAPS1.1 PJP5811.1 R9560.1 R9562.1 R9563.1 R9571.1 R9675.2 RC28.2 RC30.2 RC36.2 RC37.2 RC70.2 RC98.2 RC133.2 RC186.2 RC192.2 RC342.2 RC343.2 RC347.2 RC350.2 RC400.1 RC408.2 RC424.1 RC425.1 RC426.1 RC427.1 RC428.1 RC429.1 RC433.1 RC445.1 RC460.1 RC461.1 RC467.2 RC471.1 RC481.2 RC488.2 RC608.2 RC609.2 RC610.2 RC622.2 RP10.2 RP10.4 RP10.6 RP10.8 U43.8 U43.9 UC1.AJ21 UC1.V19 UC3.5
+3.3V_ALW_U38: C349.1 C350.1 C351.1 C354.1 C355.1 C356.1 PJP7.2 R336.1 R461.1 U38.A11 U38.A26 U38.A41 U38.A52 U38.B3 U38.B35
+3.3V_ALWP: PC5313.1 PJP5302.1 PJP5305.2 PJP5308.1 PL5304.2
+3.3V_CAM: C68.1 C9508.2 C9908.1 JEDP1.42 JEDP1.43 PJP803.1
+3.3V_CAM_C: C3601.1 JRCAM1.1 JRCAM1.2 PJP805.1
+3.3V_CAM_Q: PJP803.2 Q216.3
+3.3V_CAM_QC: PJP805.2 Q3601.3
+3.3V_FPM: PC7409.1 PU7402.1 R9694.1
+3.3V_FPM_EN: PR7405.1 PU7401.6 PU7402.3
+3.3V_FPM_FB: PR7403.2 PU7401.8
+3.3V_FPM_LX: PC7404.1 PL7401.1 PU7401.3
+3.3V_FPM_VIN: PC7401.1 PC7407.2 PU7401.2
+3.3V_HDA: C9960.1 RC445.2 UC1.AJ19
+3.3V_HDD: C113.1 C114.1 C9552.1 C9553.1 C9554.1 C9555.1 JSTRG1.13 JSTRG1.14 JSTRG1.15 JSTRG1.16 JSTRG1.17 PJP5810.2 R124.1 RN25.1 RN4108.1 RN4109.1 RN4110.1 RN4115.1 RN4116.1 RN4117.1 RN4122.1 RN4123.1 RN4124.1 RN4128.1 RN4129.1 RN4130.1 RN4131.1 RN4136.1 RN4137.1 RN4138.1 RN4142.1 RN4143.1 RN4144.1 U6205.12 U6205.24 U6206.12 U6206.24
+3.3V_LAN: C198.2 C426.1 C9923.1 JLAN1.A2 JLAN1.B1 R171.1 R172.1 R178.2 R181.2 R713.2 RC348.2 RC349.2 U22.3 U24.5
+3.3V_LAN_OUT: C182.1 C188.1 C9942.1 R181.1 U21.4 U21.5 U21.15 U21.19 U21.29
+3.3V_LCD_VDD: C63.1 C431.2 C9511.1 C9909.1 JEDP1.6 JEDP1.7 R9683.2 U9.6 U6223.3
+3.3V_M: C396.1 R9535.1 R9593.1 R9676.2 U43.13 U43.14
+3.3V_M_TCM: C9953.1 C9954.1 C9955.1 C9956.1 R9675.1 R9676.1 U26.9 U26.20 U26.25
+3.3V_M_TPM: C9564.1 C9565.1 C9566.1 PJP5811.2 Q4199.2 R9523.2 R9526.1 R9527.1 R9532.1 R9535.2 U25.14 U25.22
+3.3V_PGPPB: C9638.1 RC424.2 UC1.AG15
+3.3V_PGPPC: C9639.1 RC425.2 UC1.Y16
+3.3V_PGPPD: RC426.2 UC1.Y15
+3.3V_PGPPE: C9640.1 RC427.2 UC1.T16
+3.3V_RTC_LDO: PJP5307.2 RTCD1.2
+3.3V_RTCPRIM: C9642.1 C9643.1 RC433.2 UC1.AK17
+3.3V_RUN: C64.1 C403.2 C440.1 C634.1 C3053.1 C3082.1 C3603.1 C3701.1 C9207.1 C9437.1 C9442.1 C9445.1 C9446.1 C9447.1 C9448.1 C9449.1 C9450.1 C9451.1 C9512.1 C9556.1 C9557.1 C9558.1 C9911.1 C9928.1 C9931.1 CC41.1 JDEG2.1 JDEG2.3 JDOCK1.5 JDOCK1.6 JEDP1.33 JEPC1.31 JEPC1.32 JEPC1.33 JGFX1.21 JGFX1.23 JIOR1.14 JIOR1.15 JIOR1.16 JSEC1.19 OCS4801.1 OCS4801.4 PJP3301.1 PJP5701.2 PJP5810.1 PJP5812.1 PJP5815.1 PR5811.2 Q122.2 Q122.5 Q216.2 Q3601.2 QC1.2 QC1.5 QZ22.2 R35.1 R122.1 R123.1 R126.1 R360.1 R362.1 R376.1 R408.1 R419.2 R460.2 R473.2 R475.2 R2672.1 R3701.1 R3702.2 R3703.2 R9395.2 R9400.2 R9403.1 R9404.1 R9406.1 R9421.1 R9427.2 R9428.2 R9429.2 R9430.2 R9431.2 R9461.2 R9524.2 R9534.1 R9589.1 R9671.1 R9677.1 R9678.1 R9679.1 R9680.1 RC11.2 RC27.2 RC47.1 RC50.1 RC51.1 RC59.1 RC137.2 RC140.2 RC147.2 RC149.2 RC190.1 RC193.2 RC199.1 RC228.2 RC314.2 RC318.1 RC319.1 RC344.2 RC345.2 RC346.2 RC353.2 RC358.2 RC407.1 RC462.1 RC463.1 RC466.2 RC468.2 RC472.1 RC475.2 RC476.2 RC477.2 RC478.2 RC479.2 RC585.1 RC620.1 RC621.2 RD62.1 RD63.1 RD64.1 RD69.1 RD70.1 RD71.1 RP8.2 RP8.4 RP8.6 RP8.8 RP9.2 RP9.4 RP9.6 RP9.8 RP4804.5 RP4804.10 RP4806.5 RP4806.10 RP4807.2 RP4807.4 RP4807.6 RP4807.8 U46.8 U46.9 U6202.4 U6202.10 U6202.26 U6202.33 U6202.55 U6202.62 UC6.14 UC8.5
+3.3V_RUN_AUDIO: C118.1 C119.1 C120.1 C149.1 R9452.2 R9629.2 R9631.2 R9634.2 R9635.2 RC317.2 U17.3 U17.9 U18.8 U18.9
+3.3V_RUN_DIMM1: CD24.1 CD25.1 JDIMM1.255 RC318.2
+3.3V_RUN_DIMM2: CD132.1 CD133.1 JDIMM2.255 RC319.2
+3.3V_RUN_FFS: C9568.1 C9569.1 PJP5812.2 U15.2 U15.3 U15.9 U15.10
+3.3V_RUN_VDDA: C3088.1 C3091.1 C3092.1 C9856.1 L80.1 U6.C10 U6.H5 U6.H12 U6.J4 U6.K6 U6.K7
+3.3V_RUN_VDDIO: C26.1 C27.1 C28.1 C29.1 L79.2 U6.B5 U6.B6 U6.C3 U6.C4 U6.C11 U6.C12 U6.K3 U6.K4 U6.K11 U6.K12
+3.3V_RUN_VMM: C34.1 L79.1 L80.2 PJP5815.2 R44.2 R55.2 R64.2 R65.2 R74.2 R9537.2 R9538.2 R9539.2 R9570.2 R9594.2 R9636.2 R9637.2 RP6.2 RP6.4 RP6.6 RP6.8 U7.8
+3.3V_SPI: C9559.1 C9560.1 JSPI1.8 R1.1 R2.1 R9571.2 R9593.2 U1.8 U2.8 UC1.AJ16
+3.3V_SUS: C399.2 C633.1 JEPC1.29 JEPC1.30 QC2808.2 QC2808.5 R731.1 R732.1 U46.13 U46.14
+3.3V_TP: C374.1 JTP1.5 R404.1 R405.1 R9671.2
+3.3V_USBHUB: C3050.1 C3051.1 C3052.1 C3054.1 C3055.1 C3056.1 C3057.1 C3058.1 PJP3301.2 QC2807.2 QC2807.5 R2721.1 R2722.2 R2724.2 R2725.2 R2726.2 R2727.2 U92.5 U92.10 U92.15 U92.23 U92.29 U92.36
+3.3V_VTR: C346.1 C352.1 R336.2 U38.A22
+3.3V_VTR_ADC: C347.1 C353.1 R461.2 U38.A58
+3.3V_WLAN: C257.1 C258.1 C259.1 C260.1 C261.1 C262.1 C422.1 JWLAN1.2 JWLAN1.4 JWLAN1.72 JWLAN1.74 Q22.2 Q22.5 R227.1 R229.1 U51.13 U51.14
+3.3V_WWAN: C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C425.2 C9539.2 C9542.1 C9979.1 C9980.1 JPSEN1.1 JWWAN1.2 JWWAN1.4 JWWAN1.70 JWWAN1.72 JWWAN1.74 Q30.5 R216.2 R217.2 R226.1 R9453.2 RI31.1 U51.8 U51.9
+3.3VALW: PC5513.1 PR5501.2 PU5501.7
+3V/5V_PWR_SRC: PC5301.1 PC5302.1 PC5303.1 PC5305.1 PC5306.1 PC5307.1 PC5308.1 PC5309.1 PC5320.1 PC5321.1 PL5302.1 PL5303.1 PQ5301.2 PQ5301.3 PQ5301.4 PQ5301.10 PQ5302.2 PU5301.12
+5V_ALW: C288.1 C289.1 C1186.1 C1187.1 C3079.1 C3401.1 C3402.1 C3602.1 C9922.1 C9925.1 C9926.1 C9967.1 C9968.1 JIOR1.1 JIOR1.2 JIOR1.3 JIOR1.4 JIOR1.5 JIOR1.6 JIOR1.7 JIOR1.8 JIOR1.9 JIOR1.10 JLED1.11 JRCAM1.7 JRCAM1.8 JSEC1.18 JSH1.2 JSH1.3 PC5408.2 PJP5301.2 PJP5601.2 PJP5603.2 PJP5707.2 PJP5911.2 PR5108.1 PR5404.1 PR5812.1 PU1.5 PU5203.8 PU5401.12 PU5801.9 PU5801.10 Q16.2 R28.1 R9462.1 R9691.1 U18.1 U18.2 U18.4 U22.5 U32.1 U32.2 U32.4 U43.4 U45.1 U45.2 U45.4 U46.4 U51.4 U6204.1 U6204.7 U6204.8 U6217.4 U6221.3 U6222.3 US2.2 US2.3
+5V_ALW2: C9920.1 PC5304.1 PU5301.13 R9574.1
+5V_ALW2_R: JSEC1.17 R9574.2
+5V_ALWP: PC5312.1 PJP5301.1 PJP5303.1 PJP5304.1 PJP5911.1 PL5301.1
+5V_GPS: C9918.1 JGPS1.4 PJP5806.1
+5V_GPS_Q: PJP5806.2 Q3604.3
+5V_HDD: C111.1 C112.1 JSTRG1.6 JSTRG1.7 JSTRG1.8 JSTRG1.9 PJP5809.2 R125.2
+5V_HDMI_DDC_SCL: D65.2 R471.2 R472.1
+5V_HDMI_DDC_SDA: D64.2 R470.2
+5V_ODD: C430.1 C3004.1 C3005.1 JODD1.11 JODD1.12 JODD1.13 PJP802.1 U32.7 U32.8
+5V_RUN: C61.1 C208.1 C333.1 C375.1 C400.2 C645.1 C9462.1 C9463.1 C9464.1 C9855.1 C9905.1 C9927.1 D64.1 D65.1 D68.1 FANF1.2 HDMIU1.3 JEPC1.34 JEPC1.35 JEPC1.36 JEPC1.37 JGFX1.49 JIOR1.11 JKB1.5 JSEC1.20 PC5901.1 PC5915.1 PC5925.1 PJP802.2 PJP5809.1 PU5901.2 PU5902.6 PU5903.2 Q1.2 Q3604.2 R94.2 R355.1 R356.1 R357.1 R385.1 R472.2 R9396.2 R9414.2 U45.13 U45.14 U6203.26
+5V_RUN_AUDIO: C151.1 L21.2 R130.1 U18.13 U18.14
+5V_RUN_CRT: CRTF1.1 D68.3 R2739.1 R2740.2 R2742.2 R2747.1 R2748.1
+5V_RUN_PVDD: C122.1 C123.1 C128.1 C129.1 R130.2 U17.41 U17.46
+5V_TSP: C62.1 C9509.1 C9907.1 JEDP1.30 PJP10.1
+5V_TSP_Q: PJP10.2 Q1.3
+5V_USB: C4.1 C8.1 C3080.1 C9952.1 JUSB2.1 US2.6 US2.7 US2.8
+5V_USB_CHG_PWR: C290.1 C291.1 C809.1 JUSB1.1 U6204.12
+P1.0V_PEX_VDD: C9443.1 C9444.1 JGFX1.31 JGFX1.33 JGFX1.35 PJP5502.2
+VCC_1P8: CC269.1 RC388.2 UC1.U11 UC1.U12
+VCC_CORE: C9975.1 C9976.1 PC5912.1 PC5929.1 PC6001.1 PC6003.1 PC6004.1 PC6005.1 PC6006.1 PC6007.1 PC6008.1 PC6009.1 PC6010.1 PC6011.1 PC6012.1 PC6013.1 PC6035.1 PC6038.1 PC6040.1 PC6041.1 PC6042.1 PC6043.1 PC6056.1 PC6057.1 PC6058.1 PC6059.1 PC6060.1 PC6061.1 PC6062.1 PC6063.1 PC6064.1 PC6065.1 PC6072.1 PC6083.1 PC6084.1 PC6085.1 PC6086.1 PC6087.1 PC6088.1 PC6089.1 PC6090.1 PC6091.1 PC6092.1 PC6103.1 PC6104.1 PC6105.1 PC6106.1 PC6107.1 PC6108.1 PC6109.1 PC6110.1 PC6111.1 PC6112.1 PC6117.1 PC6118.1 PC6119.1 PC6120.1 PC6121.1 PC6122.1 PC6123.1 PC6126.1 PC6127.1 PC6128.1 PC6129.1 PC6130.1 PC6131.1 PC6132.1 PC6134.1 PC6135.1 PC6138.1 PC6141.1 PC6142.1 PJP5902.2 PL5901.2 RC250.1 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_GT: C9969.1 C9970.1 PC5927.1 PC5930.1 PC6014.1 PC6015.1 PC6016.1 PC6017.1 PC6018.1 PC6019.1 PC6020.1 PC6021.1 PC6022.1 PC6023.1 PC6026.1 PC6027.1 PC6029.1 PC6044.1 PC6045.1 PC6046.1 PC6047.1 PC6048.1 PC6049.1 PC6050.1 PC6051.1 PC6052.1 PC6053.1 PC6066.1 PC6067.1 PC6068.1 PC6069.1 PC6070.1 PC6071.1 PC6073.1 PC6074.1 PC6075.1 PC6093.1 PC6094.1 PC6095.1 PC6096.1 PC6097.1 PC6098.1 PC6099.1 PC6100.1 PC6101.1 PC6102.1 PC6113.1 PC6114.1 PC6115.1 PC6116.1 PC6139.1 PJP5906.2 PL5906.2 RC448.1 UC1.A48 UC1.A53 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K48 UC1.K50 UC1.K52 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GTX: UC1.AK42 UC1.AK43 UC1.AK45 UC1.AK46 UC1.AK48 UC1.AK50 UC1.AK52 UC1.AK53 UC1.AK55 UC1.AK56 UC1.AK58 UC1.AK60 UC1.AK70 UC1.AL43 UC1.AL46 UC1.AL50 UC1.AL53 UC1.AL56 UC1.AL60 UC1.AM48 UC1.AM50 UC1.AM52 UC1.AM53 UC1.AM56 UC1.AM58
+VCC_SA: PC6024.1 PC6025.1 PC6076.1 PC6077.1 PC6078.1 PC6079.1 PC6080.1 PC6081.1 PC6082.1 PC6125.1 PC6133.1 PC6136.1 PC6137.1 PC6140.1 PC6143.1 PC6144.1 PC6145.1 PC6146.1 PC6147.1 PJP5904.2 PL5905.2 RC422.1 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VCC_SFR_OC: C9610.1 C9984.1 RC453.2 U6222.6 UC1.AL23
+VDDA_AVDD1: C115.1 C9432.1 L21.1 U17.27
+VDDA_PVDD: C9903.1 C9904.1 R9629.1 U17.38
GND: C4.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C34.2 C42.2 C43.2 C50.2 C52.2 C61.2 C62.2 C63.2 C64.2 C65.2 C68.2 C76.1 C85.1 C87.2 C88.2 C111.2 C112.2 C113.2 C114.2 C117.2 C118.2 C119.2 C120.2 C122.2 C123.2 C124.2 C125.2 C128.2 C129.2 C135.2 C136.2 C139.2 C147.1 C148.1 C149.2 C151.2 C180.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C198.1 C208.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C266.2 C288.2 C289.2 C290.2 C291.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C336.2 C337.2 C339.2 C340.1 C342.1 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C360.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C371.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C389.2 C390.2 C391.2 C393.1 C395.1 C396.2 C397.2 C398.2 C399.1 C400.1 C401.2 C402.2 C403.1 C409.2 C410.2 C413.2 C422.2 C425.1 C426.2 C427.2 C430.2 C431.1 C440.2 C452.2 C633.2 C634.2 C635.2 C645.2 C809.2 C1002.2 C1186.2 C1187.2 C1189.2 C2750.1 C2800.2 C2801.2 C2802.2 C2803.2 C2805.2 C3004.2 C3005.2 C3050.2 C3051.2 C3052.2 C3053.2 C3054.2 C3055.2 C3056.2 C3057.2 C3058.2 C3059.2 C3060.2 C3061.2 C3062.2 C3063.2 C3079.2 C3080.2 C3082.2 C3083.2 C3084.2 C3085.2 C3086.2 C3087.2 C3088.2 C3091.2 C3092.2 C3093.2 C3094.2 C3401.2 C3402.2 C3601.2 C3602.2 C3603.2 C3701.2 C9207.2 C9430.2 C9433.2 C9437.2 C9438.2 C9439.2 C9440.2 C9441.2 C9442.2 C9443.2 C9444.2 C9445.2 C9446.2 C9447.2 C9448.2 C9449.2 C9450.2 C9451.2 C9454.2 C9456.2 C9457.2 C9458.2 C9459.2 C9462.2 C9463.2 C9464.2 C9491.1 C9492.1 C9493.2 C9494.2 C9495.2 C9505.2 C9506.2 C9507.2 C9508.1 C9509.2 C9510.2 C9511.2 C9512.2 C9513.2 C9514.2 C9525.2 C9526.2 C9527.2 C9528.2 C9539.1 C9540.1 C9541.1 C9542.2 C9543.2 C9544.2 C9552.2 C9553.2 C9554.2 C9555.2 C9556.2 C9557.2 C9558.2 C9559.2 C9560.2 C9562.2 C9563.2 C9564.2 C9565.2 C9566.2 C9567.2 C9568.2 C9569.2 C9606.2 C9607.2 C9608.2 C9609.2 C9610.2 C9611.2 C9612.2 C9613.2 C9614.2 C9615.2 C9616.2 C9617.2 C9618.2 C9619.2 C9620.2 C9621.2 C9622.2 C9623.2 C9624.2 C9625.2 C9626.2 C9627.2 C9628.2 C9629.2 C9630.2 C9631.2 C9632.2 C9633.2 C9634.2 C9635.2 C9636.2 C9637.2 C9638.2 C9639.2 C9640.2 C9641.2 C9642.2 C9643.2 C9644.2 C9645.2 C9647.2 C9648.2 C9649.2 C9650.2 C9653.2 C9654.2 C9655.2 C9656.2 C9657.2 C9658.2 C9659.2 C9660.2 C9663.2 C9664.2 C9665.2 C9666.2 C9840.2 C9841.2 C9842.1 C9843.1 C9851.2 C9855.2 C9856.2 C9884.2 C9885.2 C9886.2 C9887.2 C9888.2 C9889.2 C9899.2 C9900.2 C9905.2 C9906.1 C9907.2 C9908.2 C9909.2 C9910.2 C9911.2 C9912.2 C9913.2 C9914.2 C9915.2 C9916.2 C9917.2 C9918.2 C9919.2 C9920.2 C9921.2 C9922.2 C9923.2 C9924.2 C9925.2 C9926.2 C9927.2 C9928.2 C9929.2 C9930.2 C9931.2 C9941.2 C9942.2 C9943.2 C9944.2 C9945.2 C9946.2 C9947.2 C9950.1 C9952.2 C9953.2 C9954.2 C9955.2 C9956.2 C9957.1 C9958.2 C9959.2 C9960.2 C9961.2 C9962.2 C9963.2 C9964.2 C9965.2 C9966.2 C9967.2 C9968.2 C9969.2 C9970.2 C9971.2 C9972.2 C9973.2 C9974.2 C9975.2 C9976.2 C9977.2 C9978.2 C9979.2 C9980.2 C9981.2 C9982.2 C9983.2 C9984.2 C9985.2 C9986.2 CC5.1 CC6.2 CC7.2 CC10.2 CC11.2 CC24.2 CC25.1 CC26.2 CC41.2 CC57.1 CC80.1 CC89.2 CC90.2 CC91.2 CC92.2 CC93.2 CC94.2 CC266.2 CC267.2 CC268.2 CC269.2 CC270.1 CC271.1 CC272.2 CC273.2 CC275.1 CC276.1 CC277.1 CC278.1 CC279.1 CC280.1 CC281.1 CC282.1 CC284.1 CC285.1 CC286.1 CC287.1 CC288.1 CC289.1 CC290.1 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD34.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD85.2 CD86.2 CD89.2 CD90.2 CD93.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD132.2 CD133.2 CD134.2 CD135.2 CD136.2 CD137.2 CE1.2 CE2.2 CE14.2 CE22.2 CMOS1.2 D1.1 D4.2 D17.3 D22.2 D25.2 D66.2 D67.2 D69.2 D2301.3 D2302.3 D2800.2 D2801.2 D7108.2 D7109.2 D7113.2 D7119.2 D7120.2 D7121.2 D7122.2 H1.1 H2.1 H3.1 H5.1 H6.1 H7.1 H8.1 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H15.1 H16.1 H17.1 H18.1 H19.1 H20.1 H21.1 H22.1 H23.1 HDMIU1.1 JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JBAT1.8 JBAT1.10 JBAT1.11 JBAT1.12 JBAT1.13 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JCSW1.2 JCSW1.6 JCSW1.7 JCSW1.8 JCSW2.4 JCSW2.5 JCSW2.6 JDCIN1.5 JDCIN1.6 JDCIN1.7 JDEG1.10 JDEG1.11 JDEG1.12 JDEG2.9 JDEG2.11 JDEG2.13 JDEG2.14 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.263 JDIMM1.264 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.263 JDIMM2.264 JDOCK1.12 JDOCK1.15 JDOCK1.18 JDOCK1.21 JDOCK1.24 JDOCK1.27 JDOCK1.30 JDOCK1.33 JDOCK1.36 JDOCK1.39 JDOCK1.40 JDOCK1.41 JDOCK1.42 JDOCK1.43 JDOCK1.44 JDOCK1.45 JDOCK1.56 JDOCK1.57 JDOCK1.58 JEDP1.8 JEDP1.9 JEDP1.10 JEDP1.11 JEDP1.16 JEDP1.19 JEDP1.22 JEDP1.25 JEDP1.26 JEDP1.29 JEDP1.35 JEDP1.41 JEDP1.45 JEDP1.48 JEDP1.51 JEDP1.52 JEDP1.53 JEDP1.54 JEDP1.55 JEPC1.2 JEPC1.5 JEPC1.8 JEPC1.11 JEPC1.14 JEPC1.17 JEPC1.20 JEPC1.23 JEPC1.24 JEPC1.39 JEPC1.40 JFAN1.1 JFAN1.5 JFAN1.6 JGFX1.3 JGFX1.9 JGFX1.10 JGFX1.12 JGFX1.13 JGFX1.15 JGFX1.17 JGFX1.18 JGFX1.19 JGFX1.24 JGFX1.25 JGFX1.27 JGFX1.29 JGFX1.30 JGFX1.36 JGFX1.37 JGFX1.39 JGFX1.41 JGFX1.42 JGFX1.44 JGFX1.45 JGFX1.46 JGFX1.47 JGFX1.48 JGFX1.51 JGFX1.53 JGFX1.54 JGFX1.60 JGFX1.63 JGFX1.66 JGFX1.71 JGFX1.72 JGFX1.74 JGFX1.79 JGFX1.80 JGPS1.1 JGPS1.5 JGPS1.6 JGPS1.7 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JHS1.9 JHS1.10 JHS1.11 JHS1.12 JIOR1.19 JIOR1.28 JIOR1.34 JIOR1.41 JIOR1.44 JIOR1.47 JIOR1.50 JIOR1.53 JIOR1.54 JIOR1.55 JIOR1.56 JIOR1.57 JIOR1.58 JKB1.8 JKB1.10 JKB1.11 JKB1.12 JLAN1.9 JLAN1.10 JLED1.2 JLED1.5 JLED1.12 JLED1.13 JLED1.14 JLID1.4 JLID1.5 JLID1.6 JLID1.7 JLID1.8 JODD1.1 JODD1.2 JODD1.5 JODD1.8 JODD1.10 JODD1.14 JODD1.16 JODD1.17 JODD1.18 JPSEN1.4 JPSEN1.5 JPSEN1.6 JRCAM1.3 JRCAM1.9 JRCAM1.10 JRCAM1.11 JRCAM1.12 JRTC1.1 JRTC1.3 JRTC1.4 JSEC1.6 JSEC1.7 JSEC1.10 JSEC1.24 JSEC1.25 JSEC1.27 JSEC1.28 JSEC1.29 JSEC1.30 JSER1.5 JSER1.10 JSER1.11 JSH1.6 JSH1.9 JSH1.11 JSH1.16 JSH1.17 JSH1.18 JSIMUAJ1.11 JSIMUAJ1.12 JSIMUAJ1.21 JSIMUAJ1.22 JSPI1.4 JSPK1.5 JSPK1.6 JSTRG1.1 JSTRG1.2 JSTRG1.5 JSTRG1.10 JSTRG1.18 JSTRG1.21 JSTRG1.24 JSTRG1.27 JSTRG1.30 JSTRG1.33 JSTRG1.36 JSTRG1.39 JSTRG1.40 JSTRG1.41 JSTRG1.42 JTAG1.2 JTP1.1 JTP1.8 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.5 JUSB2.6 JUSB2.7 JUSB2.8 JWLAN1.7 JWLAN1.18 JWLAN1.33 JWLAN1.39 JWLAN1.45 JWLAN1.51 JWLAN1.57 JWLAN1.63 JWLAN1.76 JWLAN1.77 JWWAN1.3 JWWAN1.5 JWWAN1.11 JWWAN1.27 JWWAN1.33 JWWAN1.39 JWWAN1.45 JWWAN1.51 JWWAN1.57 JWWAN1.71 JWWAN1.73 JWWAN1.76 JWWAN1.77 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 ME1.2 OCS4801.2 PC5101.2 PC5102.2 PC5103.2 PC5104.2 PC5105.2 PC5106.2 PC5107.2 PC5108.2 PC5201.2 PC5203.2 PC5204.2 PC5205.2 PC5206.2 PC5207.2 PC5208.2 PC5209.2 PC5210.2 PC5211.2 PC5212.2 PC5213.2 PC5214.2 PC5215.2 PC5216.2 PC5217.2 PC5218.2 PC5219.2 PC5220.2 PC5221.2 PC5222.1 PC5223.2 PC5224.1 PC5225.2 PC5227.2 PC5228.2 PC5229.2 PC5230.2 PC5231.2 PC5233.2 PC5234.1 PC5235.2 PC5236.2 PC5237.1 PC5238.1 PC5239.2 PC5240.1 PC5241.1 PC5301.2 PC5302.2 PC5303.2 PC5304.2 PC5305.2 PC5306.2 PC5307.2 PC5308.2 PC5309.2 PC5312.2 PC5313.2 PC5314.2 PC5315.2 PC5318.2 PC5319.2 PC5320.2 PC5321.2 PC5401.2 PC5402.2 PC5403.2 PC5404.2 PC5406.2 PC5407.2 PC5408.1 PC5409.2 PC5410.2 PC5411.2 PC5412.2 PC5414.2 PC5415.2 PC5416.2 PC5501.2 PC5503.2 PC5504.2 PC5505.2 PC5507.2 PC5508.2 PC5509.2 PC5510.2 PC5511.2 PC5512.2 PC5513.2 PC5514.2 PC5601.1 PC5602.2 PC5603.2 PC5604.2 PC5605.2 PC5606.2 PC5607.2 PC5608.2 PC5609.1 PC5610.2 PC5611.1 PC5612.2 PC5613.2 PC5614.2 PC5615.2 PC5616.2 PC5617.2 PC5618.2 PC5619.1 PC5620.2 PC5701.2 PC5702.2 PC5703.2 PC5704.2 PC5705.2 PC5706.2 PC5707.2 PC5709.2 PC5710.2 PC5711.2 PC5712.2 PC5713.2 PC5714.2 PC5715.2 PC5716.2 PC5718.2 PC5719.2 PC5720.2 PC5721.2 PC5722.2 PC5723.2 PC5724.2 PC5725.2 PC5726.2 PC5727.2 PC5728.2 PC5730.2 PC5731.2 PC5732.2 PC5734.2 PC5735.2 PC5736.2 PC5737.2 PC5738.2 PC5739.2 PC5801.2 PC5802.1 PC5803.1 PC5804.1 PC5805.2 PC5808.2 PC5809.1 PC5812.1 PC5814.1 PC5815.1 PC5816.1 PC5817.1 PC5820.1 PC5822.1 PC5824.1 PC5825.1 PC5826.1 PC5828.2 PC5835.2 PC5836.2 PC5837.2 PC5839.1 PC5840.1 PC5842.1 PC5843.1 PC5901.2 PC5902.2 PC5903.2 PC5904.2 PC5905.2 PC5906.2 PC5908.2 PC5910.2 PC5911.2 PC5912.2 PC5913.2 PC5914.2 PC5915.2 PC5916.2 PC5917.2 PC5918.2 PC5919.2 PC5920.2 PC5921.2 PC5922.2 PC5924.2 PC5925.2 PC5927.2 PC5928.2 PC5929.2 PC5930.2 PC5931.2 PC5932.2 PC6001.2 PC6003.2 PC6004.2 PC6005.2 PC6006.2 PC6007.2 PC6008.2 PC6009.2 PC6010.2 PC6011.2 PC6012.2 PC6013.2 PC6014.2 PC6015.2 PC6016.2 PC6017.2 PC6018.2 PC6019.2 PC6020.2 PC6021.2 PC6022.2 PC6023.2 PC6024.2 PC6025.2 PC6026.2 PC6027.2 PC6029.2 PC6035.2 PC6038.2 PC6040.2 PC6041.2 PC6042.2 PC6043.2 PC6044.2 PC6045.2 PC6046.2 PC6047.2 PC6048.2 PC6049.2 PC6050.2 PC6051.2 PC6052.2 PC6053.2 PC6056.2 PC6057.2 PC6058.2 PC6059.2 PC6060.2 PC6061.2 PC6062.2 PC6063.2 PC6064.2 PC6065.2 PC6066.2 PC6067.2 PC6068.2 PC6069.2 PC6070.2 PC6071.2 PC6072.2 PC6073.2 PC6074.2 PC6075.2 PC6076.2 PC6077.2 PC6078.2 PC6079.2 PC6080.2 PC6081.2 PC6082.2 PC6083.2 PC6084.2 PC6085.2 PC6086.2 PC6087.2 PC6088.2 PC6089.2 PC6090.2 PC6091.2 PC6092.2 PC6093.2 PC6094.2 PC6095.2 PC6096.2 PC6097.2 PC6098.2 PC6099.2 PC6100.2 PC6101.2 PC6102.2 PC6103.2 PC6104.2 PC6105.2 PC6106.2 PC6107.2 PC6108.2 PC6109.2 PC6110.2 PC6111.2 PC6112.2 PC6113.2 PC6114.2 PC6115.2 PC6116.2 PC6117.2 PC6118.2 PC6119.2 PC6120.2 PC6121.2 PC6122.2 PC6123.2 PC6125.2 PC6126.2 PC6127.2 PC6128.2 PC6129.2 PC6130.2 PC6131.2 PC6132.2 PC6133.2 PC6134.2 PC6135.2 PC6136.2 PC6137.2 PC6138.2 PC6139.2 PC6140.2 PC6141.2 PC6142.2 PC6143.2 PC6144.2 PC6145.2 PC6146.2 PC6147.2 PC7401.2 PC7403.2 PC7406.2 PC7409.2 PD5101.2 PD5102.2 PD5103.2 PH5801.1 PH5804.1 PJP5909.2 PQ5102.2 PQ5104.1 PQ5106.1 PQ5106.4 PQ5202.1 PQ5202.4 PQ5209.2 PQ5210.1 PQ5210.4 PQ5211.2 PQ5212.2 PQ5214.1 PQ5214.4 PQ5215.2 PQ5216.2 PQ5217.2 PQ5218.5 PQ5218.6 PQ5218.7 PQ5220.1 PQ5220.4 PQ5301.5 PQ5301.6 PQ5301.7 PQ5302.5 PQ5302.6 PQ5302.7 PQ5401.5 PQ5401.6 PQ5401.7 PQ5902.5 PQ5902.6 PQ5902.7 PR5110.1 PR5113.1 PR5116.2 PR5224.1 PR5225.2 PR5227.1 PR5232.2 PR5240.2 PR5248.1 PR5258.2 PR5259.1 PR5261.1 PR5307.1 PR5308.1 PR5311.1 PR5312.1 PR5408.2 PR5506.1 PR5508.1 PR5509.2 PR5602.1 PR5608.2 PR5609.2 PR5612.2 PR5619.2 PR5620.2 PR5623.2 PR5703.2 PR5704.2 PR5708.2 PR5709.2 PR5713.2 PR5714.2 PR5716.2 PR5717.2 PR5801.1 PR5816.1 PR5819.1 PR5828.2 PR5833.1 PR5834.1 PR5842.1 PR5914.1 PR5916.1 PR6091.2 PR7401.1 PR7406.2 PR7408.2 PU1.2 PU5201.22 PU5201.29 PU5201.30 PU5201.31 PU5201.32 PU5201.33 PU5202.3 PU5203.4 PU5301.21 PU5301.22 PU5301.23 PU5401.1 PU5401.3 PU5401.14 PU5401.21 PU5401.22 PU5401.23 PU5501.9 PU5601.6 PU5601.15 PU5601.16 PU5601.17 PU5601.18 PU5601.19 PU5601.20 PU5601.21 PU5602.6 PU5602.15 PU5602.16 PU5602.17 PU5602.18 PU5602.19 PU5602.20 PU5602.21 PU5701.4 PU5701.8 PU5701.9 PU5701.10 PU5701.11 PU5701.12 PU5701.13 PU5702.4 PU5702.8 PU5702.9 PU5702.10 PU5702.11 PU5702.12 PU5702.13 PU5703.4 PU5703.8 PU5703.9 PU5703.10 PU5703.11 PU5703.12 PU5703.13 PU5801.41 PU5801.42 PU5801.43 PU5801.44 PU5801.45 PU5801.46 PU5801.47 PU5801.48 PU5801.49 PU5901.3 PU5901.9 PU5901.10 PU5901.11 PU5901.12 PU5901.13 PU5901.14 PU5901.15 PU5901.16 PU5901.17 PU5902.4 PU5902.9 PU5902.10 PU5903.3 PU5903.9 PU5903.10 PU5903.11 PU5903.12 PU5903.13 PU5903.14 PU5903.15 PU5903.16 PU5903.17 PU5904.4 PU5904.8 PU5904.9 PU5904.10 PU5904.11 PU5904.12 PU5904.13 PU7401.4 PU7402.5 PU7402.7 Q4.2 Q5.1 Q5.4 Q17.1 Q17.4 Q19.1 Q19.4 Q1701.2 Q3605.1 Q3607.2 Q3610.3 Q4200.2 QZ22.4 R32.2 R34.1 R47.2 R95.1 R96.1 R175.2 R182.1 R184.1 R185.1 R195.1 R268.2 R309.1 R310.1 R321.2 R354.1 R366.1 R368.1 R370.2 R371.1 R372.1 R373.1 R377.1 R383.2 R384.1 R394.1 R399.2 R438.1 R474.2 R801.2 R802.2 R803.2 R2677.2 R2720.2 R2729.1 R2730.1 R2732.1 R2744.1 R2745.1 R2746.1 R2810.2 R4104.1 R9394.2 R9415.1 R9417.1 R9446.1 R9454.1 R9483.2 R9486.2 R9492.1 R9529.1 R9542.2 R9543.2 R9544.2 R9583.1 R9587.1 R9615.2 R9616.2 R9617.2 R9638.1 R9648.1 R9673.1 R9684.1 R9690.1 R9692.1 RC20.2 RC21.2 RC48.2 RC69.2 RC83.2 RC88.2 RC89.2 RC90.2 RC91.2 RC96.1 RC114.1 RC128.2 RC132.2 RC153.2 RC155.2 RC156.2 RC158.2 RC169.1 RC191.1 RC198.1 RC227.1 RC260.2 RC305.2 RC306.2 RC324.2 RC338.2 RC339.2 RC359.1 RC360.1 RC369.1 RC374.1 RC383.2 RC384.1 RC385.1 RC387.1 RC390.1 RC393.1 RC395.1 RC396.1 RC398.1 RC399.1 RC421.2 RC423.2 RC449.2 RC480.2 RC584.1 RC593.2 RC617.2 RD66.2 RD67.2 RD68.2 RD72.2 RD73.2 RD74.2 RN31.1 RN4107.2 RN4111.2 RN4112.2 RN4113.2 RN4114.2 RN4119.2 RN4120.2 RN4121.2 RN4125.2 RN4126.2 RN4127.2 RN4132.2 RN4133.2 RN4134.2 RN4135.2 RN4139.2 RN4140.2 RN4141.2 RN4145.2 RN4146.2 RN4147.2 SW5.2 U1.4 U2.4 U5.3 U6.C5 U6.C13 U6.C14 U6.D4 U6.D5 U6.D6 U6.D7 U6.D8 U6.D9 U6.D10 U6.D11 U6.D13 U6.D14 U6.E4 U6.E11 U6.F4 U6.F5 U6.F6 U6.F7 U6.F8 U6.F9 U6.F10 U6.F11 U6.G4 U6.G5 U6.G6 U6.G7 U6.G8 U6.G9 U6.G10 U6.G11 U6.H4 U6.H10 U6.J5 U6.J6 U6.J7 U6.J8 U6.J9 U6.J11 U6.J12 U6.K5 U6.L6 U6.L7 U6.L8 U7.4 U9.2 U15.5 U15.6 U15.7 U15.8 U17.49 U17.50 U17.51 U17.52 U17.53 U17.54 U17.55 U17.56 U17.57 U17.58 U18.11 U18.15 U21.49 U21.50 U21.51 U21.52 U21.53 U22.1 U24.3 U25.9 U25.16 U25.23 U25.32 U25.33 U26.11 U26.16 U26.26 U26.32 U26.33 U32.5 U32.9 U37.B27 U37.C1 U37.C2 U37.C3 U37.C4 U37.C5 U37.C6 U37.C7 U37.C8 U37.C9 U37.C10 U38.B11 U38.B18 U38.B54 U38.B60 U38.B66 U38.C1 U38.C2 U38.C3 U38.C4 U38.C5 U38.C6 U38.C7 U38.C8 U38.C9 U38.C10 U43.11 U43.15 U45.11 U45.15 U46.11 U46.15 U51.11 U51.15 U92.11 U92.37 U92.38 U92.39 U92.40 U92.41 U92.42 U92.43 U92.44 U92.45 U6202.2 U6202.34 U6202.63 U6202.65 U6202.66 U6202.67 U6202.68 U6202.69 U6202.70 U6202.71 U6202.72 U6202.73 U6203.25 U6204.14 U6204.17 U6205.7 U6205.25 U6205.26 U6205.27 U6205.28 U6205.29 U6206.7 U6206.25 U6206.26 U6206.27 U6206.28 U6206.29 U6207.1 U6207.4 U6217.11 U6217.15 U6218.3 U6221.5 U6222.5 U6223.1 UC1.A5 UC1.A67 UC1.A70 UC1.AA2 UC1.AA4 UC1.AA65 UC1.AA68 UC1.AB8 UC1.AB15 UC1.AB16 UC1.AB18 UC1.AB21 UC1.AD8 UC1.AD13 UC1.AD16 UC1.AD19 UC1.AD20 UC1.AD21 UC1.AD62 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 UC1.AF1 UC1.AF2 UC1.AF4 UC1.AF10 UC1.AF15 UC1.AF17 UC1.AF63 UC1.AG16 UC1.AG17 UC1.AG18 UC1.AG19 UC1.AG20 UC1.AG21 UC1.AG71 UC1.AH6 UC1.AH13 UC1.AH63 UC1.AH64 UC1.AH67 UC1.AJ4 UC1.AJ15 UC1.AJ18 UC1.AJ20 UC1.AK8 UC1.AK11 UC1.AK16 UC1.AK18 UC1.AK21 UC1.AK22 UC1.AK27 UC1.AK63 UC1.AK68 UC1.AK69 UC1.AL2 UC1.AL4 UC1.AL28 UC1.AL32 UC1.AL35 UC1.AL38 UC1.AL45 UC1.AL48 UC1.AL52 UC1.AL55 UC1.AL58 UC1.AL64 UC1.AL65 UC1.AL66 UC1.AM8 UC1.AM13 UC1.AM21 UC1.AM25 UC1.AM27 UC1.AM43 UC1.AM45 UC1.AM46 UC1.AM55 UC1.AM60 UC1.AM61 UC1.AM68 UC1.AM71 UC1.AN20 UC1.AN23 UC1.AN28 UC1.AN30 UC1.AN32 UC1.AN33 UC1.AN35 UC1.AN37 UC1.AN38 UC1.AN40 UC1.AN42 UC1.AN58 UC1.AN63 UC1.AP10 UC1.AP18 UC1.AP20 UC1.AP23 UC1.AP28 UC1.AP32 UC1.AP35 UC1.AP38 UC1.AP42 UC1.AP58 UC1.AP63 UC1.AP68 UC1.AP70 UC1.AR5 UC1.AR8 UC1.AR11 UC1.AR15 UC1.AR16 UC1.AR20 UC1.AR23 UC1.AR28 UC1.AR35 UC1.AR42 UC1.AR43 UC1.AR45 UC1.AR46 UC1.AR48 UC1.AR50 UC1.AR52 UC1.AR53 UC1.AR55 UC1.AR58 UC1.AR63 UC1.AT2 UC1.AT4 UC1.AT20 UC1.AT23 UC1.AT28 UC1.AT35 UC1.AT42 UC1.AT56 UC1.AT58 UC1.AT63 UC1.AT68 UC1.AT71 UC1.AU10 UC1.AU15 UC1.AU20 UC1.AU32 UC1.AU38 UC1.AV1 UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 UC1.AW6 UC1.AW8 UC1.AW10 UC1.AW12 UC1.AW14 UC1.AW16 UC1.AW18 UC1.AW21 UC1.AW23 UC1.AW26 UC1.AW28 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AW41 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51 UC1.AW53 UC1.AW55 UC1.AW57 UC1.AW60 UC1.AW62 UC1.AW64 UC1.AW66 UC1.AY3 UC1.AY66 UC1.AY71 UC1.B10 UC1.B14 UC1.B18 UC1.B22 UC1.B30 UC1.B34 UC1.B39 UC1.B44 UC1.B48 UC1.B53 UC1.B58 UC1.B62 UC1.B66 UC1.B71 UC1.BA1 UC1.BA2 UC1.BA6 UC1.BA10 UC1.BA14 UC1.BA18 UC1.BA23 UC1.BA28 UC1.BA32 UC1.BA36 UC1.BA41 UC1.BA45 UC1.BA49 UC1.BA53 UC1.BA57 UC1.BA62 UC1.BA66 UC1.BA71 UC1.BB6 UC1.BB18 UC1.BB26 UC1.BB30 UC1.BB34 UC1.BB38 UC1.BB43 UC1.BB55 UC1.BB60 UC1.BB64 UC1.BB67 UC1.BB70 UC1.C1 UC1.C5 UC1.C25 UC1.D6 UC1.D10 UC1.D11 UC1.D14 UC1.D18 UC1.D22 UC1.D25 UC1.D26 UC1.D30 UC1.D34 UC1.D39 UC1.D44 UC1.D45 UC1.D47 UC1.D48 UC1.D53 UC1.D58 UC1.D62 UC1.D66 UC1.D69 UC1.E6 UC1.E11 UC1.E15 UC1.E18 UC1.E21 UC1.E46 UC1.E50 UC1.E53 UC1.E56 UC1.E65 UC1.E71 UC1.F1 UC1.F2 UC1.F4 UC1.F8 UC1.F13 UC1.F22 UC1.F23 UC1.F27 UC1.F28 UC1.F32 UC1.F33 UC1.F35 UC1.F37 UC1.F38 UC1.F40 UC1.F42 UC1.F68 UC1.G5 UC1.G6 UC1.G10 UC1.G22 UC1.G43 UC1.G45 UC1.G48 UC1.G52 UC1.G55 UC1.G58 UC1.G60 UC1.G63 UC1.G66 UC1.H15 UC1.H18 UC1.H71 UC1.J8 UC1.J11 UC1.J13 UC1.J25 UC1.J28 UC1.J32 UC1.J35 UC1.J38 UC1.J42 UC1.K16 UC1.K18 UC1.K22 UC1.K61 UC1.K63 UC1.K64 UC1.K65 UC1.K66 UC1.K67 UC1.K68 UC1.K70 UC1.K71 UC1.L2 UC1.L4 UC1.L8 UC1.L11 UC1.L16 UC1.L17 UC1.L18 UC1.L20 UC1.N6 UC1.N10 UC1.N13 UC1.N19 UC1.N21 UC1.N65 UC1.N68 UC1.P17 UC1.P19 UC1.P20 UC1.P21 UC1.R6 UC1.R13 UC1.T2 UC1.T4 UC1.T15 UC1.T17 UC1.T18 UC1.T21 UC1.U10 UC1.U63 UC1.U64 UC1.U66 UC1.U67 UC1.U69 UC1.U70 UC1.V16 UC1.V17 UC1.V18 UC1.W6 UC1.W9 UC1.W13 UC1.Y17 UC1.Y19 UC1.Y20 UC1.Y21 UC3.3 UC6.7 UC6.15 UC8.3 UC9.3 UC10.3 UC11.3 UC12.3 UC13.3 UC14.3 US2.1 X1.2 X1.4 Y1.2 Y1.4
GNDA: C115.2 C131.2 C137.2 C150.2 C385.2 C9432.2 C9897.2 C9898.2 C9901.2 C9903.2 C9904.2 JSIMUAJ1.5 JSIMUAJ1.9 JSIMUAJ1.10 JSIMUAJ1.19 JSIMUAJ1.20 PJP5909.1 Q217.2 Q3606.2 Q4209.1 Q4209.4 R163.2 R9615.1 R9616.1 R9617.1 R9627.2 U17.26 U17.37
VCC_GT_SENSE: PC5813.1 PC5821.1 PC5822.2 PR5826.2 RC448.2 UC1.J70
VCC_SW: C9973.1 C9974.1 PJP5901.2 PL5901.1 PR5902.2 PU5901.4
VCC_VIN: C9977.1 C9978.1 PC5902.1 PC5903.1 PC5904.1 PC5905.1 PC5906.1 PC5908.1 PC5932.1 PL5902.1 PU5901.5
VCCIO_SENSE: PR5603.2 RC420.2 UC1.AM23
VCCSENSE: PC5838.1 PC5840.2 PC5841.2 PR5850.1 RC250.2 UC1.E32
VCCST_PWRGD: R9582.2 RC278.1 RC372.1 RC455.2 U6218.4
VCCST_PWRGD_CPU: CC270.2 RC278.2 UC1.B65
VCCST_PWRGD_EC: R9582.1 U38.A44
VDDA18CR: C3059.1 C3060.1 U92.14
VDDA18PLL: C3061.1 C3062.1 U92.34
VIN_1V_PRIM: PC5612.1 PC5615.1 PC5616.1 PC5618.1 PJP5603.1 PU5602.10 PU5602.11 PU5602.12
VIN_1VS_VCCIO: PC5602.1 PC5603.1 PC5604.1 PC5605.1 PJP5601.1 PU5601.10 PU5601.11 PU5601.12
VSS_GT_SENSE: PC5820.2 PC5821.2 PU5801.6 RC449.1 UC1.J69
VSSIO_SENSE: PR5602.2 RC421.1 UC1.AM22
VSSSENSE: PC5841.1 PC5842.2 PU5801.18 RC260.1 UC1.E33
+BL_PWR_SRC: C52.1 C65.1 C9510.1 C9910.1 JEDP1.2 JEDP1.3 JEDP1.4 JEDP1.5 Q2.5 Q2.6 Q2.7 Q2.8
+CAP_LDO: C336.1 U37.B46
+COINCELL: C9929.1 JRTC1.2 RTCR1.1
+CRT_VCC: C9.1 C9913.1 CRTF1.2 JCRT1.9 R2739.2
+DC_IN: PC5105.1 PC5106.1 PL5104.2 PQ5103.1 PQ5103.2 PQ5103.3 PQ5104.4 PQ5105.2 PR5112.1 PR5115.1 PR5237.2
+DC_IN_SS: PC5107.1 PC5108.1 PD5202.1 PD5202.2 PQ5103.5 PQ5103.6 PQ5103.7 PQ5103.8 PQ5208.1 PQ5208.2 PQ5208.3 PR5113.2
+DCIN_JACK: JDCIN1.2 JDCIN1.3 JDCIN1.4 PC5103.1 PL5104.1
+DCPRTC: C9884.1 UC1.BB10
+DDR_VREF_A_CA: RC67.2 RC68.1 RC69.1 RD15.1
+DDR_VREF_B_CA: RC126.1 RC130.2 RC132.1 RD14.1
+DDR_VREF_B_DQ: CC69.1 RC126.2 UC1.BA67
+DDR_VREF_CA: CC67.1 RC68.2 UC1.AY67
+DOCK_DC_IN: C9930.1 JDOCK1.46 JDOCK1.47 JDOCK1.48 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.53 JDOCK1.54 JDOCK1.55 PD5201.1 PD5201.2 PQ5201.1 PQ5201.2 PQ5201.3 PR5252.2
+PBATT: PD5205.1 PD5205.2 PD5206.1 PL5101.2 PL5102.2 PQ5219.5 PQ5219.6 PQ5219.7 PQ5219.8 PR5249.1
+PECI_VREF: C360.1 R374.1 U38.B51
+PWR_SRC: C66.1 C9438.1 C9439.1 C9440.1 C9961.1 C9962.1 C9963.1 C9964.1 C9965.1 C9966.1 JGFX1.2 JGFX1.4 JGFX1.6 JGFX1.8 JHS1.1 JHS1.2 PC5215.1 PC5216.1 PC5217.1 PC5218.1 PC5219.1 PC5220.1 PC5221.1 PC5223.1 PC7407.1 PJP5203.1 PL5202.2 PL5302.2 PL5303.2 PL5401.1 PL5501.1 PL5902.2 PL5903.2 PL5904.2 PR5233.1 PR5810.1 Q2.1 Q2.2 Q2.3 R97.2 R9576.1
+PWR_SRC_AC: PD5201.3 PJP5202.1 PL5201.1 PQ5201.5 PR5202.2
+PWR_SRC_R: JSEC1.1 R9576.2
+RSVD_VCC3P3_1: R178.1 U21.1
+RTC_CELL: C50.1 PR5117.1 R208.2 R327.2 R328.2 R332.1 R346.2 R347.2 R9557.2 RC56.2 RC57.2 RC434.1 RTCD1.3
+RTC_CELL_VBAT: C345.1 R332.2 U38.B64
+SDC_IN: PD5202.3 PD5206.2 PJP5201.1 PQ5208.5 PR5202.1 PR5206.2 PR5217.2 PR5226.2
+SIM_PW: C7106.1 C7112.1 JSIM1.1 JSIMUAJ2.5 R7102.2
+SIM_PWR: C263.1 JSIMUAJ1.14 JWWAN1.36
+SM_VREF_CA_DIMMA: CD12.1 CD13.1 JDIMM1.164 RD15.2
+SM_VREF_CA_DIMMB: CD60.1 CD61.1 JDIMM2.164 RD14.2
+SM_VREF_DQ0: T6211.1 UC1.AY68
+UZ12_TPM: C9567.1 C9981.1 R9523.1 R9524.1 U25.8
+V_DDR_REF: PC5411.1 PU5401.4
+VCHGR: PC5228.1 PC5229.1 PC5230.1 PC5231.1 PD5205.3 PJP5204.1 PQ5219.1 PQ5219.2 PQ5219.3 PR5233.2
+VHDMI_VCC: C87.1 C88.1 HDMIU1.2 JHDMI1.18
+VR_CAP: C366.1 U38.B12
+VREFOUT: C131.1 R9623.1 R9624.1 U17.23
/BATPRES: PR5246.1 PR5257.1 PU5201.15
A_ON: JGFX1.73 R372.2 R424.1 U38.A4
AC_DIS: PQ5217.1 PR5225.1 U37.A50
AC_PRESENT: RP4808.5 U38.A54 UC1.AY15
ACAV_IN: JGFX1.65 JHS1.3 PQ5106.5 PQ5217.3 PR5221.2 PR5224.2 PU5201.5 Q17.5 U38.A64
ACAV_IN#: Q17.3 R9668.1 UC12.2
ACAV_IN_DOCK: PQ5104.2 PQ5214.5 PQ5216.1 PR5256.1 U38.A21
ACAV_IN_NB: PR5243.2 U38.B20
ALC3235_CBN: C134.1 U17.36
ALC3235_CBP: C134.2 U17.35
ALC3235_CPVEE: C9900.1 U17.34
ALC3235_LDO1_CAP: C9897.1 R9627.1 U17.21
ALC3235_LDO2_CAP: C9898.1 U17.39
ALC3235_LDO3_CAP: C9899.1 U17.7
ALC3235_MIC_CAP: C385.1 U17.31
ALC3235_VREF: C9901.1 U17.25
ALS_DET#: JEDP1.36 R9405.2 U37.B3
ALS_INT: JEDP1.37 JSH1.14
ALS_SCLK: JEDP1.39 JSH1.12
ALS_SDAT: JEDP1.38 JSH1.13
ALW_PWRGD_3V_5V: PR5306.2 UC9.2
ALWON: PR5264.2 PR5313.1 U38.A60
ANTCTL0: JWWAN1.59 T7157.1
ANTCTL1: JWWAN1.61 T7158.1
ANTCTL2: JWWAN1.63 T7159.1
ANTCTL3: JWWAN1.65 T7160.1
AUD_HP_NB_SENSE: R9450.2 U37.A41
AUD_HP_OUT_L: JSIMUAJ1.8 R162.2 R9442.2
AUD_HP_OUT_L_CON: C7111.1 D7102.1 JUAJ1.1 L7101.2
AUD_HP_OUT_L_D: JSIMUAJ2.11 L7101.1 R7104.1
AUD_HP_OUT_R: JSIMUAJ1.7 R166.2 R2704.2
AUD_HP_OUT_R_CON: C7110.1 D7103.1 JUAJ1.2 L7102.2
AUD_HP_OUT_R_D: JSIMUAJ2.12 L7102.1 R7103.1
AUD_HP_SENSE: JSIMUAJ1.6 Q3606.1 R9451.1 RC317.1
AUD_HP_SENSE_A: C137.1 Q217.1 Q3606.3 R163.1 R9450.1 R9451.2 R9452.1
AUD_HP_SENSE_D: D7117.1 JSIMUAJ2.13 JUAJ1.5
AUD_NB_MUTE: Q4209.5 Q4209.6 R208.1
AUD_NB_MUTE#: C410.1 R142.1 R9631.1 U17.48 U37.A39
AUD_OUT_L: C9515.1 R162.1 U17.33
AUD_OUT_R: C9516.1 R166.1 U17.32
AUD_PC_BEEP: C133.1 C143.1 U17.12
AUD_PWR_EN: R154.1 RP9.5 UC1.BA7
AUD_SENSE_A: R152.2 U17.13
AUD_SENSE_B: R9634.1 U17.14
AUD_SENSE_C: R9635.1 U17.22
AUIDO_GND: C7108.2 C7109.2 C7110.2 C7111.2 D7101.2 D7102.2 D7103.2 D7117.2 D7118.2 H7102.1 JSIMUAJ2.9 JSIMUAJ2.10 JSIMUAJ2.14 JSIMUAJ2.20 JUAJ1.6 JUAJ1.7 JUAJ1.8 R7103.2 R7104.2
AUX_EN_WOWL: RC464.1 RC584.2 U37.B67
BAT1_LED#: Q23.1 U38.B1
BAT1_LED#_Q: Q23.6 R431.1
BAT2_LED#: Q23.4 U38.A55
BAT2_LED#_Q: Q23.3 R427.1
BAT_ALERT_D: JBAT_PK1.9 JBAT_PK2.3
BAT_CON_IO: JBAT_PK1.1 JBAT_PK1.2 JBAT_PK1.3 JBAT_PK1.4 JBAT_PK2.8 JBAT_PK2.9
BATDRV#: PQ5219.4 PR5247.2
BATDRV#_R: PR5247.1 PU5201.18
BATT_GREEN_LED#: JLED1.8 R427.2
BATT_ORANGE_LED#: JLED1.9 R431.2
BATTERY_GND: H7301.1 H7302.1 JBAT_PK1.10 JBAT_PK1.11 JBAT_PK1.12 JBAT_PK1.13 JBAT_PK2.1 JBAT_PK2.2 JBAT_PK2.10 JBAT_PK2.11
BC_CLK_ECE1117: JKB1.9 U38.A20
BC_CLK_ECE5048: U37.A30 U38.A43
BC_DAT_ECE1117: JKB1.7 R344.2 U38.B21
BC_DAT_ECE5048: R343.2 U37.B31 U38.B45
BC_INT#_ECE1117: JKB1.6 JTP1.4 U38.A19
BC_INT#_ECE5048: U37.A29 U38.A42
BCM5882_ALERT#: JSEC1.13 U37.B62
BEEP: R353.2 U38.B19
BIA_PWM: C9986.1 LE1.2 R95.2 R9696.1
BIA_PWM_EC: Q4214.2 U38.B25
BIA_PWM_EC_EN#: Q4214.1 U37.B55
BIA_PWM_EC_Q: D7123.2 Q4214.3
BIA_PWM_R: D7123.3 R9696.2
BIA_PWM_SOC_EN#: Q4213.1 U37.A52
BLUE_CRT: C12.1 C9917.1 L3.1 R2744.2 U6.M8
BLUE_CRT_L: C15.1 D66.1 JCRT1.3 L3.2
BOARD_ID: C368.1 R392.2 U38.B10
BQ24777_REGN: PC5227.1 PR5204.2 PR5214.2 PR5216.2 PR5221.1 PR5242.1 PR5245.2 PU5201.24
BREATH_GREEN_LED#: JIOR1.38 JLED1.4 JLED1.6 R9645.2
BREATH_GREEN_R_LED#: Q3610.2 R9644.1 R9645.1 R9646.1
BREATH_LED#: Q28.1 U38.B57
BREATH_LED_DOCK#: JDOCK1.4 R9646.2
BREATH_Q_LED#: Q28.6 Q3610.1 R9497.1 R9644.2
BST_+1VALWP: PR5502.1 PU5501.6
BST_+1VALWP_R: PC5502.2 PR5502.2
BT_LED#: JWLAN1.16 Q22.4 R229.2
BT_RADIO_DIS#: D14.2 R298.2 U37.A13
BT_RADIO_DIS#_R: D14.1 JWLAN1.54
BTN_DET#: JCSW1.1 R479.2 U37.B4
CAM_C_DET#: JRCAM1.6 R9404.2 U37.A3
CAM_MIC_CBL_DET#: JEDP1.44 RC193.1 UC1.AB11
CAP_LOW#: T7164.1 U37.A42
CFG0: JXDP1.9 RC376.1 RC399.2 UC1.E68
CFG1: JXDP1.11 RC384.2 UC1.B67
CFG2: JXDP1.15 RC396.2 UC1.D65
CFG3: JXDP1.17 RC385.2 RC389.1 UC1.D67
CFG4: JXDP1.27 RC387.2 UC1.E70
CFG5: JXDP1.29 RC398.2 UC1.C68
CFG6: JXDP1.33 RC395.2 UC1.D68
CFG7: JXDP1.35 RC393.2 UC1.C67
CFG8: JXDP1.10 UC1.F71
CFG9: JXDP1.12 UC1.G69
CFG10: JXDP1.16 UC1.F70
CFG11: JXDP1.18 UC1.G68
CFG12: JXDP1.28 UC1.H70
CFG13: JXDP1.30 UC1.G71
CFG14: JXDP1.34 UC1.H69
CFG15: JXDP1.36 UC1.G70
CFG16: JXDP1.6 UC1.E63
CFG17: JXDP1.4 UC1.F63
CFG18: JXDP1.24 UC1.E66
CFG19: JXDP1.22 UC1.F66
CFG_RCOMP: RC114.2 UC1.E60
CHARGER_SMBCLK: PR5239.2 R350.2 U38.B50
CHARGER_SMBDAT: PR5238.2 R348.2 U38.A47
CHARGER_SRC: PC5204.1 PC5205.1 PC5206.1 PC5207.1 PC5208.1 PC5209.1 PC5210.1 PC5211.1 PC5212.1 PC5213.1 PL5201.2 PQ5218.2
CHG_ACDET: PC5214.1 PR5226.1 PR5227.2 PU5201.6
CHG_ACDRV: PR5222.1 PU5201.4
CHG_ACN: PC5202.2 PC5203.1 PQ5205.2 PQ5207.2 PR5209.2 PU5201.1
CHG_ACP: PC5201.1 PC5202.1 PQ5204.2 PQ5206.2 PR5207.2 PU5201.2
CHG_BST: PR5234.2 PU5201.25
CHG_CMPIN: PC5234.2 PR5237.1 PR5240.1 PR5241.2 PU5201.13
CHG_CMPOUT: PC5237.2 PR5241.1 PR5243.1 PR5244.2 PU5201.14
CHG_CMSRC: PR5217.1 PU5201.3
CHG_HG: PQ5218.1 PU5201.26
CHG_LG: PQ5218.8 PU5201.23
CHG_LX: PC5226.1 PL5202.1 PQ5218.9 PR5235.1 PU5201.27
CHG_SRN: PC5232.2 PC5236.1 PJP5204.2 PU5201.19
CHG_SRP: PC5232.1 PC5235.1 PJP5203.2 PU5201.20
CHG_VCC: PC5225.1 PR5230.1 PU5201.28
CLK_27M_IN: R66.2 R107.2 U6.K1
CLK_27M_IN_R: C42.1 R107.1 Y1.1
CLK_27M_OUT: C43.1 R66.1 U6.L1 Y1.3
CLK_CHINA_TPM: CC289.2 R9681.2 RC619.2 U26.22
CLK_COM_PCI: C9941.1 CC80.2 RC58.2 U6202.16
CLK_DBGPCI: CC25.2 JDEG2.12 RC66.2
CLK_DDC2_CRT: D4.4 JCRT1.15 R2748.2 U6.L4
CLK_ITPXDP_N: RC297.1 UC1.F43
CLK_ITPXDP_N_R: JXDP1.42 RC297.2
CLK_ITPXDP_P: RC298.1 UC1.E43
CLK_ITPXDP_P_R: JXDP1.40 RC298.2
CLK_KBD: R356.2 U38.A38
CLK_MSE: R385.2 U38.A39
CLK_PCI_5048: CC57.2 R324.2 RC65.2 U37.A28
CLK_PCI_MEC: CC290.2 R382.2 RC64.2 U38.A29
CLK_PCIE_N0: JGFX1.78 UC1.D42
CLK_PCIE_N1: JWLAN1.49 UC1.B42
CLK_PCIE_N2: JWWAN1.53 UC1.D41
CLK_PCIE_N3: JSTRG1.20 UC1.D40
CLK_PCIE_N4: U21.45 UC1.B40
CLK_PCIE_N5: JEPC1.10 UC1.E40
CLK_PCIE_P0: JGFX1.76 UC1.C42
CLK_PCIE_P1: JWLAN1.47 UC1.A42
CLK_PCIE_P2: JWWAN1.55 UC1.C41
CLK_PCIE_P3: JSTRG1.19 UC1.C40
CLK_PCIE_P4: U21.44 UC1.A40
CLK_PCIE_P5: JEPC1.9 UC1.E38
CLK_TP_SIO: R444.1 U38.A37
CLKDET#: T7149.1 UC1.AY8
CLKREQ_PCIE#0: JGFX1.55 RC585.2 UC1.AR10
CLKREQ_PCIE#1: JWLAN1.53 RC47.2 UC1.AT7
CLKREQ_PCIE#2: JWWAN1.52 RC50.2 UC1.AT8
CLKREQ_PCIE#3: JSTRG1.34 RC59.2 UC1.AT10
CLKREQ_PCIE#4: R169.1 RC51.2 UC1.AU8
CLKREQ_PCIE#5: C9886.1 JEPC1.12 RC190.2 UC1.AU7
CLKRUN#: RC27.1 U37.B20 U38.A32 U6202.15 UC1.AW11
CLOCKI: C9433.1 R9388.2 U6202.1
CLOCKI_R: OCS4801.3 R9388.1
COEX1: JWLAN1.48 JWWAN1.64
COEX2: JWLAN1.46 JWWAN1.62
COEX3: JWLAN1.44 JWWAN1.60
CONTACTLESS_DET#: JSEC1.23 RC468.1 UC1.W11
CORE_VID0: PR5614.1 UC1.AN11
CORE_VID1: PR5613.1 UC1.AN13
CPU_DP1_CTRL_CLK: Q122.1 R9677.2 UC1.L13
CPU_DP1_CTRL_DATA: Q122.4 R9678.2 UC1.L12
CPU_DP1_HPD: QZ22.1 R475.1 RC480.1 UC1.L9
CPU_DP1_N0: C272.2 UC1.E55
CPU_DP1_N1: C270.2 UC1.E58
CPU_DP1_N2: C209.2 UC1.F53
CPU_DP1_N3: C191.2 UC1.F56
CPU_DP1_P0: C271.2 UC1.F55
CPU_DP1_P1: C269.2 UC1.F58
CPU_DP1_P2: C199.2 UC1.G53
CPU_DP1_P3: C103.2 UC1.G56
CPU_DP2_CTRL_CLK: R9679.2 UC1.N7
CPU_DP2_CTRL_DATA: R9680.2 UC1.N8
CPU_DP2_HPD: RC156.1 U6.J1 UC1.L7
CPU_DP2_N0: C156.2 UC1.C50
CPU_DP2_N0_C: C156.1 U6.G2
CPU_DP2_N1: C158.2 UC1.C52
CPU_DP2_N1_C: C158.1 U6.F2
CPU_DP2_N2: C160.2 UC1.A50
CPU_DP2_N2_C: C160.1 U6.E2
CPU_DP2_N3: C162.2 UC1.D51
CPU_DP2_N3_C: C162.1 U6.D2
CPU_DP2_P0: C155.2 UC1.D50
CPU_DP2_P0_C: C155.1 U6.G1
CPU_DP2_P1: C157.2 UC1.D52
CPU_DP2_P1_C: C157.1 U6.F1
CPU_DP2_P2: C159.2 UC1.B50
CPU_DP2_P2_C: C159.1 U6.E1
CPU_DP2_P3: C161.2 UC1.C51
CPU_DP2_P3_C: C161.1 U6.D1
CPU_DPB_AUX: RC153.1 UC1.F50
CPU_DPB_AUX#: RC147.1 UC1.G50
CPU_DPC_AUX: C19.2 RC155.1 UC1.F48
CPU_DPC_AUX#: C20.2 RC149.1 UC1.E48
CPU_DPC_AUX#_C: C20.1 U6.H2
CPU_DPC_AUX_C: C19.1 U6.H1
CPU_SBIOS_TX: R9577.2 UC1.AB2
CPU_XDP_PRDY#: JXDP1.5 UC1.D56
CPU_XDP_PREQ#: JXDP1.3 RC362.2 UC1.D61
CPU_XDP_TCLK: JXDP1.57 RC359.2 RC402.1 UC1.B61
CPU_XDP_TDI: RC363.2 UC1.D60 UC6.6
CPU_XDP_TDO: RC361.2 UC1.A61 UC6.3
CPU_XDP_TMS: RC364.2 UC1.C60 UC6.8
CPU_XDP_TRST#: RC360.2 UC1.B59 UC1.C61 UC6.11
CRT_ID2: C16.1 D66.3 JCRT1.4
CS_CTR: T7150.1 UC1.AP2
CSI2_RCOMP: RC20.1 UC1.E13
CTS1#: JIOR1.23 RP4804.1 U6202.39
CTS2: RP4806.2 U6202.49
CTS3: RP4804.6 U6202.24 U6203.18
CTS3_T: JSER1.8 U6203.5
CV2_ON: JSEC1.3 R9583.2 U38.A9
D_CLKRUN#: RP4807.5 U37.A19
D_DLDRQ1#: RP4807.1 U37.B24
D_SERIRQ: RP4807.3 U37.A20
DAT_DDC2_CRT: D4.6 JCRT1.12 R2747.2 U6.M4
DAT_KBD: R355.2 U38.B41
DAT_MSE: R357.2 U38.B42
DAT_TP_SIO: R441.1 U38.B40
DCD1#: JIOR1.26 RP4806.8 U6202.42
DCD2: RP4806.7 U6202.44
DCD3: RP4804.8 U6202.19 U6203.15
DCD3_T: JSER1.1 U6203.8
DDI3_AUX: T6204.1 UC1.F46
DDI3_AUX#: T6203.1 UC1.G46
DDR4_DRAMRST#: CD3.1 CD34.1 JDIMM1.108 JDIMM2.108 RC189.1
DDR4_DRAMRST#_CPU: RC189.2 RD3.2 UC1.AT13
DDR_A_ACT#: JDIMM1.114 UC1.BA55
DDR_A_ALERT#: JDIMM1.116 UC1.AW50
DDR_A_BA0: JDIMM1.150 UC1.AU52
DDR_A_BA1: JDIMM1.145 UC1.AT48
DDR_A_BG0: JDIMM1.115 UC1.AY55
DDR_A_BG1: JDIMM1.113 UC1.AY54
DDR_A_CKE0: JDIMM1.109 UC1.BA56
DDR_A_CKE1: JDIMM1.110 UC1.BB56
DDR_A_CKE2: T6208.1 UC1.AW56
DDR_A_CKE3: T6207.1 UC1.AY56
DDR_A_CS#0: JDIMM1.149 UC1.AU45
DDR_A_CS#1: JDIMM1.157 UC1.AU43
DDR_A_CS#2: JDIMM1.162 T6213.1
DDR_A_CS#3: JDIMM1.165 T6212.1
DDR_A_D0: JDIMM1.3 UC1.AL71
DDR_A_D1: JDIMM1.7 UC1.AL68
DDR_A_D2: JDIMM1.17 UC1.AN68
DDR_A_D3: JDIMM1.16 UC1.AN69
DDR_A_D4: JDIMM1.8 UC1.AL70
DDR_A_D5: JDIMM1.4 UC1.AL69
DDR_A_D6: JDIMM1.21 UC1.AN70
DDR_A_D7: JDIMM1.20 UC1.AN71
DDR_A_D8: JDIMM1.29 UC1.AR70
DDR_A_D9: JDIMM1.25 UC1.AR68
DDR_A_D10: JDIMM1.38 UC1.AU71
DDR_A_D11: JDIMM1.42 UC1.AU68
DDR_A_D12: JDIMM1.28 UC1.AR71
DDR_A_D13: JDIMM1.24 UC1.AR69
DDR_A_D14: JDIMM1.37 UC1.AU70
DDR_A_D15: JDIMM1.41 UC1.AU69
DDR_A_D16: JDIMM1.46 UC1.BB65
DDR_A_D17: JDIMM1.49 UC1.AW65
DDR_A_D18: JDIMM1.58 UC1.AW63
DDR_A_D19: JDIMM1.62 UC1.AY63
DDR_A_D20: JDIMM1.50 UC1.BA65
DDR_A_D21: JDIMM1.45 UC1.AY65
DDR_A_D22: JDIMM1.59 UC1.BA63
DDR_A_D23: JDIMM1.63 UC1.BB63
DDR_A_D24: JDIMM1.71 UC1.BA61
DDR_A_D25: JDIMM1.67 UC1.AW61
DDR_A_D26: JDIMM1.83 UC1.BB59
DDR_A_D27: JDIMM1.79 UC1.AW59
DDR_A_D28: JDIMM1.66 UC1.BB61
DDR_A_D29: JDIMM1.70 UC1.AY61
DDR_A_D30: JDIMM1.84 UC1.BA59
DDR_A_D31: JDIMM1.80 UC1.AY59
DDR_A_D32: JDIMM1.170 UC1.AY39
DDR_A_D33: JDIMM1.173 UC1.AW39
DDR_A_D34: JDIMM1.186 UC1.AY37
DDR_A_D35: JDIMM1.183 UC1.AW37
DDR_A_D36: JDIMM1.174 UC1.BB39
DDR_A_D37: JDIMM1.169 UC1.BA39
DDR_A_D38: JDIMM1.187 UC1.BA37
DDR_A_D39: JDIMM1.182 UC1.BB37
DDR_A_D40: JDIMM1.194 UC1.AY35
DDR_A_D41: JDIMM1.195 UC1.AW35
DDR_A_D42: JDIMM1.207 UC1.AY33
DDR_A_D43: JDIMM1.204 UC1.AW33
DDR_A_D44: JDIMM1.191 UC1.BB35
DDR_A_D45: JDIMM1.190 UC1.BA35
DDR_A_D46: JDIMM1.203 UC1.BA33
DDR_A_D47: JDIMM1.208 UC1.BB33
DDR_A_D48: JDIMM1.215 UC1.AY31
DDR_A_D49: JDIMM1.211 UC1.AW31
DDR_A_D50: JDIMM1.228 UC1.AY29
DDR_A_D51: JDIMM1.229 UC1.AW29
DDR_A_D52: JDIMM1.216 UC1.BB31
DDR_A_D53: JDIMM1.212 UC1.BA31
DDR_A_D54: JDIMM1.225 UC1.BA29
DDR_A_D55: JDIMM1.224 UC1.BB29
DDR_A_D56: JDIMM1.249 UC1.AY27
DDR_A_D57: JDIMM1.232 UC1.AW27
DDR_A_D58: JDIMM1.245 UC1.AY25
DDR_A_D59: JDIMM1.236 UC1.AW25
DDR_A_D60: JDIMM1.237 UC1.BB27
DDR_A_D61: JDIMM1.233 UC1.BA27
DDR_A_D62: JDIMM1.250 UC1.BA25
DDR_A_D63: JDIMM1.246 UC1.BB25
DDR_A_DQS0: JDIMM1.13 UC1.AM69
DDR_A_DQS1: JDIMM1.34 UC1.AT70
DDR_A_DQS2: JDIMM1.55 UC1.AY64
DDR_A_DQS3: JDIMM1.76 UC1.BA60
DDR_A_DQS4: JDIMM1.179 UC1.AY38
DDR_A_DQS5: JDIMM1.200 UC1.BA34
DDR_A_DQS6: JDIMM1.221 UC1.AY30
DDR_A_DQS7: JDIMM1.242 UC1.BA26
DDR_A_DQS#0: JDIMM1.11 UC1.AM70
DDR_A_DQS#1: JDIMM1.32 UC1.AT69
DDR_A_DQS#2: JDIMM1.53 UC1.BA64
DDR_A_DQS#3: JDIMM1.74 UC1.AY60
DDR_A_DQS#4: JDIMM1.177 UC1.BA38
DDR_A_DQS#5: JDIMM1.198 UC1.AY34
DDR_A_DQS#6: JDIMM1.219 UC1.BA30
DDR_A_DQS#7: JDIMM1.240 UC1.AY26
DDR_A_MA0: JDIMM1.144 UC1.AY50
DDR_A_MA1: JDIMM1.133 UC1.BB50
DDR_A_MA2: JDIMM1.132 UC1.AY51
DDR_A_MA3: JDIMM1.131 UC1.BA50
DDR_A_MA4: JDIMM1.128 UC1.BB52
DDR_A_MA5: JDIMM1.126 UC1.BA51
DDR_A_MA6: JDIMM1.127 UC1.BA52
DDR_A_MA7: JDIMM1.122 UC1.AW52
DDR_A_MA8: JDIMM1.125 UC1.AY52
DDR_A_MA9: JDIMM1.121 UC1.BB54
DDR_A_MA10: JDIMM1.146 UC1.AT50
DDR_A_MA11: JDIMM1.120 UC1.BA54
DDR_A_MA12: JDIMM1.119 UC1.AW54
DDR_A_MA13: JDIMM1.158 UC1.AU46
DDR_A_MA14: JDIMM1.151 UC1.AT46
DDR_A_MA15: JDIMM1.156 UC1.AU48
DDR_A_MA16: JDIMM1.152 UC1.AU50
DDR_A_ODT0: JDIMM1.155 UC1.AT45
DDR_A_ODT1: JDIMM1.161 UC1.AT43
DDR_A_PARITY: JDIMM1.143 UC1.AT52
