# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYS_RESET#_R: length 4.5
  BOTTOM w0.108: UC8.4 134.5,114.1 134.35,113.96 134.35,112.97 v2(134.96,112.36) 135.22,112.1 RC491.2 RC224.1
SYSTEM_ID: length 26.6
  TOP w0.108: U38.A10 v1(234.75,50.53) ; v1(243.93,38.75) R386.2 ; v1(243.65,50.37) 243.52,50.25 C369.1
  IN3 w0.089: v1(234.75,50.53) 234.75,49.94 235.26,49.42 242.01,49.42 242.96,50.37 v1(243.65,50.37)
  BOTTOM w0.108: v1(243.65,50.37) 243.65,49.6 241.75,47.7 241.75,40.67 v2(242.52,39.9) 242.94,39.48 243.2,39.48 v1(243.93,38.75)
TDI_XDP: length 32.4
  IN3 w0.089: v1(83.35,118.71) 83.26,118.62 83.26,115.78 83.35,115.69 83.35,115.18 82.87,114.69 79.32,114.69 79.19,114.55 77.23,114.55 76.22,113.54 73.97,113.54 73.59,113.93 69.74,113.93 69.25,114.42 66.26,114.42 v1(66.08,114.6)
  BOTTOM w0.108: UC6.5 63.1,111.58 63.49,111.19 v2(64.22,111.19) 64.3,111.19 64.62,111.51 64.62,112.08 64.76,112.21 RC600.2 65.21,112.26 66.02,112.26 66.86,113.1 66.86,114.32 66.58,114.6 v1(66.08,114.6) ; v1(83.35,118.71) 82.81,118.71 82.3,118.19 JXDP1.56
TDO_XDP: length 30.6
  IN3 w0.089: v1(64.18,112.46) 64.21,112.46 64.63,112.04 64.63,111.49 65.65,110.48 67.79,110.48 68.09,110.78 77.74,110.78 78.07,110.45 78.97,110.45 80.4,111.88 v1(81.39,111.88)
  BOTTOM w0.108: v1(64.18,112.46) 64.37,112.65 64.37,113.04 64.37,113.04 64.37,113.25 RC95.2 63.98,113.63 63.43,113.08 UC6.2 62.79,113.08 62.57,113.3 62.57,114.41 v2(62.9,114.75) ; JXDP1.52 81.3,115.1 CC273.1 80.96,114.02 80.96,112.86 81.39,112.43 v1(81.39,111.88)
THERMATRIP2#: length 9.8
  TOP w0.108: R402.1 245.01,63.84 Q12.3 243.9,62.57 v2(243.48,62.15) 243.32,61.99 242.34,61.99 C371.1 241.49,61.14 241.43,61.14 241.08,60.79 239.12,60.79 238.96,60.63 U38.B34
THERMATRIP3#: length 245.4
  TOP w0.108: U38.A2 230.75,51.09 229.42,49.77 228.25,49.77 v1(227.86,50.15) ; R364.1 246.61,48.94 246.61,47.65 v1(246.19,47.23)
  IN1 w0.089: v1(227.86,50.15) 228.88,49.14 237.17,49.14 240.36,45.94 244.9,45.94 v1(246.19,47.23)
  IN2 w0.089: v1(219.9,66.41) 219.8,66.31 219.8,64.95 219.01,64.16 216.9,64.16 216.58,63.84 214.78,63.84 214.28,63.34 208.34,63.34 206.53,61.52 204.17,61.52 202.3,59.65 196.68,59.65 195.26,61.08 195.26,61.42 191.74,64.94 191.32,64.94 185.74,70.52 185.74,74.7 189.09,78.04 189.09,84.62 191.14,86.67 191.14,111.04 184.29,117.89 183.27,117.89 181.44,119.73 166.82,119.73 165.42,121.13 163.06,121.13 161.05,123.15 161.05,124.27 160.84,124.48 160.84,124.48 160.03,125.29 160.03,129.83 158.68,131.18 158.68,134.99 157.54,136.13 156.65,136.13 156.01,136.77 146.24,136.77 146.04,136.56 141.74,136.56 140.4,137.91 139.25,137.91 133.34,143.82 113.53,143.82 v1(112.88,143.17)
  IN4 w0.089: v1(232.57,66.16) 232.57,66.55 231.77,67.34 220.83,67.34 v1(219.9,66.41)
  BOTTOM w0.108: v1(246.19,47.23) 246.19,46.83 v2(246.59,46.42) ; v1(112.88,143.17) 112.7,142.99 JGFX1.77 ; v1(227.86,50.15) 228.25,50.54 228.25,52.92 229.02,53.69 229.02,55.07 229.95,56 230.74,56 232.85,58.11 232.85,58.55 233.06,58.76 233.06,60.67 233.6,61.22 233.6,65.55 233,66.16 v1(232.57,66.16)
THSEL_STRAP: length 7.7
  TOP w0.108: R383.1 v1(243.27,58.15) ; v1(237.71,57.74) 238.1,58.13 U38.B29
  BOTTOM w0.108: v1(243.27,58.15) v2(242.05,58.15) 241.23,58.15 241.1,58.29 238.55,58.29 238,57.74 v1(237.71,57.74)
TMDS_DDC_SCL_R: length 15.4
  TOP w0.102: Q122.6 17.6,122.78 17.46,122.93 R471.1 v1(16.75,123.58)
  IN1 w0.089: JHDMI1.15 9.6,116.28 9.6,117.86 10.35,118.61 12.51,118.61 16.75,122.85 v1(16.75,123.58)
  BOTTOM w0.102: v1(16.75,123.58) 16.47,123.31 v2(15.94,123.31)
TMDS_DDC_SDA_R: length 20.4
  TOP w0.102: v1(22.13,123.36) 21.41,124.08 Q122.3 20.56,124.62 20.69,124.75 R470.1
  BOTTOM w0.102: v1(22.13,123.36) 22.13,122.37 v2(22.11,122.34) 21.47,121.7 20.92,121.7 19.72,120.51 19.72,118.72 18.58,117.58 18.58,116.22 18.11,115.75 C9526.1 C9525.1 14.85,116.2 JHDMI1.16
TMDSB_CON_CLK: length 8.8
  TOP w0.102: JHDMI1.10 10.97,113.6 11.69,113.6 12,113.91 12,115.38 12.38,115.76 13.29,115.76 13.43,115.63 D2301.10 D2301.1 14.84,115.63 14.99,115.78 15.17,115.78 15.35,115.6 15.35,115.17 15.57,114.95 16.04,114.95 16.36,114.63 L10.3
TMDSB_CON_CLK#: length 8.8
  TOP w0.102: L10.2 16.36,115.48 16.04,115.15 15.66,115.15 15.56,115.25 15.56,115.68 15.26,115.98 15,115.98 14.86,116.13 D2301.2 D2301.9 13.46,116.13 13.3,115.97 12.3,115.97 11.8,115.47 11.8,113.99 11.61,113.8 10.97,113.8 JHDMI1.12
TMDSB_CON_N0: length 13.7
  TOP w0.102: L13.2 16.44,118.02 16.13,117.71 15.77,117.71 15.69,117.63 D2301.5 D2301.6 13.34,117.63 13.26,117.55 13.26,117.46 13.13,117.33 12.17,117.33 11.45,118.05 10.26,118.05 9.64,117.42 9.64,112.41 9.56,112.33 9.39,112.33 JHDMI1.9
TMDSB_CON_N1: length 7.2
  TOP w0.102: JHDMI1.6 10.97,110.8 11.78,110.8 13.13,112.15 13.52,112.15 13.67,112.29 D2302.1 D2302.10 15.06,112.29 15.22,112.14 15.33,112.14 15.85,112.66 16.11,112.66 16.39,112.94 RN4103.4
TMDSB_CON_N2: length 10.7
  TOP w0.102: JHDMI1.3 9.42,109.3 9.67,109.3 9.84,109.13 9.84,108.1 10.18,107.76 10.77,107.76 12.84,109.83 12.84,110.03 13.6,110.79 D2302.4 D2302.7 15.16,110.79 15.28,110.67 15.5,110.67 16,110.17 16.14,110.17 16.36,110.4 L19.2
TMDSB_CON_P0: length 13.6
  TOP w0.102: JHDMI1.7 9.45,112.13 9.65,112.13 9.84,112.33 9.84,117.34 10.35,117.84 11.36,117.84 12.08,117.13 D2301.7 D2301.4 14.83,117.13 15.13,117.42 15.78,117.42 15.86,117.51 16.05,117.51 16.39,117.17 L13.3
TMDSB_CON_P1: length 7.2
  TOP w0.102: L16.3 16.41,112.11 16.06,112.46 15.94,112.46 15.41,111.93 15.26,111.93 15.12,111.79 D2302.9 D2302.2 13.67,111.79 13.52,111.94 13.21,111.94 11.87,110.6 10.97,110.6 JHDMI1.4
TMDSB_CON_P2: length 10.7
  TOP w0.102: JHDMI1.1 9.42,109.1 9.59,109.1 9.64,109.05 9.64,108.01 10.09,107.56 10.86,107.56 13.04,109.74 13.04,109.94 13.39,110.29 D2302.5 D2302.6 15.09,110.29 15.27,110.47 15.41,110.47 16.34,109.55 L19.3
TMS_XDP: length 33.3
  IN3 w0.089: v1(82.08,112.97) 82.07,112.97 81.72,112.62 79.04,112.62 78.78,112.36 74.46,112.36 73.79,111.69 67.94,111.69 66.8,112.83 65.39,112.83 64.8,113.41 62.18,113.41 61.78,113.01 59.95,113.01 v1(59.71,113.25)
  BOTTOM w0.108: v1(59.71,113.25) 59.02,113.25 58.73,112.95 58.73,112.6 RC101.1 58.82,111.66 v2(59.5,111.66) 60.08,111.08 UC6.9 ; JXDP1.58 82.8,116.12 82.5,115.81 82.38,115.81 82.25,115.69 82.25,113.14 v1(82.08,112.97)
TOUCH_RST_N_GYRO_INT1: length 89.2
  TOP w0.108: v1(174.76,48.78) 174.76,49.01 C9493.1 176.13,48.4 v2(176.29,48.4) 176.44,48.4 176.79,48.76 RC621.1
  IN1 w0.076: 141.16,79.1 140.14,79.1 139.77,78.73 138.29,78.73 136.41,80.61 136.41,82.13 135.37,83.17 135.37,85.96 134.84,86.48 132.77,86.48 132.52,86.24 132.52,85.2 v3(132.9,84.82)
  IN1 w0.089: v1(167.19,83.05) 167.19,81.76 167.96,80.99 167.96,72.8 173.04,67.73 173.04,63.49 173.56,62.96 173.56,49.47 174.25,48.78 v1(174.76,48.78) ; 141.16,79.1 147.24,79.1 v1(150.94,82.79)
  IN3 w0.089: v1(150.94,82.79) 151.22,83.08 156.25,83.08 157.32,82.01 158.74,82.01 158.94,82.21 158.94,83.02 159.23,83.32 166.92,83.32 v1(167.19,83.05)
  BOTTOM w0.076: UC1.AP8 133.03,84.82 v3(132.9,84.82)
  BOTTOM w0.108: v1(174.76,48.78) 174.2,48.78 173.74,49.25 JSH1.10
TOUCHPAD_INTR#: length 27.3
  BOTTOM w0.076: UC1.BA5 135.62,80.4 135.62,80.06 136.24,79.43 137.65,79.43 139.05,80.84 139.55,80.84 139.91,81.2 139.91,81.55 140.14,81.78 141.05,81.78 141.16,81.67
  BOTTOM w0.108: 141.16,81.67 141.28,81.55 141.28,81.02 143.62,78.68 147.81,78.68 148.79,79.65 148.79,81.11 150,82.32 150,84.37 150.71,85.08 154.16,85.08 RC140.1
TP_CLK: length 12.5
  TOP w0.108: JTP1.2 139.6,62.54 141.49,64.43 v2(142.79,64.43) 143.28,64.91 145.62,64.91 146.4,64.13 146.4,63.79 D22.1 147.11,63.08 148.04,63.08 C380.1 148.68,63.26 148.74,63.2 L45.2
TP_CLK_R: length 6
  TOP w0.108: R444.2 150.94,63.62 150.86,63.69 C378.1 150.18,63.89 149.31,63.89 149.24,63.97 L45.1 148.46,65.32 v2(148.04,65.32) ; R444.2 R449.2 ; R444.2 R405.2
TP_DATA: length 12.6
  TOP w0.108: L44.2 148.44,62.25 C379.1 148.1,62.59 147.46,62.59 D25.1 146.72,62.16 146.72,62.5 145.91,63.31 145.91,63.92 145.41,64.42 143.48,64.42 142.98,63.92 141.77,63.92 v2(141.08,63.23) 140.71,62.86 140.62,62.86 140.1,62.35 JTP1.3
TP_DATA_R: length 5.3
  TOP w0.108: v2(148.98,59.91) 148.98,60.26 149.24,60.52 L44.1 149.81,60.91 149.92,61.02 149.92,61.18 C377.1 150.68,61.94 R450.2 R441.2 R404.2
TP_LAN_JTAG_TCK: length 1.6
  TOP w0.108: R172.2 143.11,135.9 143.75,135.27 U21.35
TP_LAN_JTAG_TDI: length 3.9
  TOP w0.108: T92.1 144.79,137.88 144.79,135.67 144.95,135.51 U21.32
TP_LAN_JTAG_TDO: length 4.7
  TOP w0.108: T93.1 143.88,138.7 143.48,138.3 143.48,137.59 143.55,137.53 143.55,136.16 144.15,135.55 U21.34
TP_LAN_JTAG_TMS: length 1.5
  TOP w0.108: U21.33 144.55,135.53 144.13,135.95 R171.2
TPM_GPIO4: length 1.5
  BOTTOM w0.108: U25.13 192.66,145.28 R9545.2
TPM_LPM#: length 13.2
  TOP w0.108: Q4199.3 190.82,150.62 190.84,150.64 Q4200.3 192.09,149.19 v1(191.73,148.83) 191.96,148.6 191.96,147.38 R9532.2 R9529.2 191.91,145.99 v2(192.34,145.56)
  BOTTOM w0.108: v1(191.73,148.83) 189.93,148.83 189.56,148.46 U25.3
TPM_PIRQ#: length 97.5
  TOP w0.108: v1(149.79,98.4) 151.85,100.46 151.85,102.07 152.17,102.38 152.47,102.38 152.94,102.86 154.49,102.86 155.31,102.05 159.92,102.05 v1(160.79,101.18)
  IN3 w0.089: v1(191.07,131.08) 191.17,130.98 191.17,120.94 190.84,120.61 190.84,120.23 191.17,119.9 191.17,116.36 185.16,110.35 177.05,110.35 172.43,114.97 170.98,114.97 162.24,106.23 162.24,105.09 160.39,103.24 160.39,101.58 v1(160.79,101.18)
  IN4 w0.089: v1(149.79,98.4) 149.6,98.21 142.76,98.21 141.89,99.08 140.95,99.08 v3(140.57,99.45)
  BOTTOM w0.076: UC1.M3 136.86,96.86 138.04,96.86 138.62,97.44 138.62,97.71 139.11,98.2 139.57,98.2 140.17,98.79 140.17,99.05 v3(140.57,99.45)
  BOTTOM w0.108: v1(191.07,131.08) 191.07,131.08 191.07,131.08 191.53,131.53 191.53,139.23 v2(191.63,139.33) R9525.2
TPM_PIRQ#_R: length 3.7
  BOTTOM w0.108: U25.18 191.56,142.23 191.44,142.12 191.44,141.95 191.43,141.93 R9526.2 191.81,141.69 192.11,142 v2(192.52,142) R9525.1
TPM_SERIRQ: length 4.8
  BOTTOM w0.108: U25.27 186.76,144.78 186.75,144.77 R9527.2 R9638.2 186.17,143.22 185.63,142.69 v2(184.95,142.69)
TRST#_XDP: length 34.5
  IN3 w0.089: v1(81.6,118.94) 81.6,117.14 83.14,115.6 83.14,115.27 82.78,114.9 79.24,114.9 79.1,114.76 77.14,114.76 76.13,113.75 74.06,113.75 73.68,114.14 69.83,114.14 69.34,114.63 66.62,114.63 66.25,115 64.15,115 63.24,114.1 61.89,114.1 61.86,114.07 61.37,114.07 61.04,114.39 v1(60.72,114.39)
  BOTTOM w0.108: UC6.12 60.28,112.58 60.2,112.66 60.2,113.87 v1(60.72,114.39) 60.72,114.64 60.34,115.02 v2(59.35,115.02) ; v1(81.6,118.94) 81.8,118.73 JXDP1.54
TX_BLANKING: length 2.4
  TOP w0.108: T6340.1 102.5,132.93 v1(101.97,132.93)
  BOTTOM w0.108: v1(101.97,132.93) 101.97,133.2 101.84,133.33 JWWAN1.48
TXD1: length 148.2
  TOP w0.108: v1(260.92,30.09) 261.72,29.29 U6202.36 261.72,27.84 261.3,27.42 261.3,27.09 R3702.1
  IN1 w0.089: v1(260.92,30.09) 260.92,35.14 257.66,38.4 249.27,38.4 248.94,38.07 234.29,38.07 232.9,39.46 232.9,40.33 228.41,44.82 227.68,44.82 226.53,45.97 183.96,45.97 181.09,48.84 181.09,58.65 178.8,60.93 178.8,78.67 179.93,79.8 179.93,82.35 180.08,82.5 180.08,96.2 179.61,96.66 179.61,96.83 179.2,97.24 179.01,97.24 v1(178.53,97.73)
  BOTTOM w0.108: v2(260.09,29.64) 260.48,29.64 v1(260.92,30.09) ; JIOR1.20 v1(178.53,97.73)
TXD2: length 3.2
  TOP w0.108: v1(266.51,27.29) 266.79,27.29 R3703.1 ; U6202.46 v1(266.72,28.94)
  BOTTOM w0.108: v1(266.51,27.29) v2(266.51,28.12) 266.51,28.73 v1(266.72,28.94)
TXD3: length 240.6
  TOP w0.108: R9428.1 258.41,34.28 258.5,34.38 U6202.21 v1(260.28,34.38) ; U6203.12 123.55,143.54 123.18,143.17 v1(121.6,143.17)
  IN3 w0.089: v1(260.28,34.38) 260.22,34.43 258.66,34.43 258.07,33.85 256.33,33.85 255.62,34.55 252.12,34.55 v1(251.63,35.04)
  IN4 w0.089: v1(251.63,35.04) 251.63,36.83 251.36,37.11 251.36,39.84 250.46,40.74 249.83,40.74 247.35,43.23 247.35,43.84 246.73,44.46 246.73,48.95 247,49.21 247,50.59 245.96,51.63 245.96,53 245.83,53.13 244.46,53.13 244.46,53.13 244.07,53.13 240.26,53.13 238.82,54.57 238.82,54.69 237.91,55.59 231.64,55.59 230.77,54.73 228.84,54.73 228.57,54.45 226.65,54.45 223.99,57.11 218.84,57.11 218.17,57.77 208.23,57.77 207.57,57.11 204.3,57.11 203.79,56.6 189.97,56.6 187.71,58.86 187.71,59.8 179.96,67.56 179.96,70.59 184.92,75.55 185.49,75.55 185.93,76 185.93,79.51 185.68,79.77 185.68,103.1 180.17,108.61 179.14,108.61 177.63,110.12 176.82,110.12 173.82,113.13 173.82,114.19 170.5,117.51 167.98,117.51 163.82,121.68 163.17,121.68 161.29,123.55 161.29,124.14 156.91,128.53 156.91,129.46 156.46,129.91 155.67,129.91 154.72,130.85 154.72,132.2 150.16,136.76 147.29,136.76 147.01,137.04 145.48,137.04 145.17,136.73 141.83,136.73 141.11,137.45 139.15,137.45 134.95,141.65 134.95,141.84 133.54,143.24 133.04,143.24 131.93,144.35 125.32,144.35 123.61,146.06 119.91,146.06 119.68,145.82 119.68,145.17 121.6,143.24 v1(121.6,143.17)
  BOTTOM w0.108: v1(260.28,34.38) 261.49,34.38 v2(261.99,33.88)
TXD3_T: length 20.1
  TOP w0.108: U6203.11 124.2,145.41 123.49,146.12 117.71,146.12 116.39,147.44 v2(116.39,147.69) 116.39,148.58 115.5,149.47 v1(113.6,149.47)
  IN1 w0.089: v1(113.6,149.47) 118.03,149.47 JSER1.3
UART2_RXD: length 19.9
  BOTTOM w0.076: 141.16,90.77 140.96,90.77 140.57,90.39 139.3,90.39 138.84,89.92 UC1.AD1
  BOTTOM w0.108: RC463.2 152.41,86.98 RC461.2 151.34,85.92 150.61,85.92 148.56,87.96 148.56,88.44 v2(147.86,89.14) 147.38,89.14 145.58,90.94 144.75,90.94 144.74,90.94 143.78,90.94 143.28,90.43 142.25,90.43 141.91,90.77 141.16,90.77
UART2_TXD: length 19.7
  BOTTOM w0.076: UC1.AD2 137.42,89.69 137.63,89.69 137.74,89.65 139.03,89.65 139.58,90.21 141.16,90.21
  BOTTOM w0.108: RC460.2 154.01,86.02 152.33,86.02 RC462.2 150.56,85.59 145.68,90.46 v2(144.31,90.46) 143.72,90.46 143.47,90.21 141.16,90.21
UIM_CLK: length 148.7
  TOP w0.108: v1(13.02,140.06) 12.89,140.18 C9513.1 12.65,140.89 v5(11.86,140.89)
  IN3 w0.089: v1(13.02,140.06) 13.42,140.46 14.03,140.46 14.97,139.52 14.97,138.58 17.02,136.53 21.89,136.53 26.49,131.93 26.49,117.6 29.79,114.3 33.13,114.3 33.49,113.94 40.57,113.94 44.45,117.82 45.18,117.82 46.48,119.12 47.91,119.12 49.7,120.92 50.49,120.92 52.11,122.54 56.42,122.54 56.88,123 61.64,123 67.27,128.63 67.27,132.42 75.36,140.51 77.69,140.51 79.05,141.87 79.44,141.87 85.6,141.87 85.8,141.68 93.6,141.68 96.59,144.67 98.77,144.67 v1(101.03,146.93)
  BOTTOM w0.108: v1(101.03,146.93) 101.41,146.55 101.82,146.55 102.15,146.21 102.15,143.77 104.17,141.75 104.17,135.34 102.96,134.13 102.96,129.96 102.32,129.33 JWWAN1.32 ; v1(13.02,140.06) 12.73,140.34 JSIMUAJ1.18
UIM_DATA: length 137.5
  TOP w0.108: v1(97.24,143.37) 97.24,142.86 100.9,139.21 100.9,130.83 v1(101.94,129.78) ; C9514.1 13.78,140.17 v1(13.66,140.06) 14.04,139.68 v5(14.27,139.68)
  IN3 w0.089: v1(13.66,140.06) 14.5,139.22 14.5,138.39 16.83,136.06 21.69,136.06 26.02,131.73 26.02,117.79 26.02,117.4 29.59,113.83 32.93,113.83 33.29,113.47 40.76,113.47 44.64,117.35 45.38,117.35 46.68,118.65 48.1,118.65 49.9,120.45 50.68,120.45 52.31,122.07 56.62,122.07 57.08,122.53 61.83,122.53 67.75,128.45 67.75,132.22 75.58,140.04 77.89,140.04 79.25,141.4 85.41,141.4 85.6,141.21 93.8,141.21 95.31,142.72 96.59,142.72 v1(97.24,143.37)
  BOTTOM w0.108: JSIMUAJ1.16 13.73,140.12 v1(13.66,140.06) ; JWWAN1.34 101.9,129.83 v1(101.94,129.78)
UIM_RESET: length 148.7
  IN3 w0.089: v1(17.87,135.09) 18.37,135.59 21.5,135.59 25.55,131.54 25.55,117.21 30.35,112.41 34.18,112.41 34.77,113 40.96,113 44.84,116.88 45.57,116.88 46.87,118.18 48.3,118.18 50.09,119.98 50.88,119.98 52.5,121.6 56.83,121.6 57.29,122.06 62.03,122.06 68.22,128.26 68.22,131.93 75.75,139.46 78.06,139.46 78.93,140.32 86.55,140.32 86.89,140.67 95.45,140.67 101.71,146.93 v1(102.3,146.93)
  BOTTOM w0.108: JSIMUAJ1.15 14.23,137.84 15.89,136.18 15.89,135.6 16.4,135.09 v1(17.87,135.09) ; v1(102.3,146.93) 102.64,146.58 102.64,144.43 v2(102.86,144.21) 102.86,143.76 104.66,141.96 104.66,135.07 103.45,133.85 103.45,130.94 103.8,130.59 103.8,128.41 103.24,127.85 101.97,127.85 101.76,128.06 101.76,128.68 101.61,128.83 JWWAN1.30
USB2_COMP: length 2.8
  TOP w0.381: v3(135.38,89.84) 135.82,90.29 RC593.1
  BOTTOM w0.178: UC1.AB6 135.15,91.53 135.52,91.16 135.52,90.77
  BOTTOM w0.254: 135.52,90.77 135.52,90.77 135.52,90.12 135.38,89.98 v3(135.38,89.84)
USB2_ID: length 13.2
  TOP w0.076: v3(140.02,87.73) 140.4,88.11 v2(140.4,88.28) 140.4,89.57 139.56,90.41 137.98,90.41 136.97,89.4 136.97,88.25 136.56,87.85 v3(135.57,87.85)
  BOTTOM w0.076: v3(140.02,87.73) 140.28,88 141.16,88 ; UC1.AG3 136.32,88.59 v3(135.57,87.85)
  BOTTOM w0.108: 141.16,88 142.23,88 142.35,88.13 RC338.1
USB2_VBUSSENSE: length 7.8
  BOTTOM w0.076: UC1.AG4 136.19,88.89 137.86,88.89 138.11,89.14 139.18,89.14
  BOTTOM w0.108: 139.18,89.14 139.43,89.4 v2(139.99,89.4) 140.3,89.09 142.96,89.09 RC339.1
USB3_PRX_DTX_N1: length 92.6
  TOP w0.102: v3(133.83,97.75) 134.38,98.3 134.38,100.54 134.51,100.67 136.38,100.67 136.83,101.12 136.83,104.4 138.74,106.32 142.81,106.32 143.85,107.35 147.14,107.35 147.97,106.52 149.65,106.52 150.82,105.35 155.54,105.35 ; v6(155.54,105.33) 155.54,105.35 ; 155.54,105.35 158.13,105.35 158.69,105.92 160.33,105.92 160.97,106.55 160.97,107.98 161.28,108.29 161.41,108.29 v1(161.78,107.93)
  BOTTOM w0.102: JIOR1.45 178.31,85.23 178.46,85.08 179.33,85.08 179.82,84.6 181.16,84.6 181.55,84.99 181.55,87.6 184.75,90.8 184.75,108.53 183.64,109.64 170.28,109.64 168.65,108 163.72,108 163.26,108.47 162.63,108.47 162.49,108.33 162.27,108.33 162.14,108.2 162.14,108.05 162.01,107.93 v1(161.78,107.93) ; v3(133.83,97.75) 133.54,98.04 UC1.H8
USB3_PRX_DTX_N2: length 95.7
  TOP w0.102: RI27.2 103.72,128.51 v1(102.88,128.51)
  IN3 w0.076: 132.22,100.83 132.51,100.53 132.51,97.47 132.63,97.36 134.91,97.36 135.02,97.47 135.02,97.7 134.97,97.75 v3(134.73,97.75)
  IN3 w0.102: 132.22,100.83 131.99,101.05 131.99,101.76 132.27,102.04 132.27,104.26 131.23,105.3 131.23,108.71 132.74,110.22 134.66,110.22 137.7,113.27 137.7,114.01 138.47,114.77 138.47,122.19 137.35,123.31 136.34,123.31 132.88,126.76 131.34,126.76 128.66,129.44 128.66,134.71 129.09,135.14 129.09,140.32 127.95,141.47 121.75,141.47 120.64,140.35 120.64,138.63 119.92,137.91 107.98,137.91 106.61,136.54 104.42,136.54 102.42,134.54 102.42,128.97 v1(102.88,128.51)
  BOTTOM w0.076: v3(134.73,97.75) 134.64,97.75 UC1.J6
USB3_PRX_DTX_N3: length 49.3
  IN4 w0.102: v3(132.9,97.75) 132.44,97.75 132.11,98.08 132.11,98.74 132.32,98.96 132.32,100.54 133.7,101.92 136.21,101.92 138.04,100.09 142.03,100.09 142.92,99.2 150.18,99.2 150.84,98.55 150.84,96.9 152.61,95.13 152.61,94.01 153.79,92.83 154.87,92.83 158.05,89.65 158.71,89.65 158.94,89.88 v1(158.94,90.16)
  BOTTOM w0.102: 164.01,90.79 168.08,90.79 168.51,90.36 L7104.1 ; 164.01,90.79 159.44,90.79 159.19,90.55 159.19,90.41 v1(158.94,90.16) ; 164.01,90.79 v6(164.01,90.81) ; UC1.J10 132.81,97.75 v3(132.9,97.75)
USB3_PRX_DTX_N4: length 190.4
  TOP w0.102: v1(24.43,92.53) 24.01,92.53 23.94,92.61 23.94,92.88 23.88,92.94 23.74,92.94 23.5,93.18 23.5,93.74 23.37,93.87 23.2,93.87 22.88,93.54 L40.4
  IN3 w0.102: v3(132.9,100.32) 133.03,100.32 133.16,100.45 133.16,103.98 134.61,105.43 134.61,106.8 141.06,113.25 141.06,114.22 141.7,114.86 141.7,118.76 141.06,119.4 141.06,120.61 140.53,121.14 140.53,124.31 136.05,128.79 136.05,133.94 132.22,137.77 132.22,139.76 128.99,142.99 125.43,142.99 124.85,143.57 118.25,143.57 117.13,142.46 108.73,142.46 107.08,140.81 104.66,140.81 102.68,138.82 102.19,138.82 96.1,132.73 95.85,132.47 95.85,123.71 94.73,122.59 90.58,122.59 90.13,123.05 85.94,123.05 85.64,122.75 74.34,122.75 71.77,120.18 69.71,120.18 68.95,119.42 65.72,119.42 63.23,116.92 60.05,116.92 58,114.87 56.86,114.87 49.24,107.25 49.24,105.47 46.47,102.69 46.47,102.54 43.66,99.73 43.04,99.73 40.43,97.12 25.74,97.12 25.08,96.46 25.08,93.18 v1(24.43,92.53)
  BOTTOM w0.102: v3(132.9,100.32) 132.55,100.32 132.5,100.37 132.29,100.37 132.19,100.27 132.19,100.09 132.29,99.99 UC1.E10
USB3_PRX_DTX_P1: length 92.7
  TOP w0.102: 157.43,105.55 v6(157.43,105.57) ; 157.43,105.55 150.91,105.55 149.74,106.72 148.06,106.72 147.22,107.56 143.77,107.56 142.73,106.52 138.66,106.52 136.62,104.48 136.62,101.2 136.3,100.88 134.43,100.88 134.17,100.62 134.17,98.46 134.07,98.36 v3(133.82,98.36) ; 157.43,105.55 158.04,105.55 158.61,106.12 160.25,106.12 160.77,106.64 160.77,108.07 161.24,108.53 v1(161.8,108.53)
  BOTTOM w0.102: UC1.G8 133.49,98.69 v3(133.82,98.36) ; v1(161.8,108.53) 162.41,108.53 162.55,108.67 163.34,108.67 163.81,108.21 168.56,108.21 170.2,109.84 183.73,109.84 184.95,108.62 184.95,90.72 181.75,87.52 181.75,84.9 181.24,84.39 179.73,84.39 179.25,84.88 178.46,84.88 178.31,84.73 JIOR1.46
USB3_PRX_DTX_P2: length 95.6
  TOP w0.102: RI28.2 103.67,128.72 103.31,128.72 v1(102.91,129.12)
  IN3 w0.076: 132.04,100.65 132.34,100.34 132.34,97.41 132.56,97.19 134.98,97.19 135.19,97.4 135.19,98.16 135.03,98.32 v3(134.75,98.32) ; 131.74,101.13 131.74,101.13
  IN3 w0.102: 132.04,100.65 131.74,100.95 131.74,101.13 ; v1(102.91,129.12) 102.68,129.35 102.68,134.43 104.53,136.28 106.72,136.28 108.09,137.66 120.03,137.66 120.89,138.52 120.89,140.25 121.85,141.21 127.85,141.21 128.84,140.22 128.84,135.25 128.41,134.82 128.41,129.33 131.23,126.51 132.78,126.51 136.24,123.05 137.25,123.05 138.21,122.09 138.21,114.88 137.45,114.11 137.45,113.38 134.55,110.48 132.64,110.48 130.97,108.81 130.97,105.19 132.01,104.15 132.01,102.15 131.74,101.87 131.74,101.13
  BOTTOM w0.076: v3(134.75,98.32) 134.4,98.32 134.27,98.19 UC1.H6
USB3_PRX_DTX_P3: length 49.3
  IN4 w0.102: v3(132.88,98.36) 132.59,98.06 132.41,98.06 132.31,98.17 132.31,98.66 132.52,98.87 132.52,100.46 133.78,101.72 136.13,101.72 137.96,99.89 141.95,99.89 142.84,99 150.1,99 150.63,98.46 150.63,96.81 152.4,95.04 152.4,93.92 153.7,92.62 154.79,92.62 157.97,89.45 158.79,89.45 159.05,89.7 159.16,89.7 159.26,89.6 159.47,89.6 159.58,89.72 v1(159.58,90.16)
  BOTTOM w0.102: L7104.4 167.66,89.97 167.79,90.1 168.07,90.1 168.2,90.23 168.2,90.39 168,90.59 165.95,90.59 ; 165.95,90.59 159.52,90.59 159.4,90.47 159.4,90.34 v1(159.58,90.16) ; 165.95,90.59 v6(165.95,90.58) ; UC1.H10 132.44,98.23 132.57,98.36 v3(132.88,98.36)
USB3_PRX_DTX_P4: length 190.4
  TOP w0.102: v1(24.43,93.14) 23.83,93.14 23.7,93.27 23.7,93.82 23.45,94.07 23.2,94.07 22.88,94.39 L40.1
  IN3 w0.102: v3(132.9,99.63) 133.41,100.14 133.41,103.87 134.86,105.32 134.86,106.69 141.31,113.15 141.31,114.11 141.95,114.75 141.95,118.86 141.31,119.5 141.31,120.71 140.78,121.24 140.78,124.42 136.31,128.9 136.31,134.04 132.47,137.88 132.47,139.87 129.09,143.24 125.54,143.24 124.95,143.83 118.14,143.83 117.02,142.71 108.62,142.71 106.97,141.06 104.55,141.06 102.57,139.08 102.09,139.08 95.85,132.83 95.85,132.83 95.59,132.58 95.59,123.81 94.63,122.85 90.69,122.85 90.23,123.31 85.84,123.31 85.53,123 74.23,123 71.66,120.43 69.61,120.43 68.84,119.67 65.62,119.67 63.12,117.18 59.94,117.18 57.89,115.13 56.75,115.13 48.99,107.36 48.99,105.57 46.21,102.8 46.21,102.65 43.56,99.99 42.93,99.99 40.32,97.37 25.64,97.37 24.83,96.56 24.83,93.29 24.68,93.14 v1(24.43,93.14)
  BOTTOM w0.102: UC1.F10 132.61,99.34 v3(132.9,99.63)
USB3_PRX_L_DTX_N3: length 12.7
  BOTTOM w0.102: L7104.2 168.51,87.59 168.29,87.37 168.29,87.03 168.12,86.86 166.3,86.86 164.94,88.22 163.61,88.22 ; JDOCK1.32 158.2,88.15 158.27,88.22 163.61,88.22 ; 163.61,88.22 v6(163.61,88.2)
USB3_PRX_L_DTX_N4: length 11.6
  TOP w0.102: JUSB1.5 12.4,90.69 12.86,91.14 14.03,91.14 15.25,92.36 15.25,93.16 16.21,94.11 D17.5 D17.6 19.07,94.11 19.34,93.84 ; 19.34,93.84 v6(19.34,93.82) ; 19.34,93.84 19.64,93.54 L40.3
USB3_PRX_L_DTX_P3: length 12.7
  BOTTOM w0.102: 165.45,88 v6(165.48,88) ; 165.45,88 166.39,87.06 168.03,87.06 168.09,87.12 168.09,87.22 167.94,87.36 167.85,87.36 167.66,87.56 L7104.3 ; 165.45,88 165.03,88.42 158.18,88.42 158.12,88.35 157.92,88.35 157.81,88.46 157.81,88.56 157.72,88.65 JDOCK1.31
USB3_PRX_L_DTX_P4: length 11.5
  TOP w0.102: JUSB1.6 12.81,91.34 13.95,91.34 15.05,92.44 15.05,93.24 16.42,94.61 D17.4 D17.7 18.39,94.61 18.53,94.48 18.53,94.45 18.66,94.31 19.15,94.31 19.72,93.75 20.13,93.75 20.21,93.82 20.21,93.96 20.15,94.02 20.15,94.3 20.25,94.39 L40.2
USB3_PRX_R_DTX_N2: length 2.6
  TOP w0.102: RI27.1 105.14,128.51 105.89,128.51 v1(106.05,128.35)
  BOTTOM w0.102: JWWAN1.29 106.28,128.58 v1(106.05,128.35)
USB3_PRX_R_DTX_P2: length 2.7
  TOP w0.102: v1(106.06,128.96) 105.82,128.72 105.2,128.72 RI28.1
  BOTTOM w0.102: JWWAN1.31 106.47,129.08 106.35,128.96 v1(106.06,128.96)
USB3_PTX_C_DRX_N1: length 90.2
  TOP w0.102: 140.24,107.23 139.8,107.23 138.09,108.95 138.09,110.8 137.62,111.27 137.15,111.27 137.04,111.16 137.04,110.95 C1103.1 ; 140.24,107.23 142.56,107.23 143.5,108.17 147.47,108.17 148.31,107.33 149.99,107.33 151.16,106.16 157.79,106.16 158.61,106.98 158.61,107.84 160.12,109.34 160.26,109.34 160.36,109.24 160.36,109.08 160.28,109 160.28,108.83 160.37,108.75 160.56,108.75 v1(160.74,108.94) ; 140.24,107.23 v6(140.24,107.2)
  BOTTOM w0.102: JIOR1.48 178.37,83.73 178.47,83.83 178.64,83.83 178.73,83.74 178.73,83.53 178.83,83.43 181.17,83.43 181.67,83.94 183.72,83.94 185.63,85.85 185.63,108.79 183.98,110.45 172.65,110.45 171.68,111.42 164.15,111.42 162.76,110.02 161.94,110.02 161.13,109.22 161.02,109.22 v1(160.74,108.94)
USB3_PTX_C_DRX_N2: length 45.1
  TOP w0.102: v6(101.74,126.8) 101.71,126.8 ; 101.71,126.8 101.71,126.11 101.78,126.03 102,126.03 v1(102.07,126.1) ; 101.71,126.8 101.71,128.82 102.04,129.14 102.3,129.14 102.78,129.62 102.78,130.45 103.04,130.7 103.52,130.7 RI29.2
  IN4 w0.102: v1(102.07,126.1) 102.12,126.05 105.76,126.05 108.12,123.69 119.65,123.69 119.93,123.41 123.1,123.41 123.79,122.72 128.73,122.72 128.93,122.92 130.74,122.92 v1(130.96,123.14)
  BOTTOM w0.102: v1(130.96,123.14) 131.33,122.77 131.33,120.08 131.58,119.83 131.58,116.43 C9550.1
USB3_PTX_C_DRX_N3: length 63.1
  IN4 w0.102: v1(163.92,93.85) 164.17,94.1 164.4,94.1 164.64,94.35 164.64,94.77 159.63,99.78 159.12,99.78 158.25,100.65 158.25,102.5 155.26,105.5 155.26,108.05 154.9,108.4 154.9,109.14 149.4,114.64 146.67,114.64 145.11,116.19 142.32,116.19 141.43,115.3 138.9,115.3 138.16,116.04 133.04,116.04 131.24,117.84 v1(130.54,117.84)
  BOTTOM w0.102: 166.38,94.16 166.07,93.85 v1(163.92,93.85) ; 166.38,94.16 v6(166.38,94.12) ; 166.38,94.16 166.81,94.59 166.81,95.13 166.96,95.27 167.81,95.27 167.98,95.1 167.98,94.81 167.66,94.49 L7105.4 ; v1(130.54,117.84) 129.78,117.08 129.78,116.32 129.97,116.13 129.97,111.4 130.46,110.91 130.46,110.73 130.31,110.58 C9548.1
USB3_PTX_C_DRX_N4: length 2.1
  TOP w0.102: L41.4 22.88,95.83 23.18,96.13 24,96.13 C292.1
USB3_PTX_C_DRX_P1: length 90.2
  TOP w0.102: 138.75,108.57 138.29,109.03 138.29,110.88 137.7,111.47 137.06,111.47 136.84,111.25 136.84,111 C1104.1 ; 138.75,108.57 v6(138.77,108.57) ; 138.75,108.57 139.89,107.43 142.48,107.43 143.42,108.37 147.56,108.37 148.39,107.53 150.07,107.53 151.24,106.36 157.7,106.36 158.41,107.06 158.41,107.92 160.03,109.55 v1(160.74,109.55)
  BOTTOM w0.102: v1(160.74,109.55) 160.87,109.42 161.05,109.42 161.85,110.22 162.67,110.22 164.07,111.62 171.77,111.62 172.73,110.65 184.06,110.65 185.84,108.88 185.84,85.76 183.81,83.73 181.76,83.73 181.25,83.23 JIOR1.49
USB3_PTX_C_DRX_P2: length 45.1
  TOP w0.102: v1(102.04,125.49) 101.51,126.02 101.51,128.51 ; RI30.2 103.54,131.03 103.42,130.9 102.95,130.9 102.58,130.53 102.58,129.71 102.22,129.35 101.95,129.35 101.51,128.9 101.51,128.51 ; 101.51,128.51 v6(101.48,128.51)
  IN4 w0.102: v1(130.9,122.52) 130.69,122.72 129.02,122.72 128.81,122.52 123.7,122.52 123.01,123.2 119.85,123.2 119.57,123.48 108.04,123.48 105.67,125.85 102.4,125.85 v1(102.04,125.49)
  BOTTOM w0.102: v1(130.9,122.52) 131.13,122.29 131.13,119.99 131.38,119.74 131.38,116.26 C9551.1
USB3_PTX_C_DRX_P3: length 63.1
  IN4 w0.102: v1(130.54,117.23) 130.95,117.64 131.15,117.64 132.95,115.84 138.08,115.84 138.81,115.1 141.51,115.1 142.4,115.99 145.03,115.99 146.58,114.44 149.31,114.44 154.7,109.05 154.7,108.32 155.05,107.96 155.05,105.42 158.05,102.42 158.05,100.56 159.03,99.58 159.55,99.58 164.44,94.69 164.44,94.43 164.31,94.3 164.08,94.3 v1(163.9,94.49)
  BOTTOM w0.102: 167.47,95.48 166.87,95.48 166.61,95.21 166.61,94.67 165.99,94.05 164.4,94.05 164.3,94.16 164.3,94.35 164.16,94.49 v1(163.9,94.49) ; 167.47,95.48 167.89,95.48 168.19,95.18 168.19,94.8 168.51,94.48 L7105.1 ; 167.47,95.48 v6(167.47,95.49) ; C9549.1 131.38,110.61 131.18,110.8 130.85,110.8 130.17,111.48 130.17,116.21 129.98,116.4 129.98,117 130.22,117.23 v1(130.54,117.23)
USB3_PTX_C_DRX_P4: length 2.1
  TOP w0.102: L41.1 22.88,96.68 23.23,96.33 24.05,96.33 C293.1
USB3_PTX_CL_DRX_N3: length 14.5
  BOTTOM w0.102: 164.76,92.98 166.07,92.98 167.4,91.64 167.98,91.64 168.14,91.8 168.14,91.98 167.66,92.46 L7105.3 ; 164.76,92.98 164.15,92.98 162.85,91.68 159.16,91.68 158.26,90.78 158.26,90.15 157.97,89.85 157.84,89.85 157.77,89.93 157.77,90.04 157.66,90.15 JDOCK1.28 ; 164.76,92.98 v6(164.76,93)
USB3_PTX_CL_DRX_N4: length 10.2
  TOP w0.102: JUSB1.8 12.79,96.14 13.17,96.14 13.37,95.94 14.02,95.94 14.2,95.75 16.85,95.75 16.99,95.61 D17.2 D17.9 18.39,95.61 18.53,95.75 18.53,95.81 18.63,95.91 19.36,95.91 19.93,96.48 20.24,96.48 20.3,96.41 20.3,96.27 20.07,96.05 20.07,95.9 20.15,95.83 L41.3
USB3_PTX_CL_DRX_P3: length 14.5
  BOTTOM w0.102: 167.7,91.44 167.32,91.44 165.99,92.77 164.23,92.77 162.93,91.48 159.24,91.48 158.47,90.7 158.47,90.07 158.05,89.65 JDOCK1.29 ; 167.7,91.44 v6(167.7,91.43) ; 167.7,91.44 168.07,91.44 168.34,91.72 168.34,92.16 168.51,92.33 L7105.2
USB3_PTX_CL_DRX_P4: length 10.1
  TOP w0.102: 19.56,96.39 19.84,96.68 L41.2 ; 19.56,96.39 v6(19.56,96.43) ; 19.56,96.39 19.27,96.11 D17.10 D17.1 16.99,96.11 16.83,95.95 14.29,95.95 14.1,96.14 13.46,96.14 13.25,96.34 12.91,96.34 12.4,96.85 JUSB1.9
USB3_PTX_CR_DRX_N2: length 2.7
  TOP w0.102: RI29.1 105.12,130.22 105.28,130.38 105.65,130.38 v1(106.01,130.02)
  BOTTOM w0.102: JWWAN1.35 106.58,130.08 106.44,130.21 106.19,130.21 v1(106.01,130.02)
USB3_PTX_CR_DRX_P2: length 2.7
  TOP w0.102: v1(106.01,130.63) 105.95,130.58 105.31,130.58 RI30.1
  BOTTOM w0.102: v1(106.01,130.63) 106.22,130.42 106.46,130.42 106.62,130.58 JWWAN1.37
USB3_PTX_DRX_N1: length 14.7
  TOP w0.102: v1(131.14,103.25) 131.52,103.25 131.58,103.19 131.73,103.19 131.81,103.27 131.81,103.59 131.88,103.66 133.12,103.66 ; C1103.2 137.43,109.24 137.28,109.09 136.97,109.09 136.82,108.93 136.82,108.81 136.9,108.73 137.21,108.73 137.61,108.33 137.61,106.37 135.62,104.38 134.55,104.38 133.83,103.66 133.12,103.66 ; v6(133.12,103.63) 133.12,103.66
  BOTTOM w0.076: UC1.C13 130.54,101.59 130.54,101.7 130.45,101.96 130.45,102.15 130.49,102.27 130.49,102.52 130.45,102.61 130.45,102.97 130.72,103.24 131.12,103.24 v1(131.14,103.25)
USB3_PTX_DRX_N2: length 15
  BOTTOM w0.076: 132.4,103.74 131.33,102.67 131.33,102.54 131.01,102.22 130.88,102.22 UC1.B13
  BOTTOM w0.102: 131.38,113.22 131.38,113.6 131.86,114.08 131.86,114.19 132.14,114.47 C9550.2 ; 131.38,113.22 v6(131.41,113.22) ; 131.38,113.22 131.38,112.13 132.27,111.24 132.27,107.06 133.06,106.27 133.06,104.4 132.4,103.74
USB3_PTX_DRX_N3: length 8
  BOTTOM w0.076: 130.51,105.44 130.51,105.21 129.69,104.4 129.69,103.94 129.09,103.35 129.09,102.33 UC1.B15
  BOTTOM w0.102: 130.51,105.98 130.51,109.08 C9548.2 ; 130.51,105.98 v6(130.49,105.98) ; 130.51,105.98 130.51,105.44
USB3_PTX_DRX_N4: length 184.5
  TOP w0.102: C292.2 25.6,95.98 25.95,95.98 v1(26.12,95.8)
  IN3 w0.102: v1(26.12,95.8) 26.34,95.59 26.57,95.59 26.69,95.71 26.69,95.89 26.57,96.01 26.57,96.11 26.64,96.18 41.24,96.18 43.7,98.64 44.46,98.64 48.35,102.53 49.06,102.53 58.08,111.54 58.08,113.43 59.65,115 63.16,115 63.82,115.66 65.11,115.66 65.68,116.22 69.08,116.22 72.86,120 73.85,120 75.68,121.83 83.04,121.83 84.1,120.78 94.16,120.78 96.71,123.32 96.71,132.12 97.68,133.08 100.11,133.08 105.59,138.57 110.38,138.57 112.25,140.45 112.25,141.04 112.54,141.33 117.28,141.33 118.05,142.1 128.56,142.1 129.75,140.9 129.75,140.5 130.49,139.76 130.49,138.28 131.79,136.98 131.79,128.79 136.63,123.94 137.65,123.94 139.08,122.52 139.08,119.95 140.83,118.2 140.83,115.21 140.36,114.75 139.38,114.75 138.39,113.76 138.39,111.93 136,109.54 133.23,109.54 132.11,108.42 132.11,106.41 v3(131.81,106.11)
  BOTTOM w0.076: UC1.C15 129.25,101.53 129.25,101.64 129.35,101.74 129.44,101.74 129.59,101.85 129.63,101.98 129.64,102 129.64,102.14 129.59,102.27 129.59,102.48 129.63,102.61 129.63,103.38 130.06,103.81 130.06,104.08 130.73,104.75 130.97,104.75 131.99,105.77 131.99,105.93 131.86,106.06
  BOTTOM w0.102: 131.86,106.06 v3(131.81,106.11)
USB3_PTX_DRX_P1: length 14.8
  TOP w0.102: 135.01,104.59 134.47,104.59 133.75,103.86 v1(131.15,103.86) ; 135.01,104.59 v6(135.01,104.61) ; 135.01,104.59 135.54,104.59 137.4,106.45 137.4,108.24 137.12,108.52 136.82,108.52 136.61,108.73 136.61,109.06 136.41,109.26 C1104.2
  BOTTOM w0.076: v1(131.15,103.86) 130.86,103.57 130.82,103.57 130.28,103.04 130.28,102.58 130.32,102.49 130.32,102.3 130.28,102.18 130.28,101.93 130.37,101.67 130.37,101.1 UC1.D13
USB3_PTX_DRX_P2: length 15
  BOTTOM w0.076: 132.25,103.88 132.25,103.88 132.25,103.84 132.22,103.81 132.22,103.8 131.16,102.74 131.16,102.61 130.99,102.44 130.81,102.44 130.72,102.53 UC1.A13
  BOTTOM w0.102: 131.71,111.51 132.07,111.16 132.07,106.97 132.85,106.19 132.85,104.48 132.25,103.88 ; 131.71,111.51 131.18,112.04 131.18,113.69 131.66,114.17 131.66,114.33 C9551.2 ; 131.71,111.51 v6(131.71,111.47)
USB3_PTX_DRX_P3: length 8
  BOTTOM w0.076: UC1.A15 129.26,102.82 129.26,103.28 129.86,103.87 129.86,104.33 130.67,105.15 130.67,105.35 130.68,105.36 130.68,105.4 130.71,105.43 130.71,105.44
  BOTTOM w0.102: 130.71,105.44 130.71,108.68 130.8,108.77 130.94,108.77 131.11,108.6 131.29,108.6 131.38,108.69 C9549.2
USB3_PTX_DRX_P4: length 184.5
  TOP w0.102: v1(26.12,96.44) 25.59,96.44 C293.2
  IN3 w0.102: v1(26.12,96.44) 41.14,96.44 43.59,98.9 44.36,98.9 48.25,102.78 48.95,102.78 57.82,111.65 57.82,113.53 59.54,115.25 63.05,115.25 63.71,115.91 65.01,115.91 65.57,116.48 68.98,116.48 72.76,120.26 73.75,120.26 75.58,122.09 83.15,122.09 84.2,121.03 94.06,121.03 96.45,123.43 96.45,132.22 97.57,133.34 100,133.34 105.49,138.82 110.27,138.82 112,140.55 112,141.15 112.44,141.59 117.17,141.59 117.94,142.36 128.66,142.36 130.01,141.01 130.01,140.6 130.74,139.87 130.74,138.38 132.04,137.09 132.04,128.89 136.74,124.19 137.76,124.19 139.33,122.62 139.33,120.05 141.08,118.3 141.08,115.1 140.47,114.49 139.48,114.49 138.64,113.65 138.64,111.82 136.1,109.28 133.34,109.28 132.37,108.31 v3(132.37,106.12)
  BOTTOM w0.076: UC1.D15 129.7,101.09 129.7,101.61 129.8,101.97 129.8,102.17 129.75,102.33 129.75,102.46 129.8,102.58 129.8,103.31 130.23,103.74 130.23,104.01 130.8,104.59 131.04,104.59 132.15,105.7 132.15,105.91 132.3,106.06
  BOTTOM w0.102: 132.3,106.06 v3(132.37,106.12)
USB20_N1: length 66.3
  IN3 w0.102: v1(180.48,88.65) 180.25,88.41 180.07,88.41 179.94,88.54 179.94,88.91 179.44,89.42 178.22,89.42 177.13,88.33 177.13,86.53 175.26,84.67 166.06,84.67 164.18,86.55 160.05,86.55 158.6,85.1 154.95,85.1 153.91,84.06 153.22,84.06 152.08,85.21 149.41,85.21 147.1,87.52 143.65,87.52 141.05,84.93 138.01,84.93 137.97,84.96 136.79,86.15 136.79,86.48 135.84,87.43 133.42,87.43 133.18,87.67 133.18,88.37 132.08,89.47 132.07,89.47 131.86,89.68 131.86,90.11 131.99,90.23 132.23,90.23 132.53,90.53 132.53,90.7 132.82,91 v3(132.83,91)
  BOTTOM w0.102: v3(132.83,91) 132.82,91.01 132.82,91.18 UC1.AB9 ; v1(180.48,88.65) 180.2,88.37 180.06,88.37 179.82,88.12 179.82,86.89 179.45,86.53 178.44,86.53 178.23,86.73 JIOR1.42
USB20_N2: length 84.6
  IN3 w0.102: v1(148.02,120.26) 148.4,119.88 148.78,119.88 150.07,118.58 150.07,110.25 150.33,110 150.33,100.9 147.55,98.12 147.55,95.34 145.76,93.56 145.04,93.56 143.3,91.81 142.15,91.81 141,90.65 136.37,90.65 135.72,91.3 135.42,91.3 v3(135.11,91)
  IN4 w0.102: v1(148.02,120.26) 147.8,120.04 147.13,120.04 146.51,120.66 144.21,120.66 143.77,121.1 142.85,121.1 142.35,120.59 141.71,120.59 140.8,121.5 140.8,122.42 140.23,122.99 139.55,122.99 138.62,122.06 134,122.06 131.79,124.27 130.82,124.27 130.49,123.94 124.17,123.94 123.86,124.24 120.61,124.24 119.57,125.29 118.02,125.29 v1(117.77,125.54)
  BOTTOM w0.102: v1(117.77,125.54) 114.6,125.54 ; 114.6,125.54 v6(114.6,125.57) ; 114.6,125.54 113.9,125.54 112.63,124.28 112.63,123.92 112.47,123.76 111.92,123.76 111.6,124.09 L57.4 ; v3(135.11,91) 135.12,90.99 UC1.AD6
USB20_N2_R: length 2.8
  BOTTOM w0.102: JWWAN1.9 107.92,123.58 108.05,123.45 108.41,123.45 108.7,123.74 109.15,123.74 109.48,124.06 RN483.3
USB20_N3: length 37.7
  IN3 w0.102: v1(167.55,85.65) 167.46,85.56 167.14,85.56 167.06,85.63 167.06,85.73 167.2,85.87 167.2,85.96 167.13,86.03 165.45,86.03 164.45,87.03 157.9,87.03 156.45,85.59 154.75,85.59 154.09,84.93 153.14,84.93 152.38,85.69 149.82,85.69 147.48,88.02 143.03,88.02 142.35,87.34 v1(142.35,87.05)
  BOTTOM w0.076: UC1.AH3 136.49,87.66 136.95,87.66 137.06,87.7 137.31,87.7 137.47,87.65 137.59,87.65 137.7,87.7 138.08,87.7 138.57,87.21 140.91,87.21 140.92,87.22 140.96,87.22 140.98,87.25 140.99,87.25
  BOTTOM w0.102: 140.99,87.25 141.52,87.25 141.74,87.03 141.89,87.03 142.04,87.18 142.22,87.18 v1(142.35,87.05) ; L7106.4 167.78,84.7 168.11,85.03 168.11,85.72 167.96,85.87 167.77,85.87 v1(167.55,85.65)
USB20_N3_R: length 14.4
  BOTTOM w0.102: JDOCK1.34 157.87,87.15 157.97,87.05 157.97,86.96 158.08,86.85 162,86.85 163.85,85 ; L7106.3 167.78,82.71 168.21,82.29 168.21,82.11 167.97,81.87 166.99,81.87 163.85,85 ; 163.85,85 v6(163.9,85)
USB20_N4: length 183.2
  IN3 w0.102: v1(25.64,94.76) 25.83,94.58 26.73,94.58 28.13,93.18 40.98,93.18 43.09,91.07 51.41,91.07 53.16,92.82 55.22,92.82 56.47,94.07 68.67,94.07 75.19,87.55 75.19,81.95 77.68,79.47 82.54,79.47 84.49,81.42 88.38,81.42 94.14,75.66 94.14,73.57 105.45,62.27 140.83,62.27 142,61.1 142,60.34 v1(142.15,60.19)
  IN4 w0.102: v3(133.43,89.83) 133.24,89.63 133.24,89.2 133.03,88.99 133.03,87.83 133.45,87.41 135.15,87.41 137.68,84.88 137.68,81.37 140.12,78.93 141.23,78.93 142.96,77.2 142.96,72.08 143.77,71.27 145.06,71.27 147.08,69.25 147.08,66.91 141.97,61.8 141.97,60.36 v1(142.15,60.19)
  BOTTOM w0.102: UC1.AD9 133.16,90.3 133.23,90.23 133.23,90.03 v3(133.43,89.83) ; v1(25.64,94.76) 25.37,95.03 25.37,95.84 24.96,96.25 U6204.2
USB20_N4_R: length 7.8
  BOTTOM w0.102: JUSB1.2 13.9,93.95 14,93.85 14.93,93.85 15.43,94.35 15.43,95.85 15.68,96.1 16.62,96.1 D7108.1 17.54,96.15 18.04,96.15 18.42,96.53 L42.3
USB20_N5: length 66.7
  IN3 w0.102: v1(139.11,86.64) 139.29,86.81 139.29,86.96 139.19,87.06 138.49,87.06 137.76,87.8 137.76,89.55 138.35,90.15 141.27,90.15 141.74,90.62 143.01,90.62 145.1,92.7 147.13,92.7 148.4,93.97 150.81,93.97 151.06,94.22 151.06,99.45 151.65,100.04 151.65,104.41 152.51,105.27 152.51,119.16 151.7,119.97 151.7,128.41 v1(156.4,133.11)
  BOTTOM w0.102: v1(156.4,133.11) 156.18,132.89 155.97,132.89 155.9,132.97 155.9,133.62 156,133.72 156.37,133.72 156.54,133.89 L76.4 ; UC1.AJ1 137.84,87.16 139.06,85.95 139.33,85.95 139.53,86.15 139.53,86.22 139.46,86.3 139.38,86.3 139.37,86.28 139.22,86.28 139.11,86.39 v1(139.11,86.64)
USB20_N5_R: length 9.1
  BOTTOM w0.102: RN247.2 156.52,136.24 156.22,136.54 156.22,137.27 D69.1 156.3,138.22 156.3,138.65 155.64,139.31 152.62,139.31 152.35,139.58 152.35,140.2 152.6,140.45 JUSB2.2
USB20_N6: length 90.5
  IN4 w0.102: v1(174.92,51.02) 174.92,50.86 174.62,50.57 174.62,50.45 174.71,50.36 174.84,50.36 174.94,50.26 174.94,50.16 174.81,50.03 172.74,50.03 172.25,49.55 172.25,47.63 171.71,47.08 166.18,47.08 165.67,47.59 162.72,47.59 162.58,47.73 161.77,47.73 158.35,51.15 158.35,56.61 157.32,57.65 151.9,57.65 151.37,58.18 151.37,66.65 150.44,67.57 150.44,71.37 152.89,73.81 154.54,73.81 154.77,74.04 154.77,76.5 155.09,76.82 155.09,77.29 153.42,78.96 153.27,78.96 152.46,79.77 152.46,80.56 151.6,81.43 151.6,86.58 149.79,88.38 140.87,88.38 140.82,88.33 138.37,88.33 137.66,89.04 136.18,89.04 136.05,89.17 135.9,89.17 135.77,89.04 135.44,89.04 135.34,89.14 135.34,89.37 135.24,89.47 134.99,89.47 134.94,89.52 134.85,89.52 134.75,89.62 v3(134.75,89.84)
  BOTTOM w0.102: v3(134.75,89.84) 134.68,89.76 134.68,89.62 134.77,89.52 134.77,89.41 134.88,89.3 135.02,89.3 UC1.AF6 ; JSH1.7 173.84,50.75 173.95,50.64 173.95,50.53 174.03,50.45 175.11,50.45 175.17,50.51 175.17,50.64 174.92,50.89 v1(174.92,51.02)
USB20_N7: length 90.4
  IN4 w0.102: v3(138.85,87.72) 139.03,87.53 139.03,87.28 139.25,87.06 140.76,87.06 141.19,87.49 146.75,87.49 149.35,84.89 149.35,81.82 144.13,76.6 144.13,74.5 145.52,73.11 146.67,73.11 147.51,72.28 147.51,70.92 148.35,70.08 148.35,66.79 150.05,65.09 150.05,57.76 151.06,56.76 156.95,56.76 157.47,56.24 157.47,50.69 159.95,48.2 159.95,46.89 161.04,45.81 162.8,45.81 163.05,46.06 176.77,46.06 177.26,46.56 177.26,46.91 177.38,47.03 177.62,47.03 177.7,47.11 v1(177.7,47.46)
  BOTTOM w0.076: v3(138.85,87.72) 138.66,87.91 137.88,87.91 137.83,87.93 UC1.AH1
  BOTTOM w0.102: 179.67,44.97 180.27,44.36 180.27,43.55 180.58,43.25 L3602.1 ; 179.67,44.97 179.02,45.62 178.18,45.62 177.26,46.53 177.26,46.93 177.37,47.03 177.62,47.03 177.7,47.1 v1(177.7,47.46) ; 179.67,44.97 v6(179.67,45.01)
USB20_N7_R: length 14.8
  BOTTOM w0.102: RN4105.4 180.55,41.16 180.27,40.88 180.27,40.34 178.59,38.65 168.93,38.65 168.19,37.92 JSEC1.8
USB20_N8: length 230.5
  IN3 w0.102: v1(18.55,134.48) 18.55,130.65 17.82,129.91 17.82,105.7 22.13,101.38 22.13,92.61 24.08,90.67 38.46,90.67 38.79,90.34 40.77,90.34 41.94,89.17 48.25,89.17 49.16,90.08 52.08,90.08 53.61,91.61 55.44,91.61 56.83,93 65.75,93 68.69,90.06 70.52,90.06 74.13,86.45 74.13,81.54 77.22,78.45 82.95,78.45 84.92,80.43 87.97,80.43 93.15,75.24 93.15,73.14 106.49,59.8 140.01,59.8 140.17,59.96 140.72,59.96 140.92,59.76 140.92,59.62 v1(140.85,59.55)
  IN4 w0.102: v3(134.11,88.91) 134.11,88.66 134.34,88.43 136.62,88.43 139.43,85.62 139.43,84.93 140.21,84.16 140.21,82.53 140.68,82.06 141.11,82.06 141.64,81.52 141.64,79.57 143.65,77.56 143.65,74.28 144.34,73.59 144.34,73.26 147.86,69.74 147.86,66.69 143.75,62.57 143.75,59.91 142.71,58.87 141.54,58.87 v1(140.85,59.55)
  BOTTOM w0.102: v3(134.11,88.91) 133.82,89.2 UC1.AF8 ; v1(18.55,134.48) 18.76,134.28 18.76,134.02 18.96,133.82 19.53,133.82 19.78,134.07 20.03,134.07 20.34,133.76 L3101.4
USB20_N8_R: length 4.8
  BOTTOM w0.102: L3101.3 22.43,133.76 22.75,134.08 23.4,134.08 23.93,134.61 23.93,135.47 24.62,136.16 24.73,136.16 24.87,136.02 JWLAN1.5
USB20_N9: length 126.6
  TOP w0.102: v1(203.95,145.09) 204.25,144.79 204.25,143.77 204.6,143.42 205.49,143.42 206.07,142.84 206.62,142.84 206.84,143.06 206.84,143.51 v6(206.86,143.52) 206.84,143.54 206.84,144.11 206.94,144.21 207.27,144.21 207.37,144.31 RN3601.2
  IN3 w0.102: v3(138.78,88.72) 138.83,88.72 139.1,88.99 139.1,89.27 139.35,89.52 140.25,89.52 140.62,89.15 141.45,89.15 142.04,89.75 143.57,89.75 144.99,91.17 147.28,91.17 148.57,92.47 151.17,92.47 151.57,92.06 151.57,90.23 153.22,88.58 154.44,88.58 157.52,91.66 157.52,97.16 157.26,97.42 157.26,105.53 158.21,106.48 158.21,107.62 158.51,107.92 158.51,111.3 163.78,116.57 172.94,116.57 177.31,112.21 180.5,112.21 183.34,115.05 183.67,115.05 188.73,120.11 188.73,129.1 190.31,130.67 190.31,135.6 190.56,135.86 190.56,138.74 194.02,142.2 198.45,142.2 198.56,142.2 200.62,144.26 204.02,144.26 204.2,144.44 204.2,144.84 v1(203.95,145.09)
  BOTTOM w0.076: 138.62,88.55 138.5,88.44 138,88.44 UC1.AG1
  BOTTOM w0.102: v3(138.78,88.72) 138.78,88.66 138.68,88.55 138.62,88.55
USB20_N9_R: length 10.8
  TOP w0.102: RN3601.1 207.37,146.93 207.11,147.2 207.11,147.35 206.46,147.99 206.09,147.99 v6(206.08,148.01) 206.07,147.99 205.67,147.99 205.45,147.77 205.45,146.98 205.27,146.8 204.62,146.8 v1(204.38,147.04)
  BOTTOM w0.102: JRCAM1.4 206.71,149.57 206.93,149.36 206.93,146.94 206.72,146.72 204.7,146.72 v1(204.38,147.04)
USB20_N10: length 94
  IN3 w0.102: v3(134.79,87.83) 134.63,87.99 134.63,88.12 134.76,88.25 135.96,88.25 138.39,85.81 140.76,85.81 141.03,86.09 141.03,87.09 142.7,88.76 147.97,88.76 148.86,87.87 151.47,87.87 152.46,86.88 156.42,86.88 157.41,87.87 157.41,89.93 159.73,92.24 159.73,96.61 158.34,98 158.34,105.04 159.21,105.91 159.21,107.19 159.5,107.48 159.5,110.59 164.39,115.48 172.61,115.48 177.08,111.01 181.59,111.01 183.81,113.22 186.27,113.22 187.77,114.72 187.77,117.72 188.53,118.48 189.55,118.48 189.88,118.81 189.88,119.61 v1(190.06,119.79)
  BOTTOM w0.102: UC1.AH7 134.47,88.15 v3(134.79,87.83) ; v1(190.06,119.79) 189.83,120.02 189.83,120.23 190.11,120.52 RN2728.4
USB20_N10_R: length 8.3
  BOTTOM w0.102: 189.22,123.86 v6(189.24,123.86) ; 189.22,123.86 188.9,124.17 188.9,125.04 186.98,126.96 186.23,126.96 185.95,127.24 185.95,127.97 186.1,128.12 U92.30 ; 189.22,123.86 189.8,123.28 189.8,122.92 190.11,122.61 RN2728.3
USB20_P1: length 66.4
  IN3 w0.102: v3(132.27,91) 132.27,90.63 132.13,90.49 131.88,90.49 131.61,90.21 131.61,89.57 131.96,89.22 131.98,89.22 132.93,88.27 132.93,87.56 133.32,87.18 135.73,87.18 136.54,86.37 136.54,86.04 137.9,84.67 141.16,84.67 143.75,87.27 146.99,87.27 149.31,84.95 151.98,84.95 153.12,83.81 154.01,83.81 155.05,84.85 158.71,84.85 160.15,86.29 164.07,86.29 165.95,84.41 175.37,84.41 177.38,86.42 177.38,88.22 178.32,89.17 179.33,89.17 179.69,88.81 179.69,88.44 179.96,88.16 180.33,88.16 v1(180.48,88.01)
  BOTTOM w0.102: v3(132.27,91) 132.27,91.29 UC1.AB10 ; v1(180.48,88.01) 180.33,88.17 180.15,88.17 180.02,88.04 180.02,86.81 179.54,86.32 178.4,86.32 178.31,86.23 JIOR1.43
USB20_P2: length 84.6
  IN3 w0.102: v3(134.53,91) 134.91,91.38 135.14,91.38 135.31,91.56 135.82,91.56 136.47,90.91 140.89,90.91 142.05,92.06 143.19,92.06 144.94,93.81 145.66,93.81 147.29,95.45 147.29,98.23 150.07,101.01 150.07,109.89 149.82,110.14 149.82,118.48 148.67,119.62 v1(148.02,119.62)
  IN4 w0.102: v1(148.02,119.62) 147.8,119.84 147.04,119.84 146.42,120.46 144.12,120.46 143.69,120.89 142.94,120.89 142.44,120.39 141.63,120.39 140.6,121.42 140.6,122.34 140.15,122.79 139.64,122.79 138.7,121.86 133.92,121.86 131.71,124.07 130.91,124.07 130.58,123.74 124.08,123.74 123.78,124.04 120.53,124.04 119.48,125.08 117.97,125.08 v1(117.77,124.88)
  BOTTOM w0.102: 116.6,125.34 113.98,125.34 112.84,124.19 112.84,123.84 112.56,123.56 111.92,123.56 111.6,123.24 L57.1 ; 116.6,125.34 v6(116.6,125.31) ; 116.6,125.34 117.23,125.34 117.33,125.24 117.33,125.06 117.51,124.88 v1(117.77,124.88) ; UC1.AD7 134.47,90.93 v3(134.53,91)
USB20_P2_R: length 2.8
  BOTTOM w0.102: RN483.1 109.48,123.26 109.21,123.53 108.78,123.53 108.49,123.24 108.08,123.24 107.91,123.08 JWWAN1.7
USB20_P3: length 37.6
  IN3 w0.102: v1(167.55,86.29) 165.55,86.29 164.55,87.29 157.8,87.29 156.35,85.84 154.64,85.84 153.98,85.18 153.25,85.18 152.49,85.94 149.93,85.94 147.59,88.28 142.93,88.28 141.9,87.25 v1(141.9,86.59)
  BOTTOM w0.076: 140.99,87.05 138.5,87.05 138.01,87.53 137.74,87.53 137.62,87.49 137.45,87.49 137.29,87.53 137.09,87.53 136.98,87.5 136.59,87.5 136.54,87.45 UC1.AJ3
  BOTTOM w0.102: 140.99,87.05 141.44,87.05 v1(141.9,86.59) ; L7106.1 168.63,84.75 168.31,85.08 168.31,85.8 168.04,86.07 167.77,86.07 v1(167.55,86.29)
USB20_P3_R: length 14.4
  BOTTOM w0.102: 164.96,83.6 166.9,81.66 168.05,81.66 168.41,82.02 168.41,82.44 168.63,82.66 L7106.2 ; 164.96,83.6 v6(164.96,83.58) ; 164.96,83.6 161.91,86.65 JDOCK1.35
USB20_P4: length 183.1
  IN3 w0.102: v1(25.61,94.15) 25.78,94.32 26.63,94.32 28.02,92.93 40.88,92.93 42.98,90.82 51.51,90.82 53.26,92.57 55.33,92.57 56.58,93.82 68.57,93.82 74.94,87.44 74.94,81.85 77.58,79.21 82.64,79.21 84.59,81.16 88.28,81.16 93.89,75.55 93.89,73.47 105.34,62.01 140.73,62.01 141.74,61 141.74,60.39 v1(141.54,60.19)
  IN4 w0.102: v1(141.54,60.19) 141.77,60.41 141.77,61.89 146.87,66.99 146.87,69.17 144.98,71.07 143.69,71.07 142.76,72 142.76,77.12 141.15,78.73 140.03,78.73 137.48,81.29 137.48,84.8 135.06,87.21 133.36,87.21 132.83,87.75 132.83,89.07 133.03,89.28 133.03,89.62 v3(132.83,89.83)
  BOTTOM w0.102: U6204.3 24.92,95.75 25.17,95.5 25.17,94.59 v1(25.61,94.15) ; v3(132.83,89.83) 132.98,89.98 132.98,90.18 132.7,90.46 UC1.AD10
USB20_P4_R: length 7.8
  BOTTOM w0.102: JUSB1.3 13.9,93.55 14,93.65 15.02,93.65 15.63,94.26 15.63,95.76 15.77,95.9 16.62,95.9 D7109.1 17.65,95.95 18.04,95.95 18.29,95.7 RN249.4
USB20_P5: length 66.7
  IN3 w0.102: v1(139.74,86.64) 139.54,86.83 139.54,87.06 139.29,87.31 138.6,87.31 138.01,87.9 138.01,89.44 138.46,89.89 141.38,89.89 141.85,90.36 143.12,90.36 145.2,92.44 147.23,92.44 148.5,93.71 150.92,93.71 151.32,94.12 151.32,99.35 151.9,99.93 151.9,104.31 152.77,105.17 152.77,119.27 151.95,120.08 151.95,128.31 156.12,132.47 v1(156.4,132.47)
  BOTTOM w0.102: v1(139.74,86.64) 139.74,86.07 139.42,85.75 138.97,85.75 137.81,86.91 137.48,86.91 137.19,87.19 UC1.AJ2 ; L76.1 155.69,133.05 155.69,133.05 155.69,132.88 155.89,132.69 156.18,132.69 v1(156.4,132.47)
USB20_P5_R: length 9.1
  BOTTOM w0.102: JUSB2.3 151.95,140.45 152.15,140.26 152.15,139.49 152.54,139.1 155.55,139.1 156.09,138.56 156.09,138.32 D67.1 156.02,137.32 156.02,136.59 155.72,136.29 RN247.4
USB20_P6: length 90.5
  IN4 w0.102: v3(134.19,89.83) 134.7,89.32 134.86,89.32 135.34,88.84 137.58,88.84 138.29,88.13 140.9,88.13 140.96,88.18 149.71,88.18 151.39,86.49 151.39,81.34 152.26,80.48 152.26,79.69 153.19,78.75 153.33,78.75 154.88,77.2 154.88,76.91 154.56,76.59 154.56,74.12 154.46,74.02 152.8,74.02 150.24,71.46 150.24,67.49 151.17,66.56 151.17,58.1 151.82,57.44 157.23,57.44 158.15,56.53 158.15,51.07 161.69,47.53 162.49,47.53 162.64,47.38 165.59,47.38 166.09,46.88 171.79,46.88 172.46,47.54 172.46,49.46 172.82,49.83 174.9,49.83 175.3,50.23 175.3,50.64 v1(175.55,50.89)
  BOTTOM w0.102: JSH1.8 175.2,50.25 175.37,50.42 175.37,50.71 v1(175.55,50.89) ; UC1.AF7 v3(134.19,89.83)
USB20_P7: length 90.4
  IN4 w0.102: v1(177.06,47.46) 177.06,46.64 176.68,46.27 162.97,46.27 162.71,46.01 161.12,46.01 160.16,46.98 160.16,48.28 157.67,50.77 157.67,56.33 157.03,56.96 151.14,56.96 150.25,57.85 150.25,65.17 148.55,66.87 148.55,70.17 147.71,71.01 147.71,72.36 146.75,73.32 145.6,73.32 144.33,74.59 144.33,76.51 149.55,81.73 149.55,84.97 146.83,87.69 141.11,87.69 140.68,87.26 139.34,87.26 139.24,87.36 139.24,87.52 v3(139.43,87.72)
  BOTTOM w0.076: v3(139.43,87.72) 139.08,88.08 137.92,88.08 137.59,88.21 137.47,88.21 137.31,88.16 137.1,88.16 UC1.AH2
  BOTTOM w0.102: v1(177.06,47.46) 177.06,46.45 178.1,45.41 178.93,45.41 180.07,44.27 180.07,43.6 179.73,43.25 L3602.4
