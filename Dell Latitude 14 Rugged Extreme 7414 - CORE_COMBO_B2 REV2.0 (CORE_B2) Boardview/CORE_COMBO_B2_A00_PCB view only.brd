# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D29: length 47.2
  IN4 w0.089: v1(97.04,41.01) 97.45,41.41 97.45,45.42 96.9,45.97 96.9,48.71 97.47,49.28 97.47,52.1 98.19,52.82 98.19,72.51 100.04,74.36 100.04,74.56 101.49,76.01 101.84,76.01 102.88,77.05 102.88,77.99 v3(103.61,78.72)
  BOTTOM w0.076: v3(103.61,78.72) 103.61,78.79 103.41,78.99 103.41,79.27 arc(103.42,79.33) 103.42,79.4 arc(103.45,79.52) 103.48,79.63 103.53,79.76 arc(103.57,79.89) 103.6,80.02 arc(103.6,80.13) 103.58,80.23 arc(103.56,80.31) 103.55,80.4 arc(103.56,80.5) 103.58,80.6 arc(103.58,80.62) 103.59,80.63 arc(103.6,80.76) 103.57,80.89 103.48,81.09 arc(103.43,81.23) UC1.AY61
  BOTTOM w0.108: v1(97.04,41.01) 97.29,41.01 98.51,39.79 JDIMM1.70
DDR_A_D30: length 47.8
  IN4 w0.089: v3(104.76,76.12) 104.48,76.12 103.92,75.56 103.92,74.76 102.91,73.75 102.91,72.76 101.24,71.09 101.24,49.33 102.16,48.41 102.16,47.6 102.6,47.17 102.6,43.4 102.51,43.31 101.98,43.31 101.89,43.22 101.89,43.04 101.98,42.95 102.51,42.95 102.6,42.86 102.6,42.69 102.51,42.6 102.08,42.6 101.97,42.48 101.97,42.36 102.08,42.24 102.51,42.24 102.6,42.15 102.6,41.43 v1(101.53,40.37)
  BOTTOM w0.076: v3(104.76,76.12) 105.42,76.79 105.42,77.28 105.27,77.43 105.27,78.97 105.02,79.22 105.02,79.79 arc(105.01,79.92) 104.98,80.04 104.86,80.33 UC1.BA59
  BOTTOM w0.108: JDIMM1.84 102.01,39.9 v1(101.53,40.37)
DDR_A_D31: length 48.1
  IN4 w0.089: v1(101.53,41.01) 101.53,43.47 102.29,44.23 102.29,47.02 102.05,47.25 102.05,47.25 101.86,47.45 101.86,48.28 100.93,49.21 100.93,71.08 102.58,72.73 102.58,73.85 103.69,74.97 103.69,75.59 104.62,76.52 v3(106.49,76.52)
  BOTTOM w0.076: UC1.AY59 104.65,81.18 104.92,80.91 104.92,80.72 105.05,80.29 105.14,80.09 arc(105.17,79.94) 105.18,79.79 105.18,79.29 105.43,79.04 105.43,77.61 v6(105.75,77.3) 106.49,76.56 v3(106.49,76.52)
  BOTTOM w0.108: v1(101.53,41.01) 101.01,40.49 JDIMM1.80
DDR_A_D32: length 48.3
  IN4 w0.089: v3(115,78.1) 115.4,77.7 115.4,76.14 115.03,75.77 115.03,71.26 115.99,70.3 115.99,62.8 116.71,62.08 116.71,59 123.11,52.6 123.11,50.07 124.44,48.74 124.44,41.4 124.72,41.12 124.72,39.89 124.88,39.74 v1(125.51,39.74)
  BOTTOM w0.076: UC1.AY39 115.7,81.18 115.43,80.91 115.43,80.63 115.33,80.37 115.26,80.24 115.26,79.04 115.44,78.86 115.44,78.54 v3(115,78.1)
  BOTTOM w0.108: JDIMM1.170 v1(125.51,39.74)
DDR_A_D33: length 46.7
  IN4 w0.089: v3(116.84,77.29) 116.22,76.67 116.22,75.19 115.95,74.92 115.95,71.64 117.43,70.16 117.43,62.66 117.62,62.46 117.62,59.38 125.96,51.04 125.96,48.69 126.38,48.28 126.38,44.77 v1(125.66,44.06)
  BOTTOM w0.076: UC1.AW39 116.42,82.03 116.6,81.85 116.6,81.39 arc(116.61,81.32) 116.63,81.25 arc(116.66,81.11) 116.63,80.98 arc(116.6,80.87) 116.58,80.77 arc(116.59,80.65) 116.62,80.54 arc(116.64,80.43) 116.62,80.32 116.61,80.27 116.61,80.24 arc(116.59,80.19) 116.59,80.14 arc(116.59,80.09) 116.59,80.03 arc(116.6,79.94) 116.62,79.85 arc(116.64,79.8) 116.66,79.76 116.73,79.63 arc(116.74,79.61) 116.75,79.58 arc(116.78,79.48) 116.79,79.38 116.79,77.34 v3(116.84,77.29)
  BOTTOM w0.108: v1(125.66,44.06) 126.17,44.57 126.17,45.45 126.26,45.54 JDIMM1.173
DDR_A_D34: length 48.6
  IN4 w0.089: v1(129.01,41.14) 128.84,41.14 128.31,41.66 128.31,50.85 119.15,60.02 119.15,63.09 118.95,63.29 118.95,70.8 117.47,72.27 117.47,75.03 117.38,75.13 117.38,76.47 v3(117.74,76.83)
  BOTTOM w0.076: v3(117.74,76.83) 117.38,77.19 117.38,77.95 116.96,78.38 116.96,79.38 arc(116.95,79.51) 116.91,79.64 arc(116.89,79.68) 116.87,79.71 116.81,79.84 arc(116.79,79.87) 116.78,79.91 arc(116.76,79.97) 116.75,80.04 arc(116.75,80.09) 116.75,80.13 arc(116.76,80.17) 116.77,80.2 116.78,80.28 arc(116.8,80.44) 116.77,80.6 arc(116.75,80.68) 116.75,80.76 arc(116.77,80.89) 116.83,81.01 arc(116.91,81.19) UC1.AY37
  BOTTOM w0.108: v1(129.01,41.14) 129.51,40.64 JDIMM1.186
DDR_A_D35: length 49
  IN4 w0.089: v3(117.74,75.54) 117.78,75.5 117.78,72.4 119.26,70.92 119.26,63.41 119.54,63.13 119.54,62.74 119.67,62.61 120.05,62.61 120.18,62.48 120.18,62.29 120.05,62.16 119.67,62.16 119.54,62.03 119.54,61.85 119.67,61.72 120.05,61.72 120.18,61.59 120.18,61.43 120.1,61.35 119.95,61.35 119.87,61.28 119.87,60.96 120.18,60.66 120.18,60.44 120.05,60.31 119.67,60.31 119.54,60.19 119.54,60.05 128.62,50.98 128.62,50.57 128.75,50.44 128.96,50.44 129.09,50.31 129.09,50.13 128.96,50 128.75,50 128.62,49.87 128.62,49.68 128.75,49.55 128.96,49.55 129.09,49.42 129.09,49.24 128.96,49.11 128.75,49.11 128.62,48.98 128.62,48.79 128.75,48.66 128.96,48.66 129.09,48.53 129.09,48.35 128.96,48.22 128.75,48.22 128.62,48.09 128.62,47.9 128.75,47.77 128.96,47.77 129.09,47.64 129.09,47.46 128.96,47.33 128.75,47.33 128.62,47.2 128.62,47.02 128.75,46.89 128.96,46.89 129.09,46.76 129.09,46.57 128.71,46.19 v1(128.71,45.33)
  BOTTOM w0.076: v3(117.74,75.54) 117.88,75.4 118.07,75.4 118.26,75.59 118.26,77.78 117.45,78.58 117.45,80.54 arc(117.41,80.75) 117.29,80.93 arc(117.25,80.98) 117.23,81.05 arc(117.22,81.18) 117.24,81.31 arc(117.25,81.41) 117.23,81.51 arc(117.17,81.63) 117.08,81.73 arc(116.96,81.86) UC1.AW37
  BOTTOM w0.108: JDIMM1.183 128.76,45.38 v1(128.71,45.33)
DDR_A_D36: length 46.9
  IN4 w0.089: v7(116.03,78.46) 116.03,78.43 115.67,78.07 115.67,75.67 115.34,75.34 115.34,71.39 116.3,70.43 116.3,62.92 117.01,62.21 117.01,59.13 123.41,52.73 123.41,51.04 125.16,49.3 125.16,48.6 124.99,48.44 124.99,45.77 125.26,45.49 125.26,41.26 v1(125.51,41.01)
  BOTTOM w0.076: UC1.BB39 115.7,79.86 115.63,79.78 115.63,79.15 116.03,78.74 v7(116.03,78.46)
  BOTTOM w0.108: v1(125.51,41.01) 126.51,40.01 JDIMM1.174
DDR_A_D37: length 47.1
  IN4 w0.089: v1(125.66,44.69) 126.06,45.09 126.06,46.69 125.69,47.07 125.43,47.07 125.3,47.2 125.3,47.38 125.43,47.51 125.71,47.51 125.84,47.64 125.84,47.82 125.71,47.95 125.43,47.95 125.3,48.09 125.3,48.31 125.66,48.67 125.66,49.23 125.06,49.82 125.06,50 125.16,50.1 125.46,50.4 125.46,50.58 125.33,50.71 125.15,50.71 124.75,50.32 124.57,50.32 124.44,50.45 124.44,50.63 124.83,51.03 124.83,51.21 124.7,51.34 124.52,51.34 124.12,50.95 123.94,50.95 123.72,51.17 123.72,52.86 117.32,59.26 117.32,62.33 116.6,63.05 116.6,70.56 115.64,71.52 115.64,75.18 116.03,75.57 v3(116.03,77.8)
  BOTTOM w0.076: v3(116.03,77.8) 115.65,78.18 115.65,78.89 115.45,79.08 115.45,79.87 115.43,79.89 115.43,80.19 115.55,80.44 115.55,80.44 115.56,80.44 115.7,80.58 UC1.BA39
  BOTTOM w0.108: JDIMM1.169 125.26,45.69 125.26,45.68 125.26,45.1 v1(125.66,44.69)
DDR_A_D38: length 47.9
  IN4 w0.089: v1(128.71,44.06) 128.71,43.52 128.79,43.45 129.32,43.45 129.42,43.54 129.42,44.18 129.27,44.33 129.27,44.72 129.42,44.86 129.42,45.15 129.17,45.4 129.17,45.73 129.42,45.98 129.42,50.61 120.48,59.54 120.48,62.62 119.56,63.54 119.56,71.05 118.08,72.53 118.08,75.01 118.17,75.1 118.17,75.89 117.89,76.17 v3(117.74,76.17)
  BOTTOM w0.076: UC1.BA37 117.02,80.52 117.29,80.25 117.29,78.52 118.1,77.71 118.1,76.25 118.02,76.17 v3(117.74,76.17)
  BOTTOM w0.108: v1(128.71,44.06) 129.12,44.06 129.76,44.7 JDIMM1.187
DDR_A_D39: length 47.2
  IN4 w0.089: v1(129.01,40.5) 128.01,41.51 128.01,50.72 118.84,59.89 118.84,62.97 118.65,63.16 118.65,70.67 117.17,72.15 117.17,74.92 117.2,74.95 117.2,76.54 117.38,76.72 117.38,77.11 v3(117.74,77.47)
  BOTTOM w0.076: v3(117.74,77.47) 117.74,77.83 117.12,78.45 117.12,79.69 117.02,79.79 UC1.BB37
  BOTTOM w0.108: v1(129.01,40.5) 128.51,40 JDIMM1.182
DDR_A_D40: length 51.7
  IN4 w0.089: v1(130.49,41.01) 130.77,41.29 130.77,41.52 130.64,41.64 130.12,41.64 129.75,42.01 129.75,42.37 129.99,42.61 130.74,42.61 130.93,42.79 130.93,43.28 130.8,43.41 130.35,43.41 130.22,43.54 130.22,50.94 121.28,59.88 121.28,62.95 120.36,63.87 120.36,71.38 118.94,72.8 v3(118.94,75.29)
  BOTTOM w0.076: UC1.AY35 118.32,80.82 arc(118.33,80.71) 118.31,80.6 arc(118.27,80.42) 118.3,80.24 arc(118.31,80.19) 118.32,80.14 118.32,78.66 118.92,78.05 118.92,77.59 119.44,77.07 v6(119.44,76.15) 119.44,75.17 119.31,75.05 119.02,75.05 118.94,75.12 v3(118.94,75.29)
  BOTTOM w0.108: JDIMM1.194 131.51,40 130.51,41.01 v1(130.49,41.01)
DDR_A_D41: length 52.6
  IN4 w0.089: v3(118.94,75.85) 119.18,75.85 119.3,75.72 119.3,72.87 120.67,71.51 120.67,64 121.21,63.45 121.75,63.45 121.91,63.3 121.91,63.11 121.8,63.01 121.72,63.01 121.59,62.88 121.59,62.69 121.72,62.56 122.45,62.56 122.61,62.4 122.61,62.22 122.51,62.12 121.72,62.12 121.59,61.99 121.59,60 125.34,56.25 125.47,56.25 125.82,56.6 125.95,56.6 126.25,56.3 126.25,56.18 125.89,55.82 125.89,55.7 126.19,55.4 126.31,55.4 126.67,55.76 126.79,55.76 127.09,55.46 127.09,55.33 126.73,54.98 126.73,54.85 130.52,51.07 130.52,44.13 130.65,44.01 v1(130.92,44.01)
  BOTTOM w0.076: v3(118.94,75.85) 118.55,75.85 118.43,75.98 118.43,77.85 117.62,78.65 117.62,80.76 117.82,80.96 arc(117.86,81.13) 117.84,81.3 arc(117.83,81.4) 117.85,81.51 arc(117.9,81.61) 117.98,81.69 arc(118.1,81.84) UC1.AW35
  BOTTOM w0.108: JDIMM1.195 131.76,44.87 131.94,44.69 131.94,44.16 131.79,44.01 v1(130.92,44.01)
DDR_A_D42: length 52.3
  IN4 w0.089: v1(134.17,44.06) 134.17,43.8 134.06,43.69 133.73,43.69 133.54,43.88 133.54,44.06 133.18,44.42 133.18,46.22 133.08,46.32 132.81,46.32 132.73,46.41 132.73,46.53 132.81,46.62 133.06,46.62 133.18,46.74 133.18,46.97 133.09,47.06 132.77,47.06 132.68,47.15 132.68,47.57 132.77,47.66 133.09,47.66 133.18,47.75 133.18,48.17 133.09,48.25 132.77,48.25 132.68,48.34 132.68,48.76 132.77,48.85 133.09,48.85 133.18,48.94 133.18,49.25 133.09,49.33 132.79,49.33 132.7,49.42 132.7,49.6 132.79,49.69 133.09,49.69 133.18,49.78 133.18,49.96 133.09,50.05 132.79,50.05 132.7,50.13 132.7,50.31 132.79,50.4 133.09,50.4 133.18,50.49 133.18,51.43 129.52,55.08 129.52,56.2 125.51,60.21 125.51,62.76 123.36,64.91 123.36,69.65 123.18,69.84 v1(122.64,69.84)
  BOTTOM w0.076: 121.21,75.49 121.06,75.64 121.06,77.23 120.5,77.79 120.5,78.26 119.67,79.09 119.67,79.47 119.81,79.61 119.81,80.21 119.65,80.56 119.65,80.91 119.38,81.18 UC1.AY33
  BOTTOM w0.108: JDIMM1.207 134.76,44.65 v1(134.17,44.06) ; 121.21,75.49 121.61,75.49 121.91,75.19 v6(121.91,74.53) 121.91,73.05 123.23,71.74 123.23,69.99 123.07,69.84 v1(122.64,69.84)
DDR_A_D43: length 50.8
  IN4 w0.089: v1(133.92,39.87) 133.44,40.35 133.44,42.99 132.07,44.36 132.07,51.67 128.91,54.83 128.91,55.95 124.9,59.96 124.9,62.46 122.19,65.17 122.19,72.14 120.84,73.49 120.84,74.9 120.71,75.02 120.71,75.81 v3(119.95,76.57)
  BOTTOM w0.076: UC1.AW33 118.66,82.03 118.65,82.03 arc(118.58,81.99) 118.53,81.93 arc(118.47,81.78) 118.48,81.61 arc(118.5,81.49) 118.49,81.37 arc(118.47,81.3) 118.44,81.24 arc(118.42,81.14) 118.43,81.03 118.48,80.87 arc(118.5,80.7) 118.46,80.53 arc(118.43,80.41) 118.45,80.3 arc(118.48,80.22) 118.48,80.14 118.48,78.72 119.09,78.12 119.09,77.66 119.95,76.8 v3(119.95,76.57)
  BOTTOM w0.108: JDIMM1.204 134.01,39.77 v1(133.92,39.87)
DDR_A_D44: length 50.4
  IN4 w0.089: v3(118.97,77.03) 119.46,77.03 119.59,76.91 119.59,75.07 119.61,75.05 119.61,73 120.97,71.63 120.97,64.66 123.38,62.26 123.38,61.88 123.18,61.69 122.19,61.69 122.06,61.56 122.06,61.38 122.19,61.25 122.94,61.25 123.12,61.07 123.12,60.65 122.97,60.49 122.16,60.49 122.03,60.36 122.03,60.18 122.16,60.05 123.06,60.05 123.2,59.91 123.2,59.7 122.88,59.38 122.88,59.14 123.18,58.84 123.36,58.84 123.71,59.19 123.89,59.19 124.02,59.06 124.02,58.87 123.68,58.53 123.68,58.34 123.81,58.21 123.99,58.21 124.34,58.56 124.52,58.56 124.65,58.43 124.65,58.25 124.3,57.9 124.3,57.71 124.43,57.58 124.62,57.58 124.97,57.93 125.15,57.93 125.35,57.73 125.35,57.48 125.11,57.24 125.11,57.11 125.31,56.91 125.44,56.91 125.69,57.16 125.92,57.16 127.47,55.61 127.47,54.55 130.85,51.17 130.85,45.35 v1(130.92,45.28)
  BOTTOM w0.076: v3(118.97,77.03) 118.76,77.24 118.76,77.98 118.05,78.69 UC1.BB35
  BOTTOM w0.108: v1(130.92,45.28) 130.76,45.44 JDIMM1.191
DDR_A_D45: length 50.7
  IN4 w0.089: v3(118.94,76.44) 118.67,76.44 118.58,76.34 118.58,72.73 120.06,71.25 120.06,63.75 120.98,62.83 120.98,59.75 129.91,50.81 129.91,43.12 129.71,42.91 129.04,42.91 128.92,42.79 128.92,41.8 129.04,41.67 129.59,41.67 129.79,41.47 129.79,40.32 129.71,40.25 129.58,40.25 129.45,40.12 129.45,39.87 129.58,39.74 v1(130.49,39.74)
  BOTTOM w0.076: v3(118.94,76.44) 118.67,76.44 118.59,76.51 118.59,77.92 117.78,78.72 117.78,80.47 UC1.BA35
  BOTTOM w0.108: v1(130.49,39.74) 130.51,39.72 JDIMM1.190
DDR_A_D46: length 51.3
  IN4 w0.089: v1(134.17,44.69) 133.82,44.69 133.48,45.03 133.48,46.07 133.61,46.2 134.12,46.2 134.25,46.33 134.25,46.51 134.12,46.64 133.61,46.64 133.48,46.77 133.48,46.96 133.61,47.09 133.99,47.09 134.12,47.22 134.12,47.4 133.99,47.53 133.61,47.53 133.48,47.66 133.48,47.85 133.61,47.98 133.99,47.98 134.12,48.11 134.12,48.29 133.99,48.42 133.61,48.42 133.48,48.55 133.48,48.73 133.61,48.87 133.99,48.87 134.12,49 134.12,49.18 133.99,49.31 133.61,49.31 133.48,49.44 133.48,49.62 133.61,49.75 133.99,49.75 134.12,49.88 134.12,50.07 133.99,50.2 133.61,50.2 133.48,50.33 133.48,50.51 133.61,50.64 133.99,50.64 134.12,50.77 134.12,50.96 133.99,51.09 133.61,51.09 133.48,51.22 133.48,51.56 129.83,55.21 129.83,56.33 125.81,60.34 125.81,62.89 123.66,65.04 123.66,69.88 123.1,70.45 v1(122.64,70.45)
  BOTTOM w0.076: 121.32,74.92 120.9,75.34 120.9,77.16 120.34,77.72 120.34,78.19 119.51,79.02 119.51,79.56 119.65,79.7 119.65,80.18 119.53,80.43 119.38,80.58 UC1.BA33
  BOTTOM w0.108: v1(134.17,44.69) 133.76,45.1 JDIMM1.203 ; v1(122.64,70.45) 122.13,70.45 121.32,71.26 v6(121.32,72.28) 121.32,74.92
DDR_A_D47: length 50.4
  IN4 w0.089: v1(122.64,69.23) 122.95,69.23 123.06,69.12 123.06,64.79 125.2,62.64 125.2,60.09 129.22,56.07 129.22,54.96 132.38,51.8 132.38,51.35 132.48,51.25 132.55,51.25 132.68,51.12 132.68,50.86 132.62,50.81 132.5,50.81 132.38,50.69 132.38,44.48 133.69,43.17 134.17,43.17 134.38,42.96 134.38,42.41 134.12,42.15 134,42.15 133.92,42.08 v1(133.92,41.14)
  BOTTOM w0.076: 120.73,74.84 120.73,77.09 120.17,77.65 120.17,78.12 119.34,78.95 119.34,79.65 119.48,79.79 119.48,79.98 UC1.BB33
  BOTTOM w0.108: 120.73,74.84 v6(120.73,70.48) 120.73,69.89 121.4,69.23 v1(122.64,69.23) ; v1(133.92,41.14) 134.33,41.14 135.01,40.45 JDIMM1.208
DDR_A_D48: length 52.9
  IN4 w0.089: v3(121.16,77.63) 121.78,77.01 121.78,75.07 121.94,74.91 121.94,73.95 123.84,72.06 123.84,71.27 124.77,70.34 124.77,65.5 127.64,62.63 127.64,60.08 131.94,55.78 131.94,54.7 135.55,51.1 135.55,41.75 135.66,41.63 136.45,41.63 136.56,41.75 136.56,42.03 136.43,42.15 136.1,42.15 135.98,42.28 135.98,44.03 v1(135.95,44.06)
  BOTTOM w0.076: v3(121.16,77.63) 121.16,77.96 120.41,78.71 120.41,79.62 120.25,79.78 120.25,80.15 arc(120.27,80.37) 120.34,80.57 arc(120.39,80.69) 120.41,80.83 arc(120.45,80.96) 120.54,81.06 arc(120.65,81.2) UC1.AY31
  BOTTOM w0.108: v1(135.95,44.06) 136.76,44.87 JDIMM1.215
DDR_A_D49: length 53.6
  IN4 w0.089: v3(122.63,77.31) 122.34,77.31 121.96,76.93 121.96,75.2 122.25,74.91 122.25,74.08 124.14,72.18 124.14,71.4 125.07,70.47 125.07,65.63 128.55,62.15 128.55,59.6 132.24,55.91 132.24,54.83 134.41,52.67 134.59,52.67 134.94,53.01 135.12,53.01 135.25,52.88 135.25,52.7 134.91,52.35 134.91,52.17 135.04,52.04 135.22,52.04 135.57,52.38 135.75,52.38 135.88,52.25 135.88,52.07 135.54,51.72 135.54,51.54 135.85,51.22 135.85,46.11 135.98,45.99 136.54,45.99 136.82,45.71 136.82,43.31 136.69,43.18 136.49,43.18 136.36,43.31 136.36,44.92 v1(135.95,45.33)
  BOTTOM w0.076: UC1.AW31 121.33,82.03 arc(121.55,81.87) 121.58,81.59 arc(121.56,81.39) 121.6,81.19 arc(121.63,81.08) 121.61,80.97 121.57,80.87 121.57,80.61 121.61,80.49 121.61,80.31 121.58,80.26 121.57,80.23 121.57,79.7 121.87,79.4 121.87,78.56 122.27,78.16 122.27,77.38 122.35,77.31 v3(122.63,77.31)
  BOTTOM w0.108: JDIMM1.211 135.76,45.52 v1(135.95,45.33)
DDR_A_D50: length 52.5
  IN4 w0.089: v3(122.63,77.86) 123.22,77.27 123.22,75.61 123.51,75.31 123.51,74.54 125.51,72.54 125.51,72.05 126.61,70.95 126.61,65.81 129.77,62.66 129.77,60.11 137.47,52.4 137.47,47.91 138.84,46.55 138.84,43.8 138.75,43.72 138.3,43.72 138.21,43.63 138.21,43.47 138.33,43.36 138.75,43.36 138.84,43.27 138.84,42.5 v1(137.98,41.64)
  BOTTOM w0.076: UC1.AY29 121.8,81.28 121.8,81.03 121.74,80.84 121.74,80.65 121.77,80.52 121.77,80.27 121.74,80.19 121.74,79.77 122.03,79.47 122.03,78.63 122.63,78.04 v3(122.63,77.86)
  BOTTOM w0.108: v1(137.98,41.64) 138.39,41.64 140.01,40.02 JDIMM1.228
DDR_A_D51: length 52.8
  IN4 w0.089: v1(139.55,44.64) 139.95,45.04 139.95,45.9 139.56,46.29 139.56,47.49 139.4,47.65 139.26,47.65 138.99,47.38 138.86,47.38 138.74,47.51 138.74,47.63 139.01,47.9 139.01,48.04 138.45,48.6 138.19,48.6 138.08,48.71 138.08,49.1 138.21,49.23 138.59,49.23 138.72,49.36 138.72,49.55 138.59,49.68 138.21,49.68 138.08,49.81 138.08,49.99 138.21,50.12 138.59,50.12 138.72,50.25 138.72,50.44 138.59,50.57 138.21,50.57 138.08,50.7 138.08,50.88 138.21,51.01 138.59,51.01 138.72,51.14 138.72,51.33 138.59,51.46 138.21,51.46 138.08,51.59 138.08,52.65 130.76,59.98 130.76,62.53 127.22,66.06 127.22,73.31 126.95,73.58 125.33,73.58 124.12,74.79 124.12,76.46 123.71,76.87 v3(123.58,76.87)
  BOTTOM w0.076: v3(123.58,76.87) 123.81,76.87 123.94,77 123.94,77.65 123.67,77.92 123.61,77.92 122.53,79 122.53,79.7 122.44,79.79 122.44,80.38 arc(122.38,80.69) 122.23,80.96 arc(122.19,81.06) 122.2,81.17 arc(122.22,81.28) 122.23,81.4 arc(122.2,81.53) 122.13,81.65 arc(121.99,81.83) UC1.AW29
  BOTTOM w0.108: v1(139.55,44.64) 140.26,45.36 JDIMM1.229
DDR_A_D52: length 51.5
  IN4 w0.089: v1(135.95,41.14) 135.52,40.7 135.52,40.15 135.43,40.06 135.09,40.06 134.96,40.18 134.96,41.64 135.24,41.92 135.24,50.97 131.63,54.58 131.63,55.66 127.33,59.95 127.33,62.5 124.46,65.37 124.46,70.21 123.53,71.15 123.53,71.93 121.64,73.83 121.64,74.91 121.42,75.12 v3(121.42,75.91)
  BOTTOM w0.076: v3(121.42,75.91) 121.78,76.26 121.78,77.81 120.75,78.84 120.75,80.01 UC1.BB31
  BOTTOM w0.108: JDIMM1.216 137.01,40.48 136.36,41.14 v1(135.95,41.14)
DDR_A_D53: length 52
  IN4 w0.089: v1(135.95,39.87) 136.25,39.87 136.38,39.74 136.38,39.41 136.25,39.28 134.78,39.28 134.66,39.41 134.66,41.76 134.94,42.04 134.94,50.84 131.32,54.46 131.32,55.53 127.03,59.83 127.03,62.38 124.16,65.25 124.16,70.09 123.23,71.02 123.23,71.8 121.33,73.7 121.33,74.9 121.06,75.18 121.06,76.11 v3(121.42,76.48)
  BOTTOM w0.076: v3(121.42,76.48) 121.44,76.48 121.52,76.55 121.52,77.84 120.58,78.77 120.58,79.7 120.41,79.87 120.41,80.15 arc(120.43,80.33) 120.49,80.5 arc(120.57,80.62) UC1.BA31
  BOTTOM w0.108: JDIMM1.212 136.01,39.8 v1(135.95,39.87)
DDR_A_D54: length 51.5
  IN4 w0.089: v3(123.58,77.45) 124.44,76.59 124.44,74.92 125.47,73.89 127.08,73.89 127.53,73.44 127.53,66.19 131.06,62.66 131.06,60.11 139.03,52.14 139.03,48.46 139.87,47.61 139.87,46.49 140.25,46.11 140.25,42.77 140.13,42.65 139.67,42.65 139.55,42.77 v1(139.55,44.02)
  BOTTOM w0.076: v3(123.58,77.45) 123.58,77.71 122.36,78.93 122.36,79.61 122.27,79.7 122.27,80.24 122,80.5 UC1.BA29
  BOTTOM w0.108: JDIMM1.225 139.26,45.69 139,45.43 139,44.57 v1(139.55,44.02)
DDR_A_D55: length 50.5
  IN4 w0.089: v3(123.58,76.32) 123.94,75.95 123.94,75.31 123.82,75.18 123.82,74.66 125.2,73.28 126.55,73.28 126.92,72.91 126.92,65.94 130.07,62.78 130.07,60.23 137.78,52.53 137.78,48.03 139.14,46.67 139.14,42.17 v1(137.98,41.01)
  BOTTOM w0.076: UC1.BB29 122,79.73 122.2,79.54 122.2,78.86 123.09,77.96 123.09,76.8 v3(123.58,76.32)
  BOTTOM w0.108: v1(137.98,41.01) 138.01,41.01 139.01,40 JDIMM1.224
DDR_A_D56: length 54
  IN4 w0.089: v1(144.84,44.18) 145.24,44.58 145.24,45.75 145.15,45.84 145.15,48.32 143.54,49.93 143.54,51.62 143.19,51.98 143.19,52.99 134.71,61.47 134.71,65.39 134.4,65.7 134.4,72.68 133.46,73.62 133.46,73.92 128.65,78.73 125.31,78.73 124.8,78.22 v3(124.8,77.36)
  BOTTOM w0.076: v3(124.8,77.36) 124.8,77.53 124.65,77.68 124.65,77.87 123.68,78.84 123.62,78.84 123.19,79.27 123.19,79.82 123.3,79.93 123.3,80.18 123.26,80.27 123.26,80.54 123.3,80.63 123.3,80.83 123.23,81.02 123.23,81.28 UC1.AY27
  BOTTOM w0.108: v1(144.84,44.18) 145.26,44.61 JDIMM1.249
DDR_A_D57: length 54.9
  IN4 w0.089: v1(141.51,40.5) 141.06,40.5 140.93,40.63 140.63,40.63 140.45,40.81 140.45,40.91 140.75,41.21 140.75,41.44 140.6,41.59 140.02,41.59 139.91,41.69 139.91,41.95 140.04,42.08 140.6,42.08 140.75,42.23 140.75,46.34 140.38,46.71 140.38,47.8 139.52,48.66 139.52,52.35 131.56,60.31 131.56,62.86 128.38,66.04 128.38,70.55 128.02,70.9 128.02,73.64 127.28,74.38 125.74,74.38 125.01,75.11 v3(124.8,75.11)
  BOTTOM w0.076: v3(124.8,75.11) 124.1,75.81 124.1,77.72 123.69,78.13 123.62,78.13 122.69,79.06 122.69,79.77 122.6,79.86 122.6,80.43 arc(122.64,80.68) 122.75,80.89 arc(122.8,80.99) 122.84,81.08 arc(122.85,81.17) 122.82,81.25 arc(122.8,81.47) 122.93,81.64 arc(123.08,81.81) UC1.AW27
  BOTTOM w0.108: v1(141.51,40.5) 141.03,40.02 141.03,39.48 141.01,39.46 JDIMM1.232
DDR_A_D58: length 53.8
  IN4 w0.089: v1(144.84,44.82) 144.46,44.82 144.35,44.93 144.35,46.22 144.44,46.31 144.76,46.31 144.85,46.4 144.85,46.82 144.76,46.91 144.44,46.91 144.35,47 144.35,47.42 144.44,47.5 144.76,47.5 144.85,47.59 144.85,48.01 144.76,48.1 144.44,48.1 144.35,48.19 144.35,48.62 143.24,49.72 143.24,51.5 142.86,51.88 142.86,52.89 134.4,61.35 134.4,65.09 134,65.49 134,72.43 133.08,73.34 133.08,73.87 132.82,74.13 132.68,74.13 132.48,73.94 132.36,73.94 132.19,74.11 132.19,74.23 132.37,74.41 132.37,74.58 132.16,74.79 132.03,74.79 131.96,74.73 131.75,74.73 131.54,74.94 131.54,75.14 131.61,75.22 131.61,75.34 131.31,75.64 131.19,75.64 130.94,75.39 130.81,75.39 130.51,75.68 130.51,75.81 130.76,76.06 130.76,76.19 130.47,76.48 130.34,76.48 130.09,76.23 129.97,76.23 129.67,76.53 129.67,76.65 129.92,76.9 129.92,77.03 128.39,78.56 127.18,78.56 126.97,78.35 126.78,78.35 126.72,78.41 126.72,78.47 126.63,78.56 126.06,78.56 v3(125.84,78.34)
  BOTTOM w0.076: v3(125.84,78.34) 125.68,78.34 124.82,79.19 124.82,80.16 124.63,80.56 124.63,80.91 124.36,81.18 UC1.AY25
  BOTTOM w0.108: JDIMM1.245 144.26,45.4 v1(144.84,44.82)
DDR_A_D59: length 54.7
  IN4 w0.089: v1(141.51,41.14) 141.18,41.14 141.06,41.26 141.06,46.47 140.69,46.84 140.69,47.93 139.83,48.79 139.83,52.48 131.86,60.44 131.86,62.99 130.47,64.39 130.47,64.51 130.59,64.63 130.59,64.79 130.49,64.89 130.34,64.89 130.21,64.76 130.09,64.76 128.69,66.16 128.69,74.15 127.82,75.02 127.29,75.02 127.06,74.79 125.68,74.79 v3(124.8,75.67)
  BOTTOM w0.076: v3(124.8,75.67) 125.18,76.05 125.18,77.51 124.82,77.87 124.82,77.94 123.72,79.03 123.66,79.03 123.39,79.3 123.39,79.78 123.46,79.86 123.46,80.22 123.43,80.31 123.43,80.51 123.46,80.59 123.46,80.86 123.43,80.96 arc(123.41,81.05) 123.42,81.13 123.47,81.29 arc(123.49,81.41) 123.48,81.53 arc(123.46,81.65) 123.47,81.76 arc(123.51,81.9) 123.59,82.01 arc(123.68,82.03) 123.76,82.03 arc(124.06,82.03) UC1.AW25
  BOTTOM w0.108: v1(141.51,41.14) 141.95,40.7 141.95,39.71 142.01,39.64 JDIMM1.236
DDR_A_D60: length 52.5
  IN4 w0.089: v3(124.8,76.8) 125.56,76.8 125.86,76.5 125.86,75.43 126.08,75.21 126.55,75.21 126.86,75.53 128.17,75.53 131.66,72.04 131.66,71.82 131.71,71.77 131.93,71.77 132.01,71.68 132.01,71.48 131.93,71.39 131.76,71.39 131.66,71.29 131.66,71.07 131.75,70.98 131.93,70.98 132.02,70.89 132.02,70.47 131.93,70.38 131.75,70.38 131.66,70.29 131.66,69.88 131.75,69.79 131.93,69.79 132.02,69.7 132.02,69.28 131.93,69.19 131.75,69.19 131.66,69.1 131.66,68.68 131.75,68.59 131.93,68.59 132.02,68.5 132.02,68.08 131.93,68 131.75,68 131.66,67.91 131.66,67.49 131.75,67.4 131.93,67.4 132.02,67.31 132.02,66.89 131.93,66.8 131.75,66.8 131.66,66.71 131.66,66.29 131.75,66.2 131.93,66.2 132.02,66.12 132.02,65.7 131.93,65.61 131.75,65.61 131.66,65.52 131.66,65.26 131.79,65.14 131.89,65.14 131.99,65.04 131.99,64.89 131.89,64.78 131.74,64.78 131.66,64.71 131.66,64.5 132.47,63.69 132.47,60.69 140.43,52.73 140.43,49.04 141.31,48.17 141.31,47.66 141.44,47.54 142.05,47.54 142.16,47.42 142.16,46.97 142.05,46.85 141.74,46.85 141.69,46.8 141.69,46.09 141.77,46.01 142.07,46.01 142.16,45.92 142.16,44.83 142.07,44.74 141.84,44.74 v1(141.76,44.82)
  BOTTOM w0.076: UC1.BB27 123.02,80.07 123.02,79.2 123.64,78.58 123.71,78.58 124.43,77.86 124.43,77.11 124.74,76.8 v3(124.8,76.8)
  BOTTOM w0.108: JDIMM1.237 142.26,45.32 v1(141.76,44.82)
DDR_A_D61: length 53.1
  IN4 w0.089: v3(124.8,76.24) 125.36,76.24 125.69,75.91 125.69,75.35 126,75.04 126.62,75.04 126.93,75.35 127.92,75.35 131.36,71.91 131.36,64.37 132.17,63.56 132.17,60.56 140.13,52.6 140.13,48.92 141.01,48.04 141.01,47.08 141.36,46.72 141.36,42.57 141.53,42.41 141.79,42.41 141.9,42.51 141.9,44.05 v1(141.76,44.18)
  BOTTOM w0.076: v3(124.8,76.24) 124.65,76.24 124.27,76.62 124.27,77.79 123.69,78.36 123.63,78.36 122.86,79.13 122.86,79.84 122.77,79.93 122.77,80.24 123.03,80.51 UC1.BA27
  BOTTOM w0.108: JDIMM1.233 141.26,44.68 v1(141.76,44.18)
DDR_A_D62: length 53.2
  IN4 w0.089: v1(144.04,41.14) 144.04,48.39 142.93,49.5 142.93,51.37 142.56,51.75 142.56,52.76 134.1,61.22 134.1,64.68 133.61,65.16 133.61,72.25 129.04,76.82 128.92,76.82 128.71,77.03 128.71,77.79 128.27,78.23 127.91,78.23 127.6,77.92 v3(126.21,77.92)
  BOTTOM w0.076: v3(126.21,77.92) 125.76,77.92 125.49,78.19 125.49,78.29 124.66,79.12 124.66,80.12 124.51,80.43 124.36,80.58 UC1.BA25
  BOTTOM w0.108: v1(144.04,41.14) 144.45,41.14 145.56,40.03 145.56,39.59 145.51,39.55 JDIMM1.250
DDR_A_D63: length 52.4
  IN4 w0.089: v3(126.23,77.26) 127.46,77.26 127.93,76.79 128.49,76.79 128.71,76.57 128.87,76.57 133.28,72.15 133.28,64.94 133.69,64.53 133.69,61.2 142.25,52.64 142.25,51.62 142.63,51.24 142.63,49.24 143.72,48.15 143.72,44.58 143.38,44.25 143.38,43.91 143.47,43.82 143.65,43.82 143.74,43.73 143.74,43.31 143.65,43.22 143.47,43.22 143.38,43.13 143.38,42.72 143.47,42.63 143.65,42.63 143.74,42.54 143.74,42.12 143.65,42.03 143.47,42.03 143.38,41.94 143.38,41.07 v1(144.02,40.44)
  BOTTOM w0.076: UC1.BB25 124.49,79.95 124.49,79.05 125.31,78.23 125.31,78.13 126.18,77.26 v3(126.23,77.26)
  BOTTOM w0.108: v1(144.02,40.44) 144.51,39.94 JDIMM1.246
DDR_A_DQS0: length 62.6
  IN4 w0.095: v1(93.15,86.73) 92.75,87.14 92.31,87.14 89,83.83 89,63.64 87.93,62.57 84.39,62.57 84.16,62.34 84.16,61.91 84.39,61.68 86.35,61.68 86.47,61.56 86.47,61.13 86.32,60.98 85.38,60.98 84.76,60.36 84.76,56.37 84.94,56.19 84.94,53.25 84.66,52.97 84.66,51.78 84.88,51.57 84.88,47.56 84.66,47.34 84.66,44.56 84.66,44.56 84.66,44.48 84.49,44.31 84.37,44.31 v1(84.2,44.48)
  BOTTOM w0.076: 94.31,86.09 94.75,86.09 94.82,86.16 95.18,86.16 95.7,86.68 96.66,86.68 96.7,86.64 97.32,86.64 97.41,86.67 97.67,86.67 97.76,86.64 98.54,86.64 UC1.AM69
  BOTTOM w0.108: JDIMM1.13 84.26,45.84 83.79,45.36 83.79,44.89 v1(84.2,44.48) ; v1(93.15,86.73) 93.15,86.35 93.41,86.09 94.31,86.09
DDR_A_DQS1: length 53
  IN4 w0.095: v3(95.36,82.68) 95.58,82.9 95.58,83.03 95.4,83.22 95,83.22 92.73,80.95 92.73,62.1 90.44,59.81 90.44,55.48 90.63,55.3 90.63,51.34 90.5,51.21 90.5,49.1 89.8,48.4 89.8,42.15 90.45,41.49 90.45,41.1 90.82,40.73 90.82,40.53 90.66,40.37 v1(90.04,40.37)
  BOTTOM w0.076: UC1.AT70 98.19,83.72 98.12,83.66 97.75,83.66 97.62,83.62 97.44,83.62 97.36,83.66 96.86,83.66 96.25,83.04 95.73,83.04 v3(95.36,82.68)
  BOTTOM w0.108: v1(90.04,40.37) 89.88,40.37 89.51,40.01 JDIMM1.34
DDR_A_DQS2: length 47.5
  IN4 w0.095: v3(101.27,77.63) 101.18,77.63 100.87,77.33 100.52,77.33 100.26,77.08 100.26,76.89 99.88,76.51 99.41,76.51 99.19,76.72 98.85,76.72 97.55,75.43 96.84,75.43 96.27,74.86 96.27,60.63 95.31,59.67 95.31,53.71 94.38,52.78 94.38,52.56 94.54,52.4 95.27,52.4 95.55,52.12 95.55,51.72 95.27,51.44 94.71,51.44 94.47,51.2 94.47,50.97 94.6,50.84 95.07,50.84 95.32,50.59 95.32,49.99 94.98,49.65 94.98,45.74 94.98,45.59 94.86,45.47 94.86,45.16 94.73,45.02 94.73,44.79 94.63,44.69 v1(94.46,44.69)
  BOTTOM w0.076: UC1.AY64 101.33,81.51 101.33,80.98 arc(101.33,80.86) 101.29,80.74 101.24,80.63 arc(101.19,80.44) 101.22,80.25 arc(101.24,80.12) 101.25,80 101.25,79.94 100.87,79.56 100.87,79.33 100.51,78.97 100.51,77.83 100.7,77.63 v3(101.27,77.63)
  BOTTOM w0.108: v1(94.46,44.69) 94.91,45.14 94.91,45.51 94.76,45.65 JDIMM1.55
DDR_A_DQS3: length 47.7
  IN4 w0.076: v3(104.57,78.67) 104.32,78.67 104.23,78.58 104.23,78.34 103.98,78.1 103.98,76.86 103.72,76.59 103.59,76.59 103.53,76.54
  IN4 w0.095: 103.53,76.54 101.97,74.98 101.78,74.98 101.23,74.43 101.23,73.38 99.63,71.78 99.63,49.24 99.12,48.73 99.12,47.71 99.53,47.29 99.53,41.2 99.77,40.95 99.96,40.95 100.09,40.82 100.09,40.58 100.16,40.5 v1(100.43,40.5)
  BOTTOM w0.076: v3(104.57,78.67) 104.57,78.9 104.38,79.09 104.38,79.17 arc(104.38,79.26) 104.36,79.35 104.35,79.42 104.36,79.44 arc(104.34,79.49) 104.33,79.53 104.23,79.9 arc(104.21,80.11) 104.26,80.32 arc(104.29,80.41) 104.26,80.5 arc(104.22,80.61) 104.21,80.74 104.21,80.81 arc(104.14,80.97) UC1.BA60
  BOTTOM w0.108: v1(100.43,40.5) 100.16,40.5 100.09,40.57 100.09,40.85 100.02,40.93 99.84,40.93 99.72,40.81 99.72,39.87 100.01,39.58 JDIMM1.76
DDR_A_DQS4: length 48
  IN4 w0.095: v1(126.78,44.06) 126.98,44.26 127.24,44.26 127.5,44.52 127.5,45.91 127.3,46.11 127.3,46.86 127.5,47.06 127.5,48.13 127.24,48.39 127.24,48.71 127.5,48.97 127.5,50.51 118.34,59.68 118.34,62.76 118.14,62.95 118.14,70.46 116.64,71.96 116.64,75.92 v3(116.83,76.11)
  BOTTOM w0.076: v3(116.83,76.11) 116.04,76.11 115.88,76.27 115.88,77.14 116.46,77.73 116.46,78.58 115.8,79.24 115.8,79.38 arc(115.83,79.57) 115.89,79.75 arc(115.94,79.87) 115.96,79.99 arc(115.97,80.13) 115.93,80.27 arc(115.91,80.41) 115.93,80.56 115.97,80.64 arc(116.02,80.83) 116.05,81.03 arc(116.12,81.38) UC1.AY38
  BOTTOM w0.108: JDIMM1.179 127.76,44.28 127.54,44.06 v1(126.78,44.06)
DDR_A_DQS5: length 51.5
  IN4 w0.095: v1(132.01,41.02) 131.91,40.92 131.73,40.92 131.54,41.11 131.54,42.08 131.68,42.22 132.26,42.22 132.51,42.48 132.51,43.09 132.17,43.43 131.74,43.43 131.54,43.62 131.54,51.45 128.38,54.61 128.38,55.73 124.07,60.05 124.07,62.54 121.66,64.95 121.66,71.92 120.33,73.25 120.33,75.86 120.19,76 v3(119.95,76)
  BOTTOM w0.076: v3(119.95,76) 120.08,76 120.15,75.93 120.15,75.77 120.25,75.67 120.33,75.67 120.4,75.75 120.4,76.95 119.83,77.52 119.83,77.99 118.94,78.89 118.94,80.06 arc(118.95,80.19) 118.98,80.32 arc(119,80.39) 118.99,80.46 arc(118.97,80.54) 118.93,80.61 118.88,80.69 arc(118.78,80.87) UC1.BA34
  BOTTOM w0.108: v1(132.01,41.02) 132.01,41.01 132.86,40.16 132.86,39.66 133.01,39.5 JDIMM1.200
DDR_A_DQS6: length 52.4
  IN4 w0.095: v3(122.62,76.18) 122.52,76.18 122.43,76.08 122.43,75.53 123.01,74.95 123.01,74.33 124.86,72.48 124.86,71.79 125.79,70.86 125.79,65.92 129.26,62.45 129.26,59.9 133.3,55.86 133.3,55.47 133.09,55.26 133.09,55.04 133.25,54.88 133.47,54.88 133.68,55.08 134.08,55.08 134.36,54.8 134.36,54.4 134.15,54.2 134.15,53.98 134.31,53.82 134.53,53.82 134.74,54.02 135.14,54.02 136.97,52.19 136.97,47.67 136.8,47.5 136.8,46.86 136.92,46.73 137.94,46.73 138.33,46.34 138.33,44.52 138.01,44.2 137.4,44.2 v1(137.26,44.06)
  BOTTOM w0.076: v3(122.62,76.18) 122.12,76.18 121.94,76.36 121.94,77.88 120.92,78.9 120.92,79.66 arc(120.93,79.79) 120.94,79.92 120.96,80.04 arc(120.96,80.1) 120.95,80.17 arc(120.94,80.2) 120.92,80.24 arc(120.88,80.41) 120.92,80.58 arc(120.95,80.65) 120.96,80.72 120.96,80.85 arc(121.03,81.3) UC1.AY30
  BOTTOM w0.108: v1(137.26,44.06) 138.01,44.06 138.26,44.31 JDIMM1.221
DDR_A_DQS7: length 53.9
  IN4 w0.095: v3(126.23,76.14) 126.43,76.14 126.5,76.21 126.5,76.42 126.6,76.52 127.16,76.52 127.25,76.42 128.03,76.42 132.55,71.9 132.55,64.62 133,64.16 133,60.91 141.11,52.81 141.11,51.16 141.32,50.95 141.56,50.95 141.69,50.82 141.69,50.43 141.53,50.28 141.32,50.28 141.11,50.06 141.11,49.36 142.69,47.78 142.69,41.23 v1(142.47,41.01)
  BOTTOM w0.076: v3(126.23,76.14) 125.99,76.14 125.92,76.21 125.92,76.44 125.82,76.54 125.59,76.54 125.35,76.77 125.35,77.56 124.98,77.93 124.98,78.01 124.15,78.84 124.15,79.44 arc(124.12,79.59) 124.04,79.72 arc(123.95,79.84) 123.92,79.99 123.92,80.15 arc(123.93,80.22) 123.96,80.29 123.99,80.46 123.81,80.89 arc(123.76,80.98) UC1.BA26
  BOTTOM w0.108: v1(142.47,41.01) 142.89,41.01 142.96,40.93 142.96,40.6 143.22,40.33 143.22,39.6 143.29,39.54 143.44,39.54 143.51,39.46 JDIMM1.242
DDR_A_DQS#0: length 62.6
  IN4 w0.095: v1(84.2,43.85) 84.48,44.13 84.56,44.13 84.84,44.4 84.84,44.63 84.84,47.26 85.06,47.48 85.06,51.64 84.85,51.85 84.85,52.9 85.12,53.17 85.12,56.27 84.95,56.44 84.95,60.29 85.46,60.8 86.4,60.8 86.65,61.05 86.65,61.63 86.42,61.86 84.47,61.86 84.34,61.99 84.34,62.26 84.47,62.39 88.01,62.39 89.19,63.57 89.19,83.75 92.27,86.84 92.43,86.84 v1(92.54,86.73)
  BOTTOM w0.076: 94.31,85.88 94.32,85.88 94.35,85.91 94.39,85.91 94.4,85.92 94.81,85.92 94.89,86 95.25,86 95.76,86.52 96.59,86.52 96.63,86.47 97.35,86.47 97.35,86.47 97.44,86.51 97.64,86.51 97.73,86.47 97.73,86.47 97.73,86.47 97.74,86.47 97.97,86.47 UC1.AM70
  BOTTOM w0.108: 94.31,85.88 93.24,85.88 92.9,86.22 92.9,86.37 92.79,86.48 92.64,86.48 92.54,86.58 v1(92.54,86.73) ; JDIMM1.11 83.76,45.63 83.58,45.45 83.58,44.81 83.79,44.6 83.79,43.97 83.92,43.85 v1(84.2,43.85)
DDR_A_DQS#1: length 53.1
  IN4 w0.095: v3(95.97,82.68) 95.77,82.89 95.77,83.11 95.48,83.4 94.92,83.4 92.55,81.02 92.55,62.17 90.26,59.89 90.26,55.41 90.45,55.22 90.45,51.42 90.31,51.28 90.31,49.18 89.61,48.48 89.61,42.07 90.27,41.41 90.27,41.23 v1(90.04,41.01)
  BOTTOM w0.076: v3(95.97,82.68) 96.13,82.68 96.93,83.49 97.32,83.49 97.4,83.46 97.65,83.46 97.78,83.49 98.45,83.49 UC1.AT69
  BOTTOM w0.108: JDIMM1.32 89.01,39.43 89.3,39.72 89.3,40.1 89.62,40.42 89.62,40.88 89.75,41.01 v1(90.04,41.01)
DDR_A_DQS#2: length 47.4
  IN4 w0.095: v3(101.27,78.22) 100.21,78.22 100.1,78.11 100.1,77.95 100.21,77.84 100.8,77.84 100.89,77.75 100.89,77.61 100.8,77.52 100.44,77.52 100.08,77.15 100.08,76.97 99.8,76.69 99.49,76.69 99.27,76.91 98.77,76.91 97.48,75.61 96.76,75.61 96.09,74.94 96.09,60.71 95.13,59.74 95.13,53.79 94.2,52.86 94.2,52.48 94.46,52.22 95.19,52.22 95.37,52.04 95.37,51.8 95.19,51.63 94.64,51.63 94.29,51.28 94.29,50.89 94.52,50.65 94.99,50.65 95.14,50.51 95.14,50.06 94.8,49.72 94.8,45.66 v1(94.46,45.33)
  BOTTOM w0.076: v3(101.27,78.22) 101.2,78.22 101,78.02 101,77.9 100.9,77.8 100.77,77.8 100.67,77.89 100.67,78.9 101.03,79.26 101.03,79.49 101.42,79.87 101.42,80 arc(101.41,80.15) 101.37,80.3 arc(101.36,80.43) 101.39,80.56 101.49,80.78 arc(101.56,80.92) UC1.BA64
  BOTTOM w0.108: JDIMM1.53 94.26,45.52 v1(94.46,45.33)
DDR_A_DQS#3: length 47.8
  IN4 w0.076: 103.6,76.35 103.68,76.43 103.79,76.43 104.15,76.79 104.15,78.03 104.23,78.11 v3(104.57,78.11)
  IN4 w0.095: 103.6,76.35 102.04,74.79 101.85,74.79 101.41,74.35 101.41,73.3 99.82,71.7 99.82,49.17 99.3,48.65 99.3,47.78 99.71,47.37 99.71,41.27 99.85,41.14 v1(100.43,41.14)
  BOTTOM w0.076: v3(104.57,78.11) 104.94,78.48 104.94,78.83 104.74,79.03 104.69,79.03 104.56,79.17 arc(104.56,79.19) 104.56,79.2 arc(104.55,79.3) 104.54,79.39 104.52,79.47 arc(104.51,79.53) 104.49,79.58 104.39,79.95 arc(104.37,80.1) 104.41,80.24 arc(104.45,80.41) 104.41,80.57 arc(104.38,80.65) 104.37,80.74 104.37,80.81 arc(104.3,81.28) UC1.AY60
  BOTTOM w0.108: v1(100.43,41.14) 99.76,41.14 99.51,40.89 JDIMM1.74
DDR_A_DQS#4: length 48
  IN4 w0.095: v3(116.84,76.68) 116.45,76.3 116.45,71.89 117.96,70.38 117.96,62.88 118.15,62.68 118.15,59.6 127.32,50.44 127.32,49.04 127.06,48.78 127.06,48.32 127.32,48.05 127.32,47.14 127.11,46.93 127.11,46.04 127.32,45.83 127.32,44.6 127.17,44.44 127.02,44.44 v1(126.78,44.69)
  BOTTOM w0.076: v3(116.84,76.68) 116.56,76.68 116.5,76.63 116.5,76.35 116.43,76.28 116.11,76.28 116.05,76.34 116.05,77.08 116.63,77.66 116.63,78.65 115.97,79.31 115.97,79.38 arc(115.99,79.53) 116.04,79.68 arc(116.1,79.82) 116.13,79.97 arc(116.13,80.15) 116.09,80.33 arc(116.07,80.42) 116.09,80.5 116.12,80.59 arc(116.23,80.83) UC1.BA38
  BOTTOM w0.108: v1(126.78,44.69) 127.04,44.69 127.11,44.62 127.11,44.35 127.2,44.27 127.46,44.27 127.55,44.36 127.55,45.4 127.43,45.53 127.34,45.53 127.26,45.61 JDIMM1.177
DDR_A_DQS#5: length 51.4
  IN4 w0.095: v1(132.01,40.39) 132.01,40.39 131.72,40.68 131.53,40.68 131.36,40.85 131.36,42.16 131.61,42.41 132.18,42.41 132.33,42.55 132.33,43.01 132.1,43.24 131.66,43.24 131.36,43.55 131.36,51.38 128.2,54.53 128.2,55.65 123.88,59.97 123.88,62.47 121.48,64.87 121.48,71.84 120.15,73.17 120.15,75.23 v3(119.95,75.43)
  BOTTOM w0.076: v3(119.95,75.43) 120.03,75.5 120.39,75.5 120.57,75.68 120.57,77.02 120,77.59 120,78.06 119.1,78.96 119.1,80.06 arc(119.11,80.16) 119.14,80.27 arc(119.16,80.38) 119.16,80.5 arc(119.12,80.6) 119.07,80.7 arc(119.03,80.79) 119.03,80.9 arc(119,81.32) UC1.AY34
  BOTTOM w0.108: JDIMM1.198 132.51,39.49 132.65,39.62 132.65,40.08 132.34,40.39 v1(132.01,40.39)
DDR_A_DQS#6: length 52.3
  IN4 w0.095: v1(137.26,44.69) 137.57,44.38 137.93,44.38 138.15,44.6 138.15,46.26 137.86,46.55 136.85,46.55 136.61,46.78 136.61,47.58 136.79,47.75 136.79,52.11 135.06,53.84 134.82,53.84 134.61,53.63 134.23,53.63 133.97,53.9 133.97,54.28 134.17,54.48 134.17,54.73 134,54.9 133.76,54.9 133.55,54.69 133.17,54.69 132.91,54.96 132.91,55.34 133.11,55.54 133.11,55.79 129.08,59.82 129.08,62.37 125.6,65.85 125.6,70.78 124.67,71.71 124.67,72.4 122.82,74.25 122.82,74.88 122.24,75.46 122.24,76.37 v3(122.62,76.75)
  BOTTOM w0.076: v3(122.62,76.75) 122.49,76.75 122.36,76.62 122.36,76.43 122.27,76.34 122.19,76.34 122.11,76.43 122.11,77.95 121.09,78.97 121.09,79.66 arc(121.09,79.78) 121.1,79.89 121.12,80.01 arc(121.12,80.11) 121.11,80.2 arc(121.09,80.26) 121.07,80.31 arc(121.05,80.41) 121.07,80.51 arc(121.11,80.61) 121.12,80.72 121.12,80.85 arc(121.19,81) UC1.BA30
  BOTTOM w0.108: JDIMM1.219 137.76,45.67 137.83,45.61 137.95,45.61 138.05,45.5 138.05,44.4 137.92,44.27 137.69,44.27 137.63,44.33 137.63,44.62 137.55,44.69 v1(137.26,44.69)
DDR_A_DQS#7: length 53.8
  IN4 w0.095: v3(126.23,76.7) 127.23,76.7 127.33,76.6 128.11,76.6 132.73,71.98 132.73,64.69 133.19,64.24 133.19,60.99 141.29,52.88 141.29,51.24 141.4,51.13 141.64,51.13 141.87,50.9 141.87,50.36 141.61,50.1 141.4,50.1 141.29,49.99 141.29,49.44 142.88,47.85 142.88,40.78 v1(142.47,40.37)
  BOTTOM w0.076: v3(126.23,76.7) 125.66,76.7 125.52,76.84 125.52,77.63 125.15,78 125.15,78.08 124.32,78.91 124.32,79.44 arc(124.27,79.65) 124.15,79.84 arc(124.11,79.91) 124.09,79.99 124.09,80.15 arc(124.09,80.18) 124.1,80.21 124.11,80.23 124.15,80.41 124.16,80.48 123.99,80.88 123.99,81.22 arc(123.94,81.49) UC1.AY26
  BOTTOM w0.108: JDIMM1.240 143.01,40.25 142.89,40.37 v1(142.47,40.37)
DDR_A_MA0: length 48.6
  IN4 w0.14: v1(116.52,40.63) 116.95,40.2 117.45,40.2 117.59,40.34 117.59,41.59 116.98,42.2 116.98,45.33 117.28,45.63 117.28,50.58 110.44,57.42 110.44,67.31 110.04,67.72 v1(110.02,67.72)
  BOTTOM w0.076: 109.61,74.84 109.61,77.2 109.4,77.41 109.4,79.15 109.51,79.26 109.51,79.47 arc(109.49,79.64) 109.42,79.79 109.38,79.86 arc(109.34,80) 109.34,80.15 arc(109.34,80.19) 109.36,80.22 109.39,80.34 109.39,80.42 arc(109.38,80.51) 109.36,80.6 arc(109.33,80.77) 109.39,80.93 arc(109.43,81.02) 109.43,81.12 arc(109.47,81.28) UC1.AY50
  BOTTOM w0.171: 109.61,74.84 v6(109.61,71.8) 109.61,69.76 110,69.37 110,67.76 110.02,67.74 v1(110.02,67.72) ; v1(116.52,40.63) 117.01,40.14 JDIMM1.144
DDR_A_MA1: length 49.9
  IN4 w0.14: v1(110.02,67.08) 109.17,66.24 109.17,56.91 114.11,51.97 114.11,49.99 114.25,49.85 115.88,49.85 116.02,49.71 116.02,49.45 115.88,49.31 114.25,49.31 114.11,49.17 114.11,47.94 114.23,47.82 115.25,47.82 115.35,47.71 115.35,47.47 115.28,47.39 114.22,47.39 114.11,47.29 114.11,47.09 114.25,46.95 115.75,46.95 115.92,46.79 115.92,46.59 115.75,46.42 114.72,46.42 114.62,46.32 114.62,46.09 114.77,45.94 115.02,45.94 115.17,45.78 115.17,45.14 v1(114.74,44.72)
  BOTTOM w0.076: 110.07,74.84 110.07,77.21 109.57,77.71 109.57,79.08 109.68,79.19 109.68,80.01 UC1.BB50
  BOTTOM w0.171: v1(110.02,67.08) 110.31,67.08 110.48,67.25 v6(110.48,69.5) 110.48,70.88 110.07,71.29 110.07,74.84 ; JDIMM1.133 114.26,45.04 114.59,44.72 v1(114.74,44.72)
DDR_A_MA2: length 50.8
  IN4 w0.14: v1(110.02,65.13) 110.02,57.25 116.86,50.41 116.86,45.8 116.55,45.49 116.55,41.36 116.1,40.91 116.1,40.17 115.97,40.04 115.79,40.04 115.67,40.16 115.67,40.87 115.53,41.01 v1(115.24,41.01)
  BOTTOM w0.076: 109.08,74.84 109.08,75.56 109.24,75.72 109.24,79.22 109.3,79.28 109.3,79.62 109.27,79.72 109.23,79.78 arc(109.17,79.98) 109.17,80.18 arc(109.18,80.23) 109.2,80.28 109.23,80.37 109.23,80.42 arc(109.22,80.48) 109.2,80.54 arc(109.16,80.79) 109.25,81.03 arc(109.27,81.06) 109.27,81.1 arc(109.17,81.43) UC1.AY51
  BOTTOM w0.171: JDIMM1.132 114.01,40.43 114.59,41.01 v1(115.24,41.01) ; v1(110.02,65.13) 109.98,65.16 109.36,65.16 109.08,65.44 v6(109.08,67.98) 109.08,74.84
DDR_A_MA3: length 49.7
  IN4 w0.14: v1(110.02,65.81) 109.78,65.81 109.59,65.63 109.59,57.08 114.55,52.12 114.55,50.47 114.72,50.31 114.95,50.31 115.07,50.43 115.07,51.05 115.21,51.19 115.49,51.19 115.71,50.97 115.71,50.51 115.86,50.36 116.32,50.36 116.44,50.24 116.44,48.9 116.25,48.71 115.3,48.71 115.16,48.57 115.16,48.37 115.3,48.23 115.44,48.23 115.59,48.09 115.59,48.07 115.84,47.82 116.29,47.82 116.44,47.67 116.44,45.97 116.3,45.84 115.73,45.84 115.59,45.7 115.59,44.95 v1(114.74,44.11)
  BOTTOM w0.076: 110.65,74.84 110.65,76.98 109.76,77.88 109.76,79.04 109.88,79.15 109.88,80.32 109.61,80.58 UC1.BA50
  BOTTOM w0.171: v1(114.74,44.11) 114.44,44.11 113.76,44.78 JDIMM1.131 ; 110.65,74.84 v6(110.65,73.24) 110.65,72.05 111.36,71.34 111.36,67.04 110.13,65.81 v1(110.02,65.81)
DDR_A_MA4: length 49.4
  IN4 w0.14: v1(105.32,72.91) 104.48,72.07 104.48,71.03 104.57,70.94 104.57,69.17 103.85,68.45 103.85,50.42 105.21,49.06 105.21,48.17 108.35,45.03 108.35,44.44 110.42,42.38 111.01,42.38 112.91,40.48 v1(113.51,40.48)
  BOTTOM w0.076: UC1.BB52 108.28,79.82 108.19,79.72 108.19,79.03 108.65,78.57 108.65,76.32 v6(108.21,75.88) 107.8,75.47 107.8,74.84
  BOTTOM w0.171: JDIMM1.128 113.01,39.98 v1(113.51,40.48) ; 107.8,74.84 107.8,74.38 106.34,72.91 v1(105.32,72.91)
DDR_A_MA5: length 50.5
  IN4 w0.14: v1(113.51,41.11) 113.34,40.93 113.06,40.93 110.98,43.01 110.98,43.02 109.2,44.8 109.2,45.37 107.07,47.5 107.07,47.69 107.1,47.72 107.1,47.92 106.9,48.12 106.7,48.12 106.68,48.09 106.48,48.09 106.05,48.52 106.05,49.41 104.69,50.77 104.69,68.11 105.4,68.82 105.4,71.61 v1(105.32,71.69)
  BOTTOM w0.076: 108.65,74.84 108.65,75.37 109.01,75.72 109.01,78.68 108.59,79.1 108.59,79.62 108.71,79.88 108.72,80.13 108.72,80.17 108.68,80.31 108.68,80.51 108.73,80.65 108.73,80.69 108.72,80.8 arc(108.79,80.97) UC1.BA51
  BOTTOM w0.171: 108.65,74.84 108.65,73.65 106.69,71.69 v6(106.18,71.69) v1(105.32,71.69) ; v1(113.51,41.11) 112.51,40.11 JDIMM1.126
DDR_A_MA6: length 50.7
  IN4 w0.14: v1(105.32,73.52) 105.32,73.51 104.81,73 104.81,72.72 104.25,72.16 104.25,71.36 103.43,70.54 103.43,50.25 104.79,48.89 104.79,48 107.94,44.86 107.94,44.27 110.28,41.92 v1(110.55,41.92)
  BOTTOM w0.076: 107.15,74.84 107.61,75.3 107.61,75.55 108.49,76.44 108.49,78.5 108.02,78.97 108.02,80.47 UC1.BA52
  BOTTOM w0.171: JDIMM1.127 112.76,43.55 112.33,43.12 111.75,43.12 v1(110.55,41.92) ; 107.15,74.84 107.02,74.71 107.02,74.66 v6(106.13,73.78) 105.88,73.52 v1(105.32,73.52)
DDR_A_MA7: length 51.4
  IN4 w0.14: v1(105.32,74.13) 104.4,73.21 104.4,72.64 104.02,72.26 104.02,71.84 103.01,70.83 103.01,50.07 104.37,48.71 104.37,47.82 106.34,45.86 106.34,45.25 106.72,44.86 106.94,44.86 107.52,44.29 107.52,43.71 111.03,40.2 111.75,40.2 v1(112.01,40.46)
  BOTTOM w0.076: 106.49,74.84 108.32,76.68 108.32,78.43 107.85,78.9 107.85,80.6 arc(107.88,80.76) 107.97,80.89 108.04,80.96 arc(108.07,81.01) 108.09,81.07 108.09,81.25 arc(108.08,81.28) 108.06,81.31 arc(108.05,81.33) 108.04,81.36 arc(108.07,81.51) 108.15,81.63 108.26,81.73 arc(108.35,81.87) UC1.AW52
  BOTTOM w0.171: JDIMM1.122 111.51,39.96 v1(112.01,40.46) ; 106.49,74.84 105.78,74.13 v1(105.32,74.13)
DDR_A_MA8: length 50.5
  IN4 w0.14: v1(105.33,72.3) 105.19,72.3 104.79,71.9 104.79,71.46 104.99,71.26 104.99,69 104.27,68.28 104.27,50.59 105.63,49.23 105.63,48.35 108.77,45.2 108.77,44.63 v1(110.55,42.85)
  BOTTOM w0.076: 108.23,74.84 108.23,75.54 108.84,76.16 108.84,78.61 108.35,79.1 108.35,79.51 108.55,79.92 108.55,80 108.56,80.14 108.47,80.42 108.56,80.68 108.55,81.01 arc(108.5,81.21) UC1.AY52
  BOTTOM w0.171: v1(105.33,72.3) 106.36,72.3 v6(107.96,73.9) 108.23,74.17 108.23,74.84 ; JDIMM1.125 112.26,44.22 112.43,44.06 112.43,43.7 112.2,43.47 111.97,43.47 111.8,43.65 111.67,43.65 111.47,43.45 111.47,43.37 111.34,43.25 111.1,43.25 110.96,43.39 110.96,43.55 110.86,43.65 110.68,43.65 110.55,43.52 v1(110.55,42.85)
DDR_A_MA9: length 49.8
  IN4 w0.14: v3(107.97,77.07) 107.97,76.22 107.08,75.33 107.08,68.13 106.37,67.41 106.37,52.96 106.52,52.81 108.53,52.81 108.67,52.67 108.67,51.61 108.81,51.47 109.12,51.47 109.26,51.61 109.26,52.36 109.4,52.51 109.6,52.51 110.01,52.1 110.01,49.79 109.84,49.62 109.15,49.62 108.86,49.91 108.67,49.91 108.52,49.77 108.52,49.54 109.48,48.58 109.87,48.58 110.01,48.44 110.01,48.11 109.87,47.97 109.55,47.97 109.45,47.87 109.45,47.63 109.59,47.49 110.2,47.49 110.34,47.35 110.34,46.69 111.34,45.69 111.34,44.86 111.48,44.72 v1(111.76,44.72)
  BOTTOM w0.076: UC1.BB54 107.36,79.98 107.36,77.99 107.48,77.86 v6(107.48,77.48) 107.48,77.05 107.36,76.93 107.36,76.36 107.43,76.29 107.58,76.29 107.97,76.68 v3(107.97,77.07)
  BOTTOM w0.171: JDIMM1.121 111.26,45.17 111.71,44.72 v1(111.76,44.72)
DDR_A_MA10: length 51.4
  IN4 w0.076: 111.16,74.79 111.16,75 111.07,75.09 111.07,79.94 109.65,81.37 109.65,83.87 109.36,84.16 v3(109.1,84.16)
  IN4 w0.14: 111.16,74.79 111.16,69.66 112.12,68.7 112.12,58.11 118.95,51.28 118.95,42.62 v7(120,41.57)
  BOTTOM w0.076: UC1.AT50 109.27,84.16 v3(109.1,84.16)
  BOTTOM w0.171: v7(120,41.57) 119.87,41.57 119.35,41.04 119.35,39.65 119.51,39.49 JDIMM1.146
DDR_A_MA11: length 50.4
  IN4 w0.14: v3(107.97,77.63) 107.58,77.63 107.48,77.53 107.48,76.16 106.66,75.35 106.66,68.3 105.95,67.59 105.95,52.69 106.4,52.24 107.91,52.24 108.25,51.89 108.25,50.09 107.92,49.76 107.92,49.56 109.03,48.45 109.03,47.41 110.92,45.52 110.92,44.28 111.51,43.69 112.04,43.69 112.18,43.55 112.18,43.02 112.53,42.66 112.53,42.05 113.04,41.54 113.37,41.54 113.51,41.68 v1(113.51,41.75)
  BOTTOM w0.076: v3(107.97,77.63) 107.52,78.08 107.52,80.25 107.25,80.52 UC1.BA54
  BOTTOM w0.171: v1(113.51,41.75) 112.63,41.75 111.01,40.12 JDIMM1.120
DDR_A_MA12: length 50.8
  IN4 w0.076: v3(107.97,78.24) 108.32,77.89 108.32,76.27 107.5,75.45 107.5,74.79
  IN4 w0.14: 107.5,74.79 107.5,67.95 106.79,67.24 106.79,53.36 106.92,53.23 107.12,53.23 107.29,53.39 107.29,54.96 107.4,55.08 107.62,55.08 107.83,54.87 107.83,53.37 107.97,53.23 108.24,53.23 108.32,53.3 108.32,53.89 108.46,54.03 108.68,54.03 108.97,53.73 108.97,53.23 109.1,53.1 109.61,53.1 110.43,52.27 110.43,48.16 110.76,47.83 110.76,47 112.19,45.57 112.19,44.17 112.13,44.12 v1(111.76,44.12)
  BOTTOM w0.076: v3(107.97,78.24) 107.69,78.52 107.69,80.74 107.51,80.91 arc(107.46,80.99) 107.44,81.08 107.44,81.24 107.51,81.4 107.51,81.46 arc(107.5,81.5) 107.48,81.53 107.28,81.73 arc(107.19,81.87) UC1.AW54
  BOTTOM w0.171: JDIMM1.119 110.76,45.1 111.75,44.12 v1(111.76,44.12)
DDR_A_MA13: length 54.1
  IN4 w0.076: v7(110.94,82.87) 110.94,80.95 112.2,79.69 112.2,75.11 112.42,74.89 112.42,74.79
  IN4 w0.14: v1(123.01,40.63) 123.29,40.35 123.48,40.35 123.58,40.45 123.58,41.28 122.89,41.97 122.89,42.21 122.79,42.3 122.62,42.3 122.46,42.15 122.46,41.82 122.39,41.75 122.26,41.75 121.9,42.11 120.71,42.11 120.03,42.8 120.03,43.07 120.25,43.3 120.25,43.85 120.64,44.24 120.64,45.68 120.21,46.11 120.21,51.8 114.09,57.92 114.09,58.45 113.9,58.64 113.52,58.64 113.38,58.78 113.38,69.22 112.42,70.18 112.42,74.79
  BOTTOM w0.076: UC1.AU46 111.08,82.87 v7(110.94,82.87)
  BOTTOM w0.171: v1(123.01,40.63) 123,40.63 122.51,40.14 JDIMM1.158
DDR_A_MA14: length 51.1
  IN4 w0.076: v3(110.94,83.53) 111.36,83.1 111.36,82.72 111.14,82.49 111.14,80.98 112.36,79.76 112.36,75.34 112.84,74.86 112.84,74.79
  IN4 w0.14: v1(121.49,44.56) 121.2,44.56 121.06,44.7 121.06,45.63 121.14,45.71 121.36,45.71 121.49,45.85 121.49,46.06 121.39,46.17 120.79,46.17 120.64,46.32 120.64,46.55 120.79,46.7 121.38,46.7 121.49,46.81 121.49,47.05 121.33,47.21 120.79,47.21 120.67,47.33 120.67,47.53 120.79,47.65 121.35,47.65 121.49,47.79 121.49,47.99 121.35,48.12 120.84,48.12 120.66,48.3 120.66,51.94 114.51,58.09 114.51,58.63 114.07,59.07 113.9,59.07 113.8,59.18 113.8,60.23 113.93,60.36 114.18,60.36 114.41,60.59 114.41,60.97 114.08,61.3 113.88,61.3 113.8,61.39 113.8,69.39 112.84,70.35 112.84,74.79
  BOTTOM w0.076: UC1.AT46 111.09,83.53 v3(110.94,83.53)
  BOTTOM w0.171: v1(121.49,44.56) 120.76,45.28 JDIMM1.151
DDR_A_MA15: length 52.2
  IN4 w0.076: 111.58,74.79 111.58,74.88 111.87,75.17 111.87,79.55 110.61,80.81 110.61,82.3 v3(110.04,82.87)
  IN4 w0.14: v1(123.01,41.25) 122.13,41.25 121.69,41.69 120.54,41.69 119.37,42.86 119.37,51.45 112.54,58.29 112.54,68.87 111.58,69.83 111.58,74.79
  BOTTOM w0.076: v3(110.04,82.87) 110.16,82.87 UC1.AU48
  BOTTOM w0.171: JDIMM1.156 122.01,40.25 123.01,41.25 v1(123.01,41.25)
DDR_A_MA16: length 51.6
  IN4 w0.076: v3(109.12,83.53) 109.48,83.17 109.48,81.3 110.74,80.04 110.74,74.79
  IN4 w0.14: v1(121.51,40.59) 121.02,41.09 119.88,41.09 118.53,42.43 118.53,51.11 111.7,57.94 111.7,68.52 110.74,69.48 110.74,74.79
  BOTTOM w0.076: UC1.AU50 109.25,83.53 v3(109.12,83.53)
  BOTTOM w0.171: JDIMM1.152 121.01,40.09 v1(121.51,40.59)
DDR_A_ODT0: length 55.6
  IN4 w0.076: 113.81,82.93 113.21,83.53 113.21,83.74 112.99,83.96 112.32,83.96 v3(111.88,83.53)
  IN4 w0.14: 113.81,82.93 114.28,82.46 115.53,82.46 115.78,82.21 115.78,79.24 115.66,79.11 114.74,79.11 114.59,78.96 114.59,75.6 114.51,75.53 114.51,71.05 115.47,70.09 115.47,62.58 116.19,61.87 116.19,58.79 122.39,52.58 122.39,49.57 123.92,48.05 123.92,42.77 123.76,42.61 123.53,42.61 123.36,42.78 123.36,43.16 123.15,43.37 v1(122.77,43.37)
  BOTTOM w0.076: UC1.AT45 112,83.53 v3(111.88,83.53)
  BOTTOM w0.171: JDIMM1.155 121.76,45.6 121.93,45.43 121.93,43.93 122.48,43.37 v1(122.77,43.37)
DDR_A_ODT1: length 57
  IN4 w0.14: v1(122.77,44.01) 123.37,44.01 123.5,44.13 123.5,47.87 121.98,49.4 121.98,52.41 115.77,58.61 115.77,61.69 115.05,62.41 115.05,69.92 114.09,70.87 114.09,75.67 114.26,75.83 114.26,79.26 114.46,79.46 115.33,79.46 115.43,79.56 115.43,79.84 115.33,79.94 113.36,79.94 113.19,80.1 113.19,80.34 113.36,80.5 115.22,80.5 115.36,80.64 115.36,81.33 115.23,81.46 114.9,81.46 114.79,81.36 114.79,81.19 114.67,81.06 113.48,81.06 113.32,81.22 113.32,81.5 113.5,81.67 114.06,81.67 114.16,81.78 114.16,82.15 112.78,83.53 v7(112.79,83.55)
  BOTTOM w0.076: v7(112.79,83.55) 112.94,83.55 UC1.AT43
  BOTTOM w0.171: JDIMM1.161 123.26,45.64 123.42,45.48 123.42,44.06 123.25,43.89 122.89,43.89 v1(122.77,44.01)
