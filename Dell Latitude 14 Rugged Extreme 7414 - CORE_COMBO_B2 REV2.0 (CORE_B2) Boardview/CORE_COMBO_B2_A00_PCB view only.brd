# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPS_PWR_EN: length 176.5
  TOP w0.108: v1(251.39,63.08) 251.39,62.47 252.97,60.9 R9415.2 252.97,59.37 253.3,59.04 254.2,59.04 254.74,58.51 255.48,58.51 255.63,58.36 U37.B52
  IN2 w0.089: v1(155.95,130.86) 156.67,130.86 159.4,128.13 159.4,125.17 160.51,124.05 160.51,122.92 162.84,120.59 165.2,120.59 166.78,119.01 170.47,119.01 171,118.49 173.42,118.49 174.1,119.16 180.74,119.16 182.6,117.29 184.06,117.29 187.55,113.8 187.55,108.33 189.66,106.22 189.66,105.25 190.61,104.31 190.61,95.62 190.16,95.17 190.16,91.77 190.43,91.5 190.43,88.83 189.96,88.37 189.96,86.33 188.63,85 188.63,78.09 185.39,74.84 185.39,70.37 191.17,64.58 191.53,64.58 194.75,61.36 194.75,61.08 196.54,59.3 202.45,59.3 204.32,61.17 206.68,61.17 208.49,62.98 214.57,62.98 215.08,63.48 216.73,63.48 217.05,63.8 219.16,63.8 220.15,64.8 220.15,65.76 221.33,66.94 242.76,66.94 245.83,63.87 251.14,63.87 251.39,63.62 v1(251.39,63.08)
  BOTTOM w0.108: v1(155.95,130.86) 155.95,130.55 155.31,129.91 Q3605.2 v2(153.33,129.91)
GPU_SMBCLK: length 332.1
  TOP w0.108: v1(183.32,54.34) 182.5,54.34 182.2,54.04 181.94,54.04 180.97,53.07 QC2808.3 ; R454.1 v1(229.17,66.16) ; v1(189.42,132.45) 189.42,132.96 189.16,133.21 188.48,133.21 187.99,133.7 QC2807.6 ; U38.B49 231,60.55 231.24,60.31 231.37,60.31 v1(231.57,60.11)
  IN3 w0.089: v1(158.98,120.98) 158.98,119.91 160.61,118.28 165.31,118.28 166.09,117.51 173.59,117.51 174.31,118.23 180.73,118.23 181.42,117.54 185.49,117.54 188.23,120.27 188.23,120.52 188.23,121.32 188.22,129.75 189.71,131.24 189.71,131.36 189.82,131.47 189.82,132.05 v1(189.42,132.45) ; v1(169.2,34.18) 169.84,34.82 192.44,34.82 193.47,33.78 223.13,33.78 228.86,39.51 229.73,39.51 v1(230.16,39.09)
  IN4 w0.089: v1(231.57,60.11) 231.81,60.35 231.81,61.44 231.39,61.86 231.39,63.02 228.9,65.51 228.9,65.89 v1(229.17,66.16) ; v1(128.2,140.04) 129.32,138.93 129.66,138.93 133.08,135.51 135.47,135.51 137.93,133.05 142.1,133.05 142.27,132.87 143.77,132.87 144.47,132.18 147.91,132.18 149.5,130.59 150.4,130.59 154.81,126.18 155.29,126.18 157.77,123.69 157.77,122.02 158.82,120.98 v1(158.98,120.98) 159.29,120.98 160.73,119.53 161.45,119.53 162.05,118.93 162.55,118.93 176.06,105.42 176.06,105.18 176.06,105.18 176.06,98.5 177.1,97.45 177.1,93.51 178.37,92.24 178.63,92.24 v1(179.14,91.73) 177.53,90.13 177.53,86.12 178.45,85.21 178.88,85.21 179.69,84.39 179.69,76.69 176.46,73.47 176.46,64.58 181.07,59.98 181.07,58.39 182.69,56.77 182.69,55.98 182.9,55.77 182.9,54.77 v1(183.32,54.34) 183.83,54.34 184.16,54.01 184.16,53.75 185.29,52.62 185.29,51.88 185.77,51.4 186.99,51.4 187.56,51.98 189.7,51.98 190.86,53.15 198.11,53.15 202.27,48.99 213.38,48.99 214.19,48.18 217.38,48.18 217.73,47.83 226.67,47.83 228.03,46.47 v1(228.03,45.45)
  BOTTOM w0.108: JGFX1.14 128.7,139.54 v1(128.2,140.04) ; v1(169.2,34.18) 169.33,34.05 169.33,31.46 168.28,30.41 JHS1.6 ; v1(231.57,60.11) 231.57,59.34 230.99,58.76 230.36,58.76 229.62,58.03 229.62,56.47 228.5,55.34 228.5,53.75 226.5,51.75 226.5,50.64 228.13,49 v2(228.13,46.09) 228.13,45.56 v1(228.03,45.45) 228.51,44.97 228.51,42.25 230.16,40.6 v1(230.16,39.09) ; v1(179.14,91.73) 178.71,91.3 178.29,91.3 178.22,91.23 JIOR1.33
GPU_SMBDAT: length 326.9
  TOP w0.108: v1(183.32,53.46) 183.32,51.68 182.5,50.85 182.27,50.63 QC2808.6 ; v1(189.42,131.81) 190.18,131.81 190.7,132.33 190.73,132.33 191.5,133.11 191.5,134.8 191.14,135.17 190.76,135.17 190.6,135 QC2807.3 ; v1(231.41,60.72) 231.5,60.81 U38.B48 ; v1(228.18,66.16) 228.15,66.18 R455.1
  IN3 w0.089: v1(229.55,39.05) 229.38,39.22 228.98,39.22 223.25,33.49 193.35,33.49 192.32,34.53 170.18,34.53 v1(169.84,34.18) ; v1(160.3,119.28) 161,118.57 165.43,118.57 166.21,117.8 173.47,117.8 174.18,118.52 180.85,118.52 181.54,117.83 185.37,117.83 187.93,120.4 187.93,121.2 187.93,129.87 189.42,131.36 v1(189.42,131.81)
  IN4 w0.089: v1(227.52,45.84) 227.73,46.05 227.73,46.3 226.5,47.54 217.61,47.54 217.26,47.89 214.07,47.89 213.26,48.7 202.15,48.7 197.99,52.86 190.99,52.86 189.82,51.69 187.69,51.69 187.11,51.11 185.65,51.11 185,51.76 185,52.49 184.04,53.46 v1(183.32,53.46) 182.61,54.17 182.61,55.65 182.31,55.95 182.31,56.65 180.78,58.18 180.78,59.86 176.16,64.47 176.16,73.57 179.4,76.81 179.4,84.27 178.76,84.91 178.33,84.91 177.24,86 177.24,90.44 v1(178.53,91.73) 178.31,91.95 178.17,91.95 176.81,93.31 176.81,97.33 175.77,98.37 175.77,105.3 162.43,118.64 161.93,118.64 161.33,119.24 160.34,119.24 v1(160.3,119.28) 160.3,119.53 159.25,120.58 159.14,120.58 159.14,120.58 158.81,120.58 158.8,120.59 158.79,120.59 157.39,121.99 157.39,123.66 155.18,125.87 154.71,125.87 150.28,130.3 149.38,130.3 147.79,131.88 144.35,131.88 143.65,132.58 142.15,132.58 141.98,132.75 137.81,132.75 135.34,135.22 132.96,135.22 129.54,138.63 129.2,138.63 128.4,139.43 v1(128.2,139.43) ; v1(231.41,60.72) 231.41,61.38 231.09,61.69 231.09,62.9 228.61,65.39 228.61,65.72 v1(228.18,66.16)
  BOTTOM w0.108: v1(231.41,60.72) 231.15,60.47 231.15,59.37 230.86,59.08 230.65,59.08 230.65,59.07 230.23,59.07 229.31,58.16 229.31,56.6 228.19,55.47 228.19,53.88 226.17,51.86 226.17,50.51 227.82,48.86 227.82,48.53 227.52,48.22 v2(227.52,47.85) v1(227.52,45.84) 227.52,45.38 228.2,44.7 228.2,42.12 229.85,40.47 229.85,39.35 229.75,39.25 229.75,39.25 v1(229.55,39.05) ; JHS1.7 169.28,30.97 169.28,30.97 169.64,31.33 169.64,32.66 v2(169.81,32.83) 169.68,32.96 169.68,34.02 v1(169.84,34.18) ; JIOR1.32 v1(178.53,91.73) ; v1(128.2,139.43) JGFX1.16
GPUHOT#: length 3.2
  BOTTOM w0.108: T7163.1 115.91,144.11 116.7,143.32 JGFX1.61
GREEN_CRT: length 24.5
  TOP w0.089: 83.63,129.68 U6.M7
  TOP w0.108: v1(73.52,132.51) 74.06,131.97 78.26,131.97 80.49,129.73 82.1,129.73 C9916.1 82.92,129.68 83.63,129.68
  BOTTOM w0.108: v1(73.52,132.51) 73.06,132.97 73.06,136.74 74.99,138.67 v2(74.99,139.61) R2746.2 C11.1 L2.1
GREEN_CRT_L: length 12.2
  BOTTOM w0.108: L2.2 C14.1 v2(77.62,144.7) 79.89,144.7 D66.4 80.6,144.71 80.83,144.94 80.83,149.47 JCRT1.2
GT_SW: length 2.7
  TOP w0.254: 65.92,91.71 65.92,89.95 66.36,89.52 v2(66.36,89.17)
GT_VIN:
  vias: v2(67.75,86.73) v4(58.56,100.38) v4(58.56,99.49) v4(59.45,100.38) v4(59.45,99.49)
H_CATERR#: length 15.4
  TOP w0.089: v3(101.66,99.68) 100.98,100.37
  TOP w0.108: 100.98,100.37 100.58,100.37 100.39,100.56 99.35,100.56 98.64,99.85 93.95,99.85 93.78,99.68 93.25,99.68 93.09,99.85 90.9,99.85 v5(90.89,99.86) 90.69,100.06 90.69,100.34 v1(90.51,100.52)
  BOTTOM w0.076: v3(101.66,99.68) 101.66,100.06 102.11,100.51 UC1.D63
  BOTTOM w0.108: v1(90.51,100.52) 90.13,100.14 89.19,100.14 RC113.2
H_CPU_SVIDALRT#: length 13
  BOTTOM w0.076: UC1.B63 102.11,102.27 102.34,102.5 102.34,102.5 102.37,102.6 102.37,102.87 102.26,102.98 102.26,103.03 100.14,105.14 98.99,105.14 v2(98.13,106.01)
  BOTTOM w0.108: RC248.2 97.48,111.55 97.48,111.04 97.45,111.02 97.45,110.15 97.31,110 97.31,106.83 v2(98.13,106.01)
H_CPUPWRGD: length 9.8
  BOTTOM w0.076: UC1.A68 98.31,103.38 96.72,103.38 96.45,103.11
  BOTTOM w0.108: 96.45,103.11 93.85,103.11 93.84,103.11 93.46,103.11 CC271.2 93,102.65 91.78,102.65 91.5,102.93 91.2,102.93 RC406.2 90.99,103.91 v2(91.17,104.08)
H_CPUPWRGD_R: length 1.2
  BOTTOM w0.108: T7138.1 89.52,103.75 RC406.1
H_PROCHOT#: length 314.5
  TOP w0.108: v1(88.18,105.12) 88.18,105.81 87.71,106.29 87.28,106.29 86.34,107.23 86.34,112.72 81.2,117.86 79.36,117.86 78.65,118.57 78.65,120.68 v1(78.55,120.78) 78.55,120.93 77.62,121.86 76.81,121.86 75.37,123.31 75.37,124.85 73.45,126.78 72.36,126.78 v5(72.17,126.96) 69.28,126.96 69.05,127.19 68.21,127.19 67.83,126.81 PR5803.2 PC5843.2 PR5806.1 ; PR5236.2 246.29,32.25 v1(246.37,32.17) ; v1(229.8,66.16) 229.88,66.08 RC486.2
  IN4 w0.089: v1(219.01,66.41) 220.2,65.22 223.13,65.22 224.46,66.56 229.4,66.56 v1(229.8,66.16) ; v1(246.37,32.17) 245.37,33.17 245.37,37.66 244.54,38.49 244.54,39.38 243.58,40.34 233.11,40.34 232.06,41.39 229.75,41.39 227.79,43.35 217.43,43.35 214.47,46.31 213.07,46.31 v1(212.79,46.6) 212.36,47.02 197.39,47.02 195.73,45.37 190.3,45.37 189.95,45.71 184.92,45.71 176.95,53.69 176.95,58.45 176.12,59.27 172.96,59.27 172.12,60.11 172.12,69.36 167.49,73.98 167.49,80.76 167.66,80.93 167.66,84.03 167.95,84.31 167.95,93.32 161.3,99.97 161.3,101.94 159.84,103.4 159.35,103.4 156.58,106.18 156.58,110.36 155.04,111.9 153.96,111.9 148.73,117.13 146,117.13 145.65,117.48 142.07,117.48 141.65,117.89 137.78,117.89 136.55,119.13 131.66,119.13 130.91,119.89 127.04,119.89 124.71,117.56 106.74,117.56 105.93,118.38 102.98,118.38 102.85,118.5 96.4,118.5 95.84,119.07 85.01,119.07 83.9,120.18 79.15,120.18 v1(78.55,120.78)
  BOTTOM w0.108: RC117.1 89.58,105.32 89.58,105.39 RC405.2 89.02,105.96 v1(88.18,105.12) ; v1(212.79,46.6) 212.79,52.87 214.19,54.27 214.19,55.62 216.28,57.71 216.28,61.48 217.36,62.56 217.36,62.84 219.02,64.49 219.02,66.4 v1(219.01,66.41)
H_PROCHOT#_R: length 18.8
  BOTTOM w0.076: 95.02,106.16 95.02,105.36 96.16,104.22 100.07,104.22 100.81,103.47 100.81,102.96 100.71,102.87 100.71,102.61 100.74,102.55 100.74,102.23 100.71,102.15 100.71,101.96 100.78,101.77 100.87,101.68 arc(100.95,101.55) UC1.C65
  BOTTOM w0.108: 95.02,106.16 95.02,107.2 95.13,107.32 v2(95.13,108.8) 94.52,108.18 92.21,108.18 90.15,106.13 RC117.2
H_THERMTRIP#: length 315
  TOP w0.108: Q12.2 246.99,63.52 246.85,63.67 246.31,63.67 246.09,63.44 246.09,62.12 246.55,61.66 v1(246.55,59.42) ; RD61.2 115.12,37.5 v1(114.49,36.87) ; RD4.2 114.53,29.45 v1(114.05,29.93)
  IN3 w0.089: v1(114.05,29.93) 115.18,29.93 119.09,26.02 148.58,26.02 150.35,27.79 150.35,28.26 152.18,30.09 167.78,30.09 168.37,29.5 187.16,29.5 188.83,27.83 195.9,27.83 197.14,26.58 225.74,26.58 226.34,25.98 233.94,25.98 234.6,25.32 236.38,25.32 236.82,24.88 247.47,24.88 v1(248.09,24.25) ; v1(86.4,100.47) 86.83,100.04 87.95,100.04 88.48,100.57 v1(89.72,100.57)
  IN4 w0.089: v1(86.4,100.47) 83.37,100.47 80.88,97.98 78.57,97.98 77.76,97.17 77.76,90.72 86.96,81.52 86.96,78.45 84.8,76.29 81.11,76.29 80.05,75.22 80.05,65.77 80.4,65.42 80.4,53.02 80.2,52.82 80.2,49.37 81.47,48.1 81.47,42.14 83.58,40.03 83.58,39.74 85.16,38.16 99.1,38.16 101.22,36.04 105.95,36.04 106.78,36.86 112.37,36.86 113.37,35.87 113.37,30.62 v1(114.05,29.93) 114.1,29.93 114.92,30.75 114.92,36.44 v1(114.49,36.87)
  BOTTOM w0.108: RC80.2 RC172.2 90.07,100.86 90.01,100.86 v1(89.72,100.57) ; v1(248.09,24.25) 248.09,27.75 v2(248.65,28.31) 249.11,28.77 249.11,34.02 248.66,34.47 248.66,42.12 248.07,42.71 248.07,46.62 248.27,46.83 248.27,48.83 248.28,48.84 248.28,49.18 248.27,49.19 248.27,49.98 248.28,49.98 248.28,50.32 248.27,50.33 248.27,50.61 248.62,50.96 248.62,53.07 248.25,53.44 248.25,55.84 247.46,56.63 247.46,58.23 246.55,59.14 v1(246.55,59.42)
H_THERMTRIP#_R: length 12.9
  TOP w0.076: 93.66,100.18 93.81,100.03 98.56,100.03 99.27,100.74 101.25,100.74 v3(101.45,100.55)
  TOP w0.108: 93.66,100.18 93.35,100.5 v5(92.97,100.5) 92.61,100.86 91.79,100.86 v1(91.37,100.45)
  BOTTOM w0.076: UC1.C63 102.11,101.2 101.45,100.55 v3(101.45,100.55)
  BOTTOM w0.108: v1(91.37,100.45) 91.31,100.51 RC172.1
H_VCCST_PWRGD_XDP: length 9.8
  BOTTOM w0.108: JXDP1.39 78.3,123.93 77.46,124.78 76.65,124.78 75.91,125.51 75.91,127.03 CC272.1 RC373.2 ; RC373.2 RC372.2 ; RC373.2 75.08,129.17 74.51,129.17 v2(74.33,129.35)
HDD_DET#: length 202.4
  TOP w0.254: v1(209.69,44.31) v2(209.69,43.63)
  IN2 w0.089: v1(210.05,58.23) 208.79,58.23 206.45,55.89 195.35,55.89 194.52,56.73 191.13,56.73 189.7,58.16 188.82,58.16 185.61,61.37 184.45,61.37 179.77,66.06 179.77,83.3 179.66,83.4 179.66,83.4 179.1,83.96 178.52,83.96 177.36,85.12 177.36,92.29 177.36,92.29 177.36,92.44 172.97,96.83 172.97,96.83 172.87,96.93 172.87,96.93 172.76,97.04 169.09,97.04 168.95,97.04 168.8,97.04 167.74,95.97 163.42,95.97 161.77,97.63 161.62,97.63 158.25,97.63 158.21,97.58 156.99,96.36 155.88,96.36 154.77,97.47 151.72,97.47 150.22,98.98 143.4,98.98 v3(139.14,103.24) ; v1(209.69,44.31) 209.61,44.23 203.59,44.23 201.68,46.15 201.68,46.62 201.42,46.87 197.57,46.87 194.35,43.65 183.42,43.65 178.4,48.67 175.26,48.67 174.94,48.35 173.25,48.35 170.45,51.15 169.69,51.15 165.75,55.1 161.76,55.1 v1(160.49,56.38)
  BOTTOM w0.076: v3(139.14,103.24) 139.48,102.9 139.48,100.47 138.32,99.31 138.32,99 138.08,98.77 137.74,98.77 137.62,98.8 137.41,98.8 137.31,98.77 137.07,98.77 136.87,98.57 UC1.H2
  BOTTOM w0.108: v1(209.69,44.31) 210.87,45.49 210.87,53.13 211.55,53.81 211.55,56.8 211.31,57.04 211.31,58.71 211.11,58.92 210.73,58.92 v1(210.05,58.23) ; JSTRG1.11 158.36,59.85 160.21,58 160.21,56.66 v1(160.49,56.38) ; v3(139.14,103.24) 138.31,104.06 138.31,107 138.82,107.51 RC466.1
HDD_DEVSLP: length 95
  TOP w0.108: v1(165.92,104.1) 167.06,102.96 167.06,101.55 169.55,99.07 169.55,96.59 168.03,95.07 168.03,88.08 163.16,83.2 163.16,78.05 161.77,76.66 v1(161.29,76.66)
  IN1 w0.076: v3(139.3,99.07) 141.16,99.07
  IN1 w0.089: v1(161.29,76.66) 159.7,75.07 159.7,75.07 157.69,73.07 157.69,69.75 154,66.05 v1(151.78,66.05) ; v1(152.33,102.86) 151.5,102.86 147.46,98.82 142.07,98.82 141.82,99.07 141.16,99.07
  IN2 w0.089: v1(165.92,104.1) 164.18,104.1 164.11,104.02 163.06,104.02 162.46,103.42 152.9,103.42 v1(152.33,102.86)
  BOTTOM w0.076: v3(139.3,99.07) 139.06,98.83 138.88,98.83 138.05,97.99 137.96,97.99 UC1.J1
  BOTTOM w0.108: R9499.1 R124.2 152.91,60.68 151.94,60.68 151.47,60.21 151.47,59.22 150.89,58.64 149.49,58.64 149.01,59.12 149.01,63.69 v2(149.79,64.48) 150.15,64.83 150.15,65.34 150.86,66.05 v1(151.78,66.05)
HDD_DEVSLP_R: length 6.2
  BOTTOM w0.108: v2(159.73,57.72) 158.1,59.35 JSTRG1.12 154.26,59.35 R9499.2
HDD_FALL_INT: length 101.4
  IN1 w0.089: v1(188.3,46.5) 188.24,46.44 184.16,46.44 181.56,49.04 181.56,56.59 v1(183.51,58.55)
  IN3 w0.089: v1(149.93,80.76) 150.69,80 153.88,80 156.76,77.12 159.12,77.12 159.75,77.75 160.78,77.75 161.58,76.95 162.91,76.95 163.71,77.75 167.41,77.75 168.08,77.08 172.91,77.08 173.67,76.32 176.07,76.32 183.68,68.7 183.68,65.58 186.45,62.81 v1(188.78,62.81)
  BOTTOM w0.076: UC1.BB11 131.72,79.56 132.31,78.97 132.31,78.97 132.65,78.63 134.58,78.63 135.1,78.11 138.25,78.11 138.64,78.51 140.46,78.51 140.93,78.98 141.16,78.98
  BOTTOM w0.108: v1(183.51,58.55) 183.51,59.92 185.68,62.09 188.07,62.09 v1(188.78,62.81) ; v1(188.3,46.5) 188.84,45.96 189.14,45.96 R9458.2 ; RC475.1 150.41,80.28 v1(149.93,80.76) v2(149.93,79.72) 149.93,79.03 148.64,77.74 143.17,77.74 141.93,78.98 141.16,78.98
HDD_LED#: length 4.5
  TOP w0.254: Q144.2 262.87,8.83 262.42,9.28 v1(262.18,9.28)
  BOTTOM w0.254: JLED1.7 v1(262.18,9.28) 262.28,9.28 262.66,9.67 262.66,10.22 v2(262.14,10.74)
HDD_LED#_Q: length 16
  TOP w0.108: Q25.3 v1(272.49,11.4) ; v1(262.04,7.18) 262.26,6.96 Q144.1
  BOTTOM w0.108: v1(262.04,7.18) 263.16,6.06 264.36,6.06 267.3,8.99 267.3,10.35 v2(267.42,10.48) 267.73,10.78 269.86,10.78 270.79,11.72 272.18,11.72 v1(272.49,11.4)
HDD_LED#_R: length 8.1
  TOP w0.254: v2(258.81,7.23) 259.19,7.61 Q144.3 260.49,7.05 259.9,6.47 v1(259.65,6.47) ; R438.2 v1(262.06,4.15)
  BOTTOM w0.254: v1(262.06,4.15) 260.95,4.15 260.11,4.99 260.11,6.01 v1(259.65,6.47)
HDMI_CEC: length 14.3
  IN1 w0.089: v1(17.33,116.73) 17.33,116.83 16.44,117.72 12.38,117.72 11.96,118.14 10.54,118.14 10.01,117.6 10.01,115.69 JHDMI1.13
  BOTTOM w0.108: C9527.1 17.17,117.41 R473.1 17.46,116.85 v1(17.33,116.73) 17.74,116.32 v2(17.84,116.32)
HDMI_CLKN: length 4.6
  TOP w0.102: L10.1 18.46,115.48 18.78,115.15 19.34,115.15 v1(19.63,115.45) 19.94,115.14 20.41,115.14 C191.1
  BOTTOM w0.102: R466.1 20.54,115.05 20.03,115.05 v1(19.63,115.45)
HDMI_CLKP: length 4.6
  TOP w0.102: C103.1 20.31,114.94 19.89,114.94 v1(19.62,114.67) 19.34,114.95 18.78,114.95 18.46,114.63 L10.4
  BOTTOM w0.102: R464.1 20.4,114.85 19.8,114.85 v1(19.62,114.67)
HDMI_HPD_SINK: length 11.9
  TOP w0.108: QZ22.6 17.96,119.86 17.74,119.65 17.74,119.51 17.54,119.3 17.15,119.3 17.08,119.37 R474.1 16.75,118.99 16.62,118.86 v2(14.79,118.86) 14.53,118.86 v1(13.84,118.16)
  IN4 w0.089: JHDMI1.19 10.21,117.7 10.67,118.16 v1(13.84,118.16)
  BOTTOM w0.108: C9528.1 v1(13.84,118.16)
HDMI_OB: length 13.4
  TOP w0.254: QZ22.3 v1(21.65,121.16) v2(22.34,121.16)
  BOTTOM w0.254: R465.2 21.71,109.59 R468.2 21.7,110.48 R467.2 21.71,112 R469.2 21.7,112.9 R464.2 R466.2 R462.2 21.71,117.21 R463.2 21.71,118.73 21.65,118.78 v1(21.65,121.16)
HDMI_TX_N0: length 4.7
  TOP w0.102: C209.1 20.32,117.72 19.74,117.72 v1(19.52,117.95) 19.27,117.69 18.78,117.69 18.46,118.02 L13.1
  BOTTOM w0.102: R463.1 20.44,117.75 19.72,117.75 v1(19.52,117.95)
HDMI_TX_N1: length 4.4
  TOP w0.102: RN4103.3 18.51,112.94 18.81,112.64 19.59,112.64 v1(19.83,112.87) 20.14,112.55 20.36,112.55 C270.1
  BOTTOM w0.102: v1(19.83,112.87) 20.13,112.56 20.51,112.56 R469.1
HDMI_TX_N2: length 4.4
  TOP w0.102: RN4104.3 18.55,110.37 18.86,110.06 19.54,110.06 v1(19.83,110.35) 20.06,110.12 20.34,110.12 C272.1
  BOTTOM w0.102: v1(19.83,110.35) 20.08,110.1 20.46,110.1 R468.1
HDMI_TX_P0: length 4.7
  TOP w0.102: C199.1 20.39,117.52 19.85,117.52 v1(19.55,117.21) 19.27,117.49 18.73,117.49 18.41,117.17 L13.4
  BOTTOM w0.102: v1(19.55,117.21) 19.88,117.54 20.5,117.54 R462.1
HDMI_TX_P1: length 4.4
  TOP w0.102: C269.1 20.36,112.35 20.04,112.35 v1(19.81,112.12) 19.5,112.43 18.76,112.43 18.46,112.14 RN4103.1
  BOTTOM w0.102: R467.1 20.48,112.36 20.05,112.36 v1(19.81,112.12)
HDMI_TX_P2: length 4.4
  TOP w0.102: C271.1 20.37,109.92 20.13,109.92 v1(19.8,109.59) 19.53,109.86 18.84,109.86 18.55,109.57 RN4104.1
  BOTTOM w0.102: v1(19.8,109.59) 20.1,109.89 20.53,109.89 R465.1
HOST_DEB_TX: length 105.7
  TOP w0.108: R400.1 v1(231.84,68.21) ; v1(153.18,77.08) 153.54,76.72 153.54,76.64 153.64,76.54 JDEG1.8
  IN2 w0.089: v1(222.26,53.21) 222.24,53.21 222.26,53.21 222.26,53.23 222.26,53.23 221.76,53.73 218.06,53.73 215.48,51.15 208.69,51.15 206.08,53.76 194.47,53.76 193.63,54.6 190.24,54.6 188.84,56 187.72,56 186.12,57.6 185.38,57.6 184.54,58.44 184.54,58.68 184.18,59.04 182.52,59.04 174.2,67.36 174.2,68.22 169.56,72.86 168.2,72.86 165.7,75.36 154.89,75.36 v1(153.18,77.08)
  BOTTOM w0.108: v1(231.84,68.21) 231.25,67.63 v2(229.32,67.63) 228.48,66.79 226.05,66.79 225.36,66.1 225.36,65.32 224.65,64.61 224.65,64.1 224.16,63.62 224.06,63.62 222.82,62.37 222.82,61.37 222.69,61.24 222.69,58.55 223.27,57.96 223.27,54.8 222.26,53.79 v1(222.26,53.21)
HOST_DEBUG_TX: length 12
  TOP w0.108: U38.B44 233.5,60.76 v1(234.11,60.15) ; v1(233.74,66.03) 233.44,66.03 R396.1 R400.2
  IN4 w0.089: v1(233.74,66.03) 233.6,65.89 233.6,61.7 233.07,61.16 233.07,60.05 233.3,59.81 233.77,59.81 v1(234.11,60.15)
  BOTTOM w0.108: v2(233.36,66.74) 233.36,66.41 v1(233.74,66.03)
HOST_SD_WP#: length 62.5
  IN2 w0.089: v3(139.3,91.3) 139.63,91.63 139.63,92.04 140.14,92.55 142.59,92.55 143.83,93.79 143.83,96.89 144.07,97.13 147.09,97.13 148.85,95.37 153.12,95.37 v1(153.88,96.13) 154.77,95.24 157.8,95.24 158.29,95.73 159.7,95.73 160.11,95.31 162.19,95.31 162.42,95.09 168.11,95.09 169.17,96.15 172.38,96.15 176.41,92.11 176.41,83.99 v1(178.62,81.78)
  BOTTOM w0.076: UC1.AB3 136.77,91.02 136.98,91.02 137.09,90.98 137.29,90.98 137.41,91.01 137.65,91.01 137.82,90.95 138.95,90.95 v3(139.3,91.3)
  BOTTOM w0.108: JIOR1.52 178.58,81.73 v1(178.62,81.78) ; RC479.1 154.08,95.93 v1(153.88,96.13) v2(153.88,96.81)
HS_DET#: length 117.8
  TOP w0.108: U37.B58 256.24,54.58 256.83,53.99 v1(256.83,53.67)
  IN3 w0.089: v1(167.83,34.15) 168.89,35.21 192.6,35.21 193.64,34.18 222.97,34.18 229.41,40.62 232.69,40.62 233.96,39.36 238.9,39.36 240.52,37.73 249.44,37.73 250.25,36.92 255.31,36.92 v1(255.79,37.4)
  IN4 w0.089: v1(255.79,37.4) 257.18,38.8 257.18,39.87 256.1,40.95 256.1,43.56 256.44,43.9 256.44,45.54 255.9,46.09 255.9,46.94 256.62,47.67 256.62,52.16 256.83,52.37 v1(256.83,53.67)
  BOTTOM w0.108: v1(167.83,34.15) 167.83,34.02 v2(167.4,33.59) 167.22,33.41 167.22,32.04 PR5118.1 167.28,31.24 JHS1.5
HS_IND/CFG_SEL1: length 7.8
  BOTTOM w0.108: U92.25 189.56,130.18 190.92,131.53 v2(190.92,132.12) 191.07,132.27 R2729.2 190.63,133.6 190.63,134.88 R2725.1
HS_LCDPWR_DIS: length 11.1
  TOP w0.108: UC12.4 56.12,114.94 55.95,115.11 R9673.2 56.23,115.93 56.23,117.02 56.95,117.75 Q4210.1 56.24,118.43 55.48,119.19 v2(55.48,120.71) 55.48,121.54 55.91,121.97 Q4211.1
HSYNC_BUF: length 18.5
  TOP w0.089: 83.63,128.38 U6.M9
  TOP w0.108: v1(79.97,128.41) 80.2,128.41 80.88,127.72 82.92,127.72 83.58,128.38 83.63,128.38
  BOTTOM w0.108: v1(79.97,128.41) 79.97,129.02 79.28,129.71 v2(79.28,135.55) 79.28,138.16 80.96,139.84 R2743.1
HSYNC_BUF_L: length 12.7
  IN4 w0.089: v1(88.18,145.12) 88.58,145.53 88.58,146.73 87.8,147.51 86.1,147.51 JCRT1.13
  BOTTOM w0.108: v1(88.18,145.12) D4.1 C18.1 R2740.1 85.91,143.32 v2(85.71,143.12) 85.29,143.12 85.18,143.23 L4.2
HSYNC_BUF_R: length 3.1
  BOTTOM w0.108: R2743.2 80.96,141.9 v2(81.52,142.46) 82.29,143.23 L4.1
HUB_SRCDET: length 5.6
  TOP w0.089: U6.C2 90.85,132.59 92.73,132.59 93.03,132.3
  TOP w0.108: 93.03,132.3 93.03,132.22 93.66,131.59 93.66,131.38 R9594.1 94.12,130.19 v2(94.33,129.98)
HUB_USB20_N1: length 203.1
  IN3 w0.102: v1(182.15,127.75) 182.15,123.15 181.8,122.8 178.9,122.8 178.72,122.98 171.1,122.98 170.85,123.23 169.76,123.23 169.48,122.95 167.3,122.95 167.07,123.18 163.08,123.18 159.95,126.3 159.95,135.34 158.3,137 149.82,137 149.61,137.2 142.78,137.2 141.52,138.46 139.54,138.46 136.26,141.74 136.26,142.12 133.79,144.59 133.26,144.59 132.42,145.43 126.38,145.43 125.67,146.14 116.81,146.14 115.82,145.15 105.58,145.15 105.09,144.67 102.66,144.67 93.72,135.73 91.35,135.73 90.54,134.91 90.54,134.76 89.37,133.59 88.96,133.59 86.93,131.56 86.93,130.44 86.37,129.88 84.72,129.88 81.93,127.09 78.73,127.09 78.27,126.63 77.26,126.63 75.68,125.05 75.68,124.24 75.14,123.71 73.75,123.71 72.33,122.29 70.32,122.29 68.41,120.38 65.19,120.38 62.65,117.84 59.73,117.84 57.67,115.79 56.03,115.79 45.53,105.28 45.53,103.26 43.91,101.64 40.23,101.64 38.67,100.09 38.67,99.15 38.77,99.05 38.92,99.05 38.98,99.1 39.12,99.1 39.24,98.98 39.24,98.83 v1(39.03,98.62)
  BOTTOM w0.102: 42.17,98.81 41.85,98.49 41.02,98.49 D7120.1 40.35,96.7 40.35,95.78 40.21,95.64 39.16,95.64 38.62,96.19 38.62,98.21 v1(39.03,98.62) ; 42.17,98.81 v6(42.17,98.83) ; 42.17,98.81 43.17,99.81 43.71,99.81 44.03,100.13 JEDP1.28 ; U92.1 182.05,129.18 181.9,129.32 181.76,129.32 181.67,129.24 181.67,128.42 181.83,128.26 182.03,128.26 182.15,128.13 v1(182.15,127.75)
HUB_USB20_N2: length 110
  IN4 w0.102: v1(184.5,51.96) 184.09,52.37 184.09,52.55 183.79,52.85 182.04,52.85 181.67,53.22 181.67,56.43 180.17,57.93 180.17,59.61 175.27,64.51 175.27,73.67 177.39,75.79 177.39,83.68 175.7,85.37 175.7,93.74 174.74,94.7 174.74,102.66 172.48,104.92 172.48,107.01 162.88,116.6 162.5,116.6 161.82,117.28 161.82,117.45 v1(162.01,117.64)
  BOTTOM w0.102: 171.47,119.34 175.14,119.34 176.44,120.64 177.48,120.64 179.26,122.42 180.23,122.42 180.66,122.84 180.66,123.91 180.83,124.09 180.83,129.45 181.72,130.34 181.95,130.34 182.11,130.18 U92.3 ; 171.47,119.34 170.63,119.34 169.56,118.28 163.98,118.28 163.55,118.71 162.09,118.71 161.61,118.23 161.61,118.05 v1(162.01,117.64) ; 171.47,119.34 v6(171.47,119.32) ; RN4149.1 184.74,52.71 184.36,52.33 184.36,52.1 v1(184.5,51.96)
HUB_USB20_N2_R: length 4.3
  BOTTOM w0.102: RN4149.2 184.74,54.68 184.45,54.96 184.45,55.47 184.11,55.82 183.25,55.82 182.51,56.55 182.51,56.63 182.63,56.75 JEPC1.19
HUB_USB20_N3: length 208
  IN3 w0.102: v1(33.18,99.3) 32.83,99.3 32.7,99.43 32.7,99.61 32.9,99.81 33.95,99.81 34.58,100.44 34.58,101.19 36.04,102.65 39.48,102.65 42.54,105.71 43.3,105.71 47.81,110.22 47.81,112.92 49.36,114.47 49.36,114.64 51,116.28 53.36,116.28 54.39,117.31 57.44,117.31 59.13,119 62.17,119 64.25,121.07 64.25,121.45 66.48,123.69 72.02,123.69 76.21,127.88 77.55,127.88 79.66,129.99 82.15,129.99 84.9,132.73 84.9,133.32 88.86,137.28 93.65,137.28 102.23,145.86 104.66,145.86 105.17,146.37 115.29,146.37 116.28,147.36 126.05,147.36 126.86,146.55 133.08,146.55 133.89,145.74 134.37,145.74 140.04,140.07 143.42,140.07 144.84,138.65 153.74,138.65 154.22,138.16 160.16,138.16 160.62,137.71 160.62,136.44 161.86,135.19 161.86,129.15 162.24,128.77 162.24,125.62 163.51,124.35 180.52,124.35 181.04,124.86 181.04,125.99 180.78,126.24 180.78,128.76 182.43,130.41 182.43,131.13 182.03,131.53 181.37,131.53 181.27,131.43 v1(181.04,131.43)
  BOTTOM w0.102: L8.1 28.05,102.51 27.62,102.93 27.62,103.46 27.8,103.64 28.64,103.64 29.04,103.23 29.04,100.69 30.08,99.66 31.2,99.66 ; v6(31.2,99.63) 31.2,99.66 ; 31.2,99.66 33.15,99.66 33.23,99.58 33.23,99.35 v1(33.18,99.3) ; v1(181.04,131.43) 181.28,131.68 U92.6
HUB_USB20_N3_R: length 12.2
  BOTTOM w0.102: JEDP1.47 34.53,101 34.4,100.88 34.4,100.76 34.5,100.66 34.56,100.66 34.6,100.7 34.71,100.7 34.78,100.63 34.78,100.55 34.28,100.05 34.28,98.75 33.68,98.16 30.54,98.16 29.31,99.39 ; L8.2 28.05,100.11 27.96,100.02 27.71,100.02 27.63,99.94 27.63,99.84 27.71,99.76 28.94,99.76 29.31,99.39 ; 29.31,99.39 v6(29.34,99.39)
HUB_USB20_N4: length 36.5
  IN4 w0.102: v1(179.18,121.43) 179.39,121.63 179.39,122.27 179.74,122.62 181.46,122.62 181.72,122.88 181.72,125.6 182.61,126.49 182.61,129.06 182.31,129.37 182.31,132.67 182.09,132.88 181.21,132.88 v1(181.04,132.7)
  BOTTOM w0.102: v1(181.04,132.7) 181.16,132.83 181.67,132.83 181.82,132.68 U92.8 ; 177.49,119.75 178.46,119.75 179.39,120.67 179.39,121.22 v1(179.18,121.43) ; 177.49,119.75 176.72,119.75 175.14,118.17 173.61,118.17 169.29,113.85 165.34,113.85 165.15,114.04 165.15,114.77 165.03,114.9 JGPS1.3 ; 177.49,119.75 v6(177.49,119.76)
HUB_USB20_P1: length 203.2
  IN3 w0.102: v1(181.53,127.75) 181.9,127.38 181.9,123.26 181.69,123.05 179,123.05 178.82,123.24 171.2,123.24 170.95,123.48 169.66,123.48 169.38,123.2 167.4,123.2 167.17,123.43 163.18,123.43 160.21,126.41 160.21,135.45 158.41,137.25 149.92,137.25 149.72,137.45 142.89,137.45 141.62,138.72 139.64,138.72 136.51,141.85 136.51,142.23 133.9,144.84 133.37,144.84 132.52,145.68 126.48,145.68 125.77,146.39 116.71,146.39 115.72,145.4 105.47,145.4 104.99,144.92 102.55,144.92 93.61,135.98 91.24,135.98 90.28,135.02 90.28,134.86 89.27,133.85 88.86,133.85 86.68,131.67 86.68,130.55 86.27,130.14 84.61,130.14 81.82,127.34 78.62,127.34 78.16,126.89 77.15,126.89 75.42,125.16 75.42,124.35 75.04,123.97 73.65,123.97 72.22,122.54 70.21,122.54 68.31,120.64 65.09,120.64 62.54,118.09 59.62,118.09 57.57,116.04 55.93,116.04 45.27,105.39 45.27,103.37 43.8,101.9 40.12,101.9 38.42,100.19 v1(38.42,98.62)
  BOTTOM w0.102: v1(181.53,127.75) 181.53,128.27 181.46,128.34 181.46,129.32 181.67,129.53 181.9,129.53 182.05,129.68 U92.2 ; v6(38.4,97.32) 38.42,97.32 ; 38.42,97.32 v1(38.42,98.62) ; 38.42,97.32 38.42,96.1 39.08,95.44 40.3,95.44 40.55,95.7 40.55,96.76 D7119.1 40.67,97.65 40.67,97.86 41.1,98.29 41.94,98.29 43.26,99.61 43.79,99.61 44.23,100.05 44.23,100.65 44.53,100.95 JEDP1.27
HUB_USB20_P2: length 110
  IN4 w0.102: v1(161.4,117.64) 161.61,117.43 161.61,117.2 162.42,116.4 162.8,116.4 172.27,106.92 172.27,104.84 174.53,102.58 174.53,94.62 175.5,93.66 175.5,85.28 177.19,83.59 177.19,75.87 175.07,73.75 175.07,64.42 179.97,59.52 179.97,57.85 181.47,56.35 181.47,53.14 181.96,52.65 183.7,52.65 183.89,52.47 v1(183.89,51.96)
  BOTTOM w0.102: 173.21,119.55 170.54,119.55 169.48,118.48 164.07,118.48 163.63,118.92 162.01,118.92 161.4,118.31 161.4,117.96 161.4,117.96 v1(161.4,117.64) ; 173.21,119.55 v6(173.21,119.57) ; 173.21,119.55 175.06,119.55 176.35,120.84 177.4,120.84 179.17,122.62 180.15,122.62 180.45,122.92 180.45,124 180.63,124.18 180.63,129.54 181.64,130.54 181.93,130.54 182.06,130.68 U92.4 ; v1(183.89,51.96) 184.11,52.19 184.11,52.37 183.94,52.53 RN4149.3
HUB_USB20_P2_R: length 4.4
  BOTTOM w0.102: RN4149.4 183.94,54.68 184.25,54.99 184.25,55.39 184.03,55.61 183.16,55.61 182.75,56.02 ; JEPC1.18 182.13,56.81 182.31,56.63 182.31,56.47 182.75,56.02 ; 182.75,56.02 v6(182.75,56)
HUB_USB20_P3: length 208
  IN3 w0.102: v1(181.04,132.07) 181.32,131.79 182.14,131.79 182.69,131.24 182.69,130.31 181.04,128.66 181.04,126.35 181.29,126.1 181.29,124.75 180.63,124.09 163.41,124.09 161.99,125.51 161.99,128.66 161.61,129.04 161.61,135.09 160.36,136.33 160.36,137.6 160.05,137.91 154.11,137.91 153.63,138.39 144.74,138.39 143.31,139.82 139.94,139.82 134.26,145.49 133.78,145.49 132.98,146.29 126.75,146.29 125.94,147.1 116.38,147.1 115.39,146.11 105.27,146.11 104.76,145.61 102.34,145.61 93.75,137.02 88.96,137.02 85.15,133.21 85.15,132.63 82.26,129.73 79.77,129.73 77.66,127.62 76.31,127.62 72.12,123.43 66.59,123.43 64.5,121.35 64.5,120.96 62.28,118.74 59.23,118.74 57.55,117.06 54.5,117.06 53.47,116.03 51.1,116.03 49.62,114.54 49.62,114.36 48.07,112.81 48.07,110.12 43.4,105.46 42.64,105.46 39.58,102.39 36.15,102.39 34.83,101.08 34.83,100.34 33.83,99.33 v1(33.83,99.27)
  BOTTOM w0.102: 28.22,103.84 28.72,103.84 29.25,103.32 29.25,100.78 30.16,99.86 33.24,99.86 33.52,99.58 v1(33.83,99.27) ; 28.22,103.84 27.71,103.84 27.42,103.54 27.42,102.73 27.22,102.53 RN4100.1 ; 28.22,103.84 v6(28.22,103.86) ; U92.7 182.04,132.18 181.74,131.88 181.22,131.88 v1(181.04,132.07)
HUB_USB20_P3_R: length 12.3
  BOTTOM w0.102: 34.48,99.4 34.48,99.96 35.03,100.51 JEDP1.46 ; 34.48,99.4 v6(34.5,99.4) ; 34.48,99.4 34.48,98.67 33.77,97.96 30.46,97.96 28.86,99.56 27.62,99.56 27.2,99.98 L8.3
HUB_USB20_P4: length 36.4
  IN4 w0.102: v1(181.04,133.34) 181.29,133.08 182.18,133.08 182.51,132.75 182.51,129.45 182.81,129.15 182.81,126.4 181.93,125.51 181.93,122.8 181.54,122.42 179.82,122.42 179.59,122.18 179.59,121.63 v1(179.79,121.43)
  BOTTOM w0.102: U92.9 181.82,133.18 181.68,133.03 181.34,133.03 v1(181.04,133.34) ; v6(179.28,120.24) 179.28,120.28 ; 179.28,120.28 178.55,119.55 176.8,119.55 175.23,117.97 173.69,117.97 169.38,113.65 JGPS1.2 ; 179.28,120.28 179.59,120.59 179.59,121.22 v1(179.79,121.43)
HW_GPS_DISABLE#: length 247.2
  TOP w0.108: v1(268.29,59.65) 268.46,59.83 R282.2 ; U37.A35 263.03,59.51 v1(263.21,59.68)
  IN2 w0.089: v1(268.29,59.65) 267.78,60.16 265.77,60.16 263.94,61.99 258.56,61.99 258.43,62.12 246.83,62.12 244.32,64.62 226.12,64.62 226.1,64.65 223.55,64.65 223.36,64.47 220.83,64.47 218.31,61.95 214.3,61.95 212.79,60.44 206.31,60.44 205.68,59.8 204.11,59.8 202,57.69 196.98,57.69 194.4,60.27 190.43,60.27 187.06,63.64 186.97,63.64 185.03,65.58 185.03,74.99 188.28,78.23 188.28,85.18 189.61,86.51 189.61,88.51 190.07,88.98 190.07,91.17 189.79,91.45 189.79,95.2 189.13,95.86 189.13,96.35 188.76,96.72 188.76,105.32 183.42,110.66 176.41,110.66 175.5,111.56 174.21,112.86 167.29,112.86 164.63,115.51 158.69,115.51 155.37,118.83 140.27,118.83 132.65,126.45 128.89,126.45 127.01,128.33 123.75,128.33 123.1,128.99 123.1,129.53 120.46,132.17 114.44,132.17 112.39,130.11 108.65,130.11 106.48,127.95 99.85,127.95 v1(98.08,129.72)
  IN3 w0.089: v1(268.29,59.65) 267.8,59.17 263.71,59.17 v1(263.21,59.68)
  BOTTOM w0.108: v2(269.02,59.65) v1(268.29,59.65) ; D7111.2 98.62,129.46 98.36,129.72 v1(98.08,129.72)
HW_GPS_DISABLE#_R: length 3.9
  BOTTOM w0.108: JWWAN1.26 99.55,127.83 99.55,127.82 D7111.1 98.87,128.36 98.39,128.84 v2(97.62,128.84)
I2C0_SCL_VMM: length 118.2
  TOP w0.076: RC616.1 140.52,96.84 v3(141.16,97.47)
  TOP w0.089: 93.03,132.68 92.92,132.79 91.96,132.79 U6.A2
  TOP w0.108: 93.03,132.68 93.13,132.58 v1(93.53,132.58) 93.53,132.4 R9637.1
  IN1 w0.089: v1(93.53,132.58) 93.69,132.42 94.22,132.42 96.1,130.54 97.7,130.54 101.62,134.47 103.63,134.47 104.46,135.29 106.49,135.29 107.15,135.95 113.75,135.95 115.57,134.14 124.72,134.14 127.51,131.35 132.86,131.35 133.15,131.06 136.17,131.06 138.8,128.43 138.8,125.79 138.84,125.75 138.84,124.66 138.6,124.42 138.51,124.42 138.26,124.17 138.26,123.69 138.9,123.05 138.9,120.29 141.21,117.98 152.73,117.98 159.06,111.65 159.06,104.87 v1(159.32,104.61)
  BOTTOM w0.108: v3(141.16,97.47) 142.2,97.47 142.76,98.03 148.49,98.03 149.57,99.11 150.28,99.11 v2(150.89,99.71) 151.57,100.39 151.57,102.99 151.57,103.19 153.3,104.93 159.01,104.93 v1(159.32,104.61)
I2C0_SCL_VMM_R: length 20.4
  TOP w0.108: RP8.1 151.43,93.3 150.83,93.9 v2(150.4,93.9) 144.92,93.9 142.39,96.43 141.06,96.43 141.02,96.39 140.38,96.39 140.25,96.25 139.86,96.25 RC616.2 139.28,96.45 138.7,95.87 137.09,95.87 135.58,94.36 135.58,94.36 135.5,94.28 v3(135.36,94.28)
  BOTTOM w0.076: v3(135.36,94.28) 135.36,94.27 135.12,94.03 UC1.U6
I2C0_SDA_VMM: length 120.8
  TOP w0.076: v3(140.64,95.82) 140.4,95.59 RC615.1
  TOP w0.089: v1(92.63,133.48) 92.53,133.58 U6.A1
  TOP w0.108: R9636.1 93.81,133.9 93.32,133.9 92.9,133.48 v1(92.63,133.48)
  IN1 w0.089: v1(159.32,104) 158.81,104.52 158.81,111.55 152.59,117.76 141.12,117.76 138.64,120.24 138.64,122.94 138.04,123.55 138.04,125.01 138.59,125.56 138.59,128.28 136.07,130.8 133.02,130.8 132.73,131.1 127.46,131.1 124.63,133.92 115.48,133.92 113.66,135.74 107.24,135.74 106.58,135.08 104.56,135.08 103.74,134.25 101.71,134.25 97.79,130.33 96.01,130.33 95.92,130.42 95.91,130.42 94.28,132.04 93.36,132.04 92.96,132.45 92.96,132.65 92.63,132.97 v1(92.63,133.48)
  BOTTOM w0.108: v3(140.64,95.82) 140.88,95.82 v2(141.71,96.66) 142.06,97 142.44,97 143.23,97.79 148.59,97.79 149.67,98.87 150.73,98.87 151.8,99.94 151.8,103.09 153.4,104.69 158.63,104.69 v1(159.32,104)
I2C0_SDA_VMM_R: length 21
  TOP w0.108: RP8.3 151.52,92.7 150.96,93.26 150.43,93.26 150.04,93.64 148.48,93.64 148.19,93.36 v2(148.12,93.36) 147.84,93.64 144.84,93.64 142.29,96.19 140.46,96.19 140.27,96 139.64,96 RC615.2 137.08,95.59 135.77,94.28 135.77,94.17 135.51,93.91 135.08,93.91 v3(134.71,94.28)
  BOTTOM w0.076: v3(134.71,94.28) 134.72,94.27 134.72,94.16 134.47,93.91 UC1.U7
I2C1_SCK_TP: length 57.5
  TOP w0.108: RP8.5 151.06,92.2 v2(151.01,92.24) 150.51,92.24 v1(149.95,91.68) 148.86,92.77 144.67,92.77 143.21,94.23 141.06,94.23 141.02,94.19 136.74,94.19 136.51,93.96 135.85,93.96 135.57,93.69 134.07,93.69 v3(133.56,93.18) ; R449.1 152.5,62.4 v1(152.72,62.4)
  IN4 w0.089: v1(152.72,62.4) 153.12,62.8 153.12,66.64 151.39,68.37 151.39,70.98 153.23,72.82 154.89,72.82 155.71,73.65 155.71,76.11 156.03,76.43 156.03,77.68 154.57,79.15 154.57,79.8 153.74,80.62 153.74,81.21 153.51,81.43 153.1,81.43 152.54,81.99 152.54,86.97 152.3,87.22 152.3,87.22 150.87,88.65 150.87,89.33 150.34,89.87 150.34,91.29 v1(149.95,91.68)
  BOTTOM w0.108: v3(133.56,93.18) 133.39,93.35 133.39,93.44 UC1.U9
I2C1_SDA_TP: length 57.7
  TOP w0.108: RP8.7 150.64,91.59 v1(150.56,91.68) 150.15,91.27 149.78,91.27 149.52,91.53 149.52,91.78 148.76,92.54 144.57,92.54 143.11,94 142.18,94 v2(141.9,93.71) 141.61,94 136.82,94 136.59,93.76 135.93,93.76 135.66,93.49 134.46,93.49 v3(134.15,93.18) ; R450.1 152.35,61.72 v1(152.72,61.72)
  IN4 w0.089: v1(150.56,91.68) 150.56,89.96 151.09,89.42 151.09,88.74 152.76,87.06 152.76,82.08 153.19,81.65 153.6,81.65 153.95,81.3 153.95,80.71 154.82,79.84 154.82,79.2 156.25,77.77 156.25,76.34 155.93,76.02 155.93,73.56 154.98,72.61 153.38,72.61 151.63,70.86 151.63,68.57 153.33,66.87 153.33,62.34 v1(152.72,61.72)
  BOTTOM w0.108: v3(134.15,93.18) 134.15,93.33 UC1.U8
I2S_BCLK: length 5.1
  TOP w0.221: 42.72,127.02 U17.16
  TOP w0.254: 42.72,127.02 44.56,128.87 44.56,129.25 T2706.1
I2S_DI#: length 2.2
  TOP w0.221: T2703.1 38.49,126.73 39.52,125.71 U17.24
I2S_DO: length 6.7
  TOP w0.221: 42.32,127.18 U17.17
  TOP w0.254: T2705.1 43.93,130.21 43.93,128.79 42.32,127.18
I2S_LRCLK: length 4
  TOP w0.221: 41.92,127.9 U17.18
  TOP w0.254: T2704.1 41.92,127.9
I2S_MCLK: length 4.4
  TOP w0.221: U17.15 43.12,126.03
  TOP w0.254: v1(44.33,127.78) 44.23,127.78 43.47,127.01 43.47,126.38 43.12,126.03
  BOTTOM w0.254: T2707.1 44.33,129.07 v1(44.33,127.78)
I_ADP: length 33.8
  TOP w0.108: v1(235.75,50.53) 235.75,50.54 U38.A12 ; PR5228.2 v1(244.18,30.6)
  IN4 w0.089: v1(244.18,30.6) 246.19,30.6 247.08,31.48 247.08,32.37 246.19,33.26 246.19,33.26 245.76,33.69 245.76,37.82 244.93,38.65 244.93,39.98 242.65,42.26 242.65,50.57 242.08,51.14 239.15,51.14 239.09,51.21 236.09,51.21 235.75,50.86 v1(235.75,50.53)
  BOTTOM w0.108: v2(243.53,30.6) v1(244.18,30.6)
I_BATT: length 67
  TOP w0.108: R381.2 224.09,56.5 v1(223.96,56.38) ; PR5229.2 v1(244.18,31.48)
  IN1 w0.089: v1(244.18,31.48) 244.6,31.07 250.6,31.07 v1(251.27,31.74) ; v1(254.16,54.37) 253.37,55.16 241.81,55.16 241.33,55.65 226.34,55.65 225.61,56.38 v1(223.96,56.38)
  BOTTOM w0.108: v1(251.27,31.74) 251.27,31.41 251.66,31.01 v2(252.17,31.01) 253.31,32.16 253.31,33.68 254.41,34.78 254.41,35.44 253.44,36.41 253.44,42.39 253.06,42.78 253.06,47.6 254.7,49.25 254.7,50.41 254.46,50.66 254.46,54.08 v1(254.16,54.37)
I_BATT_R: length 8.3
  TOP w0.108: U38.B61 230.3,56.13 v1(230.8,56.63) ; R381.1 v1(226.12,56.5)
  IN4 w0.089: v1(226.12,56.5) 226.63,55.99 229.59,55.99 229.72,56.12 230.29,56.12 v1(230.8,56.63)
  BOTTOM w0.108: v1(226.12,56.5) 225.89,56.73 v2(225.89,57.19)
I_SYS: length 349.2
  TOP w0.108: v1(250.35,48.78) 250.07,49.06 R9689.2 ; PR5231.2 v1(244.18,32.37) ; v1(66.86,121.12) 66.58,120.84 66.58,120.79 PR5824.1
  IN1 w0.089: v1(253.2,26.43) 252.82,26.43 252.21,27.04 244.24,27.04 242.6,25.4 229.48,25.4 229.02,24.94 217.35,24.94 215.43,26.86 214.55,26.86 213.42,27.99 213.42,29.23 211.62,31.03 189.04,31.03 184.91,35.15 176.66,35.15 176.21,35.6 176.21,36.82 175.14,37.89 175.14,44.37 171.62,47.9 171.62,64.2 170.45,65.37 168.48,65.37 165.89,67.96 165.89,89.44 167.07,90.62 167.07,92.14 166.09,93.11 166.09,96.81 166.38,97.09 166.38,103.01 166.55,103.18 166.55,116.12 153,129.68 150.04,129.68 149.06,130.66 149.06,131.38 149.87,132.19 149.87,133.59 149.08,134.38 148.28,134.38 147.59,135.07 142.69,135.07 142.51,134.89 140.24,134.89 137.17,137.96 136.96,138.17 136.96,139.53 133.81,142.69 131.81,142.69 131.72,142.77 124.24,142.77 123.43,143.57 108.58,143.57 106.12,141.12 106.12,138.83 104.86,137.58 104.38,137.58 102.92,136.12 100.43,136.12 99.61,135.3 96.68,135.3 96.2,135.78 96.2,136.51 95.06,137.66 92.27,137.66 90.8,139.12 77.38,139.12 74.09,135.83 74.09,133.01 75.8,131.31 75.81,131.31 76.81,130.3 76.81,129.23 77.78,128.26 77.78,125.93 77.27,125.42 76.4,125.42 73.9,122.92 68.59,122.92 66.86,121.2 v1(66.86,121.12) ; v1(252.03,32.6) 246.23,32.6 246,32.37 v1(244.18,32.37)
  IN4 w0.089: v1(252.03,32.6) 252.43,32.2 252.43,30.74 252,30.31 252,27.17 252.74,26.43 v1(253.2,26.43)
  BOTTOM w0.108: v1(253.2,26.43) 253.2,25.85 v2(253.05,25.69) ; v1(252.03,32.6) 252.74,33.32 252.74,36.99 252.26,37.48 252.26,39.58 252.95,40.28 252.95,42.19 252.49,42.66 251.17,42.66 250.73,43.1 250.73,43.52 249.82,44.43 249.82,45.71 250.67,46.56 250.67,48.47 v1(250.35,48.78)
IFDET_SATA#_PCIE: length 236.1
  TOP w0.108: v1(164.65,60.64) 165.1,61.09 165.1,61.21 RC617.1
  IN1 w0.089: v1(164.65,60.64) 165.1,60.19 165.1,59.36 165.06,59.31 165.06,54.63 165.18,54.5 165.18,49.41 v1(164.78,49.01) 165.19,48.6 165.19,45.76 v1(164.25,44.82)
  IN2 w0.089: v1(219.77,42.91) 219.35,43.34 204.27,43.34 203.55,42.62 177.24,42.62 174.64,45.22 164.65,45.22 v1(164.25,44.82) ; v3(139.12,102.67) 142.98,98.8 150.14,98.8 151.65,97.3 154.65,97.3 155.76,96.18 157.06,96.18 158.18,97.3 158.33,97.45 161.69,97.45 163.34,95.8 167.81,95.8 168.87,96.86 169.02,96.86 172.69,96.86 172.79,96.75 177.18,92.37 177.18,85.05 178.44,83.78 179.03,83.78 179.59,83.22 179.59,66.13 179.59,66.13 179.59,65.99 184.38,61.2 185.54,61.2 188.75,57.98 189.62,57.98 191.05,56.55 194.44,56.55 195.28,55.72 206.53,55.72 208.51,57.7 212.87,57.7 212.99,57.57 220.53,57.57 220.66,57.7 221.37,57.7 v1(221.55,57.52)
  BOTTOM w0.076: v3(139.12,102.67) 139.23,102.56 139.23,100.45 138.16,99.37 138.16,99.08 138.01,98.93 137.76,98.93 137.64,98.97 137.39,98.97 137.29,98.93 136.38,98.93 136.12,99.2 UC1.G4
  BOTTOM w0.108: v1(164.65,60.64) 165.02,61.01 U6206.20 ; U6205.20 164.91,49.4 164.78,49.28 v1(164.78,49.01) ; v1(219.77,42.91) 220.5,43.64 220.5,47.4 221.42,48.32 221.42,49.14 220.85,49.71 220.85,52.6 220.62,52.83 220.62,54.62 221.35,55.34 221.35,57.32 v1(221.55,57.52) ; v3(139.12,102.67) 138.01,103.78 138.01,107.17 138.1,107.27 138.1,107.29 138.5,107.69 138.5,107.69 138.55,107.74 138.55,108.32 RC11.1 ; JSTRG1.35 158.88,47.85 160.82,45.91 161.43,45.91 v2(161.71,45.63) 163,44.34 163.76,44.34 v1(164.25,44.82)
ILIM_SEL: length 5
  TOP w0.108: R9462.2 27.04,93.74 26.63,93.33 25.72,93.33 v2(24.88,94.17) v1(24.32,94.73)
  BOTTOM w0.108: v1(24.32,94.73) 24.52,94.73 24.68,94.89 24.68,95.12 24.56,95.25 U6204.4
ILMT_+1VALWP: length 4.6
  TOP w0.108: v2(130.62,125.51) 130.85,125.29 PR5501.1
  TOP w0.203: PR5501.1 131.43,124.58 131.67,124.82 PR5506.2 131.84,124.66 131.84,124.64 132.1,124.37 132.48,124.37 132.88,124.77 132.88,125.06 133.06,125.24 PU5501.3
IMVP_VR_ON: length 424.3
  TOP w0.108: U6218.2 218.19,68.19 v1(218.52,68.52) ; PR5817.1 67.07,120.69 v1(67.5,121.12) ; R9579.2 223.23,66.82 223.26,66.85 UC11.4 224.04,68.4 v1(224.04,68.57)
  IN1 w0.089: v1(67.5,121.12) 67.5,121.58 68.66,122.75 73.98,122.75 76.47,125.24 77.34,125.24 77.96,125.86 77.96,128.47 76.99,129.44 76.99,130.38 75.88,131.48 75.87,131.48 74.27,133.09 74.27,135.72 77.49,138.94 90.73,138.94 92.27,137.4 94.93,137.4 95.95,136.39 95.95,135.62 96.45,135.12 99.82,135.12 100.64,135.94 102.99,135.94 104.45,137.4 104.94,137.4 106.3,138.76 106.3,141.04 108.33,143.08 111.76,143.08 112.24,142.59 131.65,142.59 131.73,142.51 133.73,142.51 136.78,139.46 136.78,138.1 140.17,134.71 142.63,134.71 142.82,134.89 147.51,134.89 148.89,133.52 148.89,130.59 150.08,129.39 153.03,129.39 166.37,116.04 166.37,103.25 166.2,103.08 166.2,97.22 165.92,96.93 165.92,93.04 166.88,92.07 166.88,90.69 165.71,89.51 165.71,67.89 168.41,65.19 170.37,65.19 171.44,64.12 171.44,47.83 173.44,45.82 173.44,43.63 174.92,42.15 174.92,37.66 176.03,36.54 176.03,35.5 176.56,34.98 184.84,34.98 188.96,30.85 211.55,30.85 213.24,29.16 213.24,27.91 214.48,26.68 215.36,26.68 217.28,24.76 229.09,24.76 229.56,25.22 242.67,25.22 244.24,26.79 249.21,26.79 249.97,26.02 254.34,26.02 254.85,25.52 259.68,25.52 260.44,24.76 260.44,23.86 261.26,23.03 264.89,23.03 v1(268.64,26.79)
  IN2 w0.089: v1(224.04,68.57) 223.71,68.89 218.9,68.89 v1(218.52,68.52)
  IN3 w0.089: v1(224.04,68.57) 224.55,68.06 229.86,68.06 230.52,68.72 239.36,68.72 239.86,68.21 240.27,68.21 246.56,61.92 251.43,61.92 251.5,61.99 268.92,61.99 269.68,61.22 269.68,57.27 271.15,55.8 271.15,51.53 269.87,50.25 269.87,46.15 269.12,45.4 269.12,44.11 269.42,43.81 269.42,27.57 v1(268.64,26.79)
  BOTTOM w0.108: v1(268.64,26.79) 268.31,26.79 v2(267.96,26.43)
IMVP_VR_ON_EC: length 39
  TOP w0.108: U38.A1 230.25,51.13 229.3,50.18 v1(228.66,50.18) ; v1(221.91,65.64) 221.91,65.85 R9579.1 222.64,66.59 222.64,68.7 222.41,68.92 UC11.1
  IN3 w0.089: v1(219.48,46.47) 219.52,46.47 220.64,47.59 226.99,47.59 228.66,49.26 v1(228.66,50.18)
  BOTTOM w0.108: v1(221.91,65.64) 221.17,64.9 221.17,63.69 220.25,62.77 220.25,61.64 218.95,60.34 218.95,55.29 219.57,54.68 219.57,52.73 219.18,52.35 219.18,47.36 v2(219.31,47.23) 219.48,47.07 v1(219.48,46.47)
INT_SPK_L+: length 30.9
  TOP w1.016: 41.59,117.34 41.59,115 40.63,114.04 34.43,114.04 29.11,108.71 29.11,99.57 32.17,96.51
  vias: v2(33.92,95.21)
INT_SPK_L-: length 29
  TOP w1.016: 43.15,117.25 43.15,114.22 41.38,112.45 35.18,112.45 30.74,108.01 30.74,100.12 32.96,97.91
  vias: v2(33.97,97.09)
INT_SPKR_L+:
  vias: v2(42.43,92.16) v4(44,92.19)
INT_SPKR_L-:
  vias: v2(42.4,94.04) v4(45.27,92.19)
INTRUDER#: length 41.1
  TOP w0.108: v5(152.02,57.92) 152.02,57.92 152.02,57.93 151.35,58.6 R9557.1 150.93,58.96 v1(150.68,59.2)
  IN3 w0.089: v1(150.68,59.2) 149.52,59.2 149.06,59.66 149.06,60.41 148.01,61.46 144.97,61.46 143.33,63.09 143.33,63.72 141.32,65.73 141.32,67.32 138.6,70.04 137.15,70.04 136.41,70.78 136.41,71.95 135.26,73.1 134.88,73.1 133.21,74.77 133.21,77.62 128.71,82.11 128.71,84.44 v3(128.33,84.82)
  BOTTOM w0.108: UC1.AP16 128.46,84.82 v3(128.33,84.82)
IO_PME#: length 1.7
  TOP w0.108: v1(266.89,37.71) 266.72,37.54 U6202.3
  BOTTOM w0.108: v1(266.89,37.71) 266.89,37.35 T6273.1
IOR_BD_ID0#: length 133.2
  TOP w0.108: R9418.2 v1(259.4,46.72) 258.99,47.13 258.99,47.5 259.23,47.74 259.41,47.74 259.53,47.87 U37.A7
  IN2 w0.089: v1(259.09,60.06) 258.21,59.18 252.28,59.18 252.26,59.2 251.06,59.2 250.19,60.07 244.91,60.07 241.6,63.38 240.1,63.38 239.27,62.56 239.27,62.39 238.93,62.05 228.71,62.05 228.41,62.34 226.56,62.34 223.58,59.37 218.73,59.37 217.64,58.29 213.41,58.29 212.5,59.2 206.9,59.2 206.35,58.65 206.35,57.36 205.41,56.43 195.58,56.43 194.94,57.07 194.74,57.27 191.45,57.27 189.8,58.92 189.8,59.08 186.5,62.37 185.48,62.37 183.37,64.47 183.37,67.37 180.48,70.27 180.48,83.66 179.54,84.6 179.54,87.18 179.23,87.49 178.64,87.49 178.15,87.98 178.15,88.92 178.39,89.15 178.77,89.15 v1(179.19,88.73)
  IN4 w0.089: v1(259.09,60.06) 259.09,56.93 259.8,56.23 259.8,47.12 v1(259.4,46.72)
  BOTTOM w0.108: v2(258.77,46.1) v1(259.4,46.72) ; JIOR1.37 178.69,89.23 v1(179.19,88.73)
IOR_BD_ID1#: length 128.5
  TOP w0.108: R9500.2 181.42,83.17 v1(180.91,82.67) ; U37.A8 260.03,47.67 259.7,47.33 v1(259.4,47.33)
  IN1 w0.089: v1(259.4,47.33) 258.94,46.88 258.94,46.72 258.01,45.78 250.09,45.78 248.93,44.62 248.93,43.81 245.91,40.79 240.73,40.79 239.93,39.99 234.21,39.99 227.18,47.02 206.23,47.02 206.19,46.98 194.31,46.98 193.87,47.43 191.23,47.43 190.87,47.79 185.67,47.79 183.12,50.34 183.12,51.45 183.3,51.63 183.3,52.44 183.88,53.02 183.88,55.44 182.95,56.37 182.95,56.79 183.06,56.9 184.52,58.36 184.52,60.39 179.27,65.64 179.27,78.47 180.4,79.6 180.4,79.99 180.4,82.16 v1(180.91,82.67)
  BOTTOM w0.108: JIOR1.51 180.47,82.23 v1(180.91,82.67) ; v2(260.58,46.25) 260.13,46.25 259.9,46.48 259.9,46.83 v1(259.4,47.33)
IOR_HUB_EN#: length 131.2
  TOP w0.108: R9485.2 258.51,46.62 258.4,46.72 v1(258.38,46.72) ; v1(261.19,49.57) 261.19,49.57 261.28,49.48 U37.B11
  IN2 w0.089: v1(179.14,90.13) 179.72,89.55 179.72,84.7 181.34,83.07 181.34,71.71 183.58,69.48 183.58,64.52 185.52,62.57 186.55,62.57 189.97,59.15 189.97,58.99 191.52,57.44 194.81,57.44 195.65,56.6 205.34,56.6 206.17,57.44 206.17,58.72 206.82,59.37 212.57,59.37 213.48,58.46 217.57,58.46 218.65,59.54 223.51,59.54 226.48,62.52 228.49,62.52 228.78,62.23 238.86,62.23 239.09,62.46 239.09,62.63 240.02,63.56 241.72,63.56 245.04,60.24 251.59,60.24 252.03,59.81 v1(255.66,59.81)
  IN4 w0.089: v1(255.66,59.81) 257.85,57.62 257.85,51.86 258.63,51.08 258.63,49.24 257.98,48.58 257.98,47.12 v1(258.38,46.72)
  BOTTOM w0.108: v1(261.19,49.57) v2(260.14,48.52) 259.71,48.1 259.17,48.1 258.89,47.82 258.89,47.23 v1(258.38,46.72) ; v1(179.14,90.13) 178.74,89.73 JIOR1.36
IOR_LANPHY_ENABLE: length 128.6
  TOP w0.108: R9466.2 253.17,49.77 v1(253.43,49.52) 253.51,49.6 253.51,50.42 253.71,50.62 253.71,50.63 254.46,51.38 254.46,51.57 254.72,51.83 U37.A60
  IN2 w0.089: v1(253.68,60.44) 253.22,59.98 252.11,59.98 251.67,60.42 247.23,60.42 244.84,62.8 242.78,62.8 241.85,63.74 236.15,63.74 235.27,62.85 234.04,62.85 233.22,63.67 231.51,63.67 230.75,62.91 226.78,62.91 226.55,63.13 221.99,63.13 217.5,58.64 213.55,58.64 212.64,59.55 206.75,59.55 205.99,58.79 205.99,57.51 205.26,56.78 195.72,56.78 194.88,57.62 191.6,57.62 190.15,59.07 190.15,59.23 186.63,62.75 185.6,62.75 183.75,64.6 183.75,69.55 181.52,71.79 181.52,83.15 179.89,84.77 179.89,91.54 179.19,92.24 178.93,92.24 v1(178.53,92.65)
  IN4 w0.089: v1(253.68,60.44) 255.48,58.64 255.48,55.13 254.91,54.55 254.91,51.63 253.67,50.39 253.67,49.76 v1(253.43,49.52)
  BOTTOM w0.108: JIOR1.30 178.45,92.73 v1(178.53,92.65) ; v2(253.68,59.74) v1(253.68,60.44)
IOR_LANWAKEB#: length 4.4
  TOP w0.108: R9501.2 179.77,93.36 178.98,93.36 v2(178.85,93.23) 178.85,92.93 v1(179.14,92.65)
  BOTTOM w0.108: v1(179.14,92.65) 178.64,93.14 178.34,93.14 178.26,93.23 JIOR1.29
IRQ_SERIRQ: length 181.5
  TOP w0.108: v1(263.73,51.75) 264.14,51.34 264.43,51.34 264.69,51.08 U37.B21 ; v1(260.51,36.23) 260.37,36.38 U6202.17 ; U38.A28 240.14,58.38 v1(240.64,57.88)
  IN3 w0.089: v1(263.73,51.75) 263.28,51.75 262.21,52.83 257.54,52.83 257.39,52.98 252.81,52.98 251.32,54.47 250.39,54.47 249.23,55.63 247.69,55.63 247.15,56.17 242.34,56.17 v1(240.64,57.88) ; v1(149.16,77.08) 150.66,75.58 152.79,75.58 153.62,74.75 157.21,74.75 157.61,74.35 164.72,74.35 166.62,72.45 173.91,72.45 181.85,64.5 182.59,64.5 185.79,61.31 187.06,61.31 189.46,58.9 189.46,58.78 191.57,56.67 206.8,56.67 208.81,58.68 217.24,58.68 220.04,61.48 226.1,61.48 226.78,62.17 239.45,62.17 v1(239.73,62.45)
  IN4 w0.089: v1(263.73,51.75) 264.13,51.35 264.35,51.35 265.23,50.47 265.23,46.21 264.13,45.1 263.8,45.1 263.4,44.7 263.4,44.07 261.48,42.16 261.48,39.06 261.17,38.75 261.17,37.53 260.51,36.87 v1(260.51,36.23) ; v1(240.64,57.88) 239.22,59.3 239.22,61.42 239.71,61.92 239.71,62.45 v1(239.73,62.45)
  BOTTOM w0.076: 141.16,78.36 140.98,78.18 138.78,78.18 138.39,77.78 134.96,77.78 134.47,78.28 132.53,78.28 131.98,78.83 131.98,78.83 131.29,79.53 131.29,80.71 131.4,80.82 131.4,80.93 UC1.AY11
  BOTTOM w0.108: v1(263.73,51.75) 263.73,52.09 v2(263.05,52.77) ; 141.16,78.36 141.96,78.36 143.02,77.3 148.8,77.3 148.8,77.31 148.93,77.31 v1(149.16,77.08) 149.38,77.3 149.38,77.88 150.73,79.24 RC345.1
IRRX2: length 9.6
  TOP w0.108: RP4806.1 v1(263.23,23.74) ; U6202.30 258.94,29.88 v1(258.94,29.88)
  BOTTOM w0.108: v1(263.23,23.74) 262.6,24.37 v2(262.6,24.55) 262.6,26.3 259.02,29.88 v1(258.94,29.88)
ISH_I2C2_SCL: length 96.3
  TOP w0.108: v1(100.13,120.93) 100.37,120.69 100.37,120.36 101.58,119.14 101.58,117.28 99.29,114.99 99.29,112.88 98.41,112 97.64,112 96.88,111.24 96.88,110.65 95.58,109.35 95.58,104.94 93.16,102.52 91.36,102.52 90.92,102.07 90.23,102.07 89.35,101.19 v2(88.49,101.19) 88.2,100.9 87.7,100.9 v1(87.52,101.08)
  IN3 w0.089: v1(100.13,120.93) 100.32,121.12 100.32,122.82 101.03,123.53 101.03,125.72 100.57,126.18 100.57,130.04 99.48,131.13 v1(97.19,131.13)
  IN4 w0.089: v3(130.57,89.95) 130.39,90.13 127.24,90.13 127,89.9 125.5,89.9 124.27,89.9 123.94,90.23 123.94,94.76 123.11,95.58 120.8,95.58 119.89,94.67 119.12,94.67 118.52,95.26 114.77,95.26 114.41,94.9 112.74,94.9 112.21,95.43 112.21,95.79 111.77,96.23 102.96,96.23 102.51,96.68 100.62,96.68 100.24,97.07 96.13,97.07 93.15,100.05 89.59,100.05 88.75,100.89 87.71,100.89 v1(87.52,101.08)
  BOTTOM w0.108: v1(97.19,131.13) 97.32,131 R218.1 ; UC1.AD12 131.08,90.46 v3(130.57,89.95)
ISH_I2C2_SCL_R: length 3
  BOTTOM w0.108: JWWAN1.40 99.46,131.33 98.92,131.86 R216.1 R218.2
ISH_I2C2_SDA: length 100.2
  TOP w0.108: v1(100.75,120.94) 100.62,120.82 100.62,120.43 101.81,119.24 101.81,117.18 99.55,114.92 99.55,112.81 98.49,111.75 97.75,111.75 97.12,111.11 97.12,110.55 95.82,109.26 95.82,104.84 93.26,102.28 91.46,102.28 v2(90.82,101.64) 90.13,101.64 89.42,100.93 88.92,100.93 88.66,100.67 87.72,100.67 v1(87.52,100.47)
  IN3 w0.089: v1(97.19,131.81) 97.66,131.34 99.57,131.34 100.79,130.12 100.79,126.26 101.24,125.81 101.24,123.44 100.54,122.74 100.54,121.15 v1(100.75,120.94)
  IN4 w0.089: v3(131.14,89.93) 130.79,89.57 130.34,89.57 129.96,89.95 127.31,89.95 127.08,89.72 124.2,89.72 123.76,90.16 123.76,94.68 123.04,95.4 120.88,95.4 119.96,94.49 119.05,94.49 118.45,95.09 114.84,95.09 114.48,94.72 112.66,94.72 112.03,95.36 112.03,95.72 111.7,96.05 102.88,96.05 102.43,96.5 100.55,96.5 100.16,96.89 96,96.89 93.06,99.83 89.5,99.83 88.66,100.67 87.73,100.67 v1(87.52,100.47)
  BOTTOM w0.076: 131.15,89.93 v3(131.14,89.93)
  BOTTOM w0.108: 131.15,89.93 131.33,89.93 UC1.AD11 ; v1(97.19,131.81) 97.19,132.86 97.37,133.03 98.41,133.03 R219.1
