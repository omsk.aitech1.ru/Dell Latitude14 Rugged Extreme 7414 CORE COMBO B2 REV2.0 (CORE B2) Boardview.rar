# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BTOB_60P_20_F_SAM
  round 1.016 hole 1.016 unplated: (-10.06,0) (10.066,0)
  rect 0.279x2.286 smd: 1(-7.25,-5.53) 2(-7.25,0.198) 3(-6.75,-5.53) 4(-6.75,0.198) 5(-6.25,-5.53) 6(-6.25,0.198) 7(-5.75,-5.53) 8(-5.75,0.198) 9(-5.25,-5.53) 10(-5.25,0.198) 11(-4.75,-5.53) 12(-4.75,0.198) 13(-4.25,-5.53) 14(-4.25,0.198) 15(-3.75,-5.53) 16(-3.75,0.198) 17(-3.25,-5.53) 18(-3.25,0.198) 19(-2.75,-5.53) 20(-2.75,0.198) 21(-2.25,-5.53) 22(-2.25,0.198) 23(-1.75,-5.53) 24(-1.75,0.198) 25(-1.25,-5.53) 26(-1.25,0.198) 27(-0.75,-5.53) 28(-0.75,0.198) 29(-0.25,-5.53) 30(-0.25,0.198) 31(0.25,-5.53) 32(0.25,0.198) 33(0.75,-5.53) 34(0.75,0.198) 35(1.25,-5.53) 36(1.25,0.198) 37(1.75,-5.53) 38(1.75,0.198) 39(2.25,-5.53) 40(2.25,0.198) 41(2.75,-5.53) 42(2.75,0.198) 43(3.25,-5.53) 44(3.25,0.198) 45(3.75,-5.53) 46(3.75,0.198) 47(4.25,-5.53) 48(4.25,0.198) 49(4.75,-5.53) 50(4.75,0.198) 51(5.25,-5.53) 52(5.25,0.198) 53(5.75,-5.53) 54(5.75,0.198) 55(6.25,-5.53) 56(6.25,0.198) 57(6.75,-5.53) 58(6.75,0.198) 59(7.25,-5.53) 60(7.25,0.198)
C0201
  rect 0.305x0.305 smd: 1(-0.254,0) 2(0.254,0)
C0402
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
C0603
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
C0805
  rect 1.27x1.27 smd: 1(-1.041,0) 2(1.041,0)
C0805_H57
  rect 1.27x1.27 smd: 1(-1.041,0) 2(1.041,0)
C1210
  rect 1.448x2.489 smd: 1(1.722,0) 2(-1.722,0)
C1808
  rect 2.184x2.007 smd: 1(1.886,0) 2(-1.886,0)
C3528_H79
  rect 1.905x2.21 smd: 1(1.816,0) 2(-1.816,0)
C7343
  rect 2.388x2.388 smd: 1(3.45,0) 2(-3.45,0)
C7343_H63
  rect 2.388x2.388 smd: 1(3.45,0) 2(-3.45,0)
C7343D_H75
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
CHOKE_4P_79X47_FUKUI
  rect 0.889x0.356 smd: 1(-0.85,-0.425) 2(0.85,-0.425) 3(0.85,0.425) 4(-0.85,0.425)
CHOKE_4P_79X47_FUKUI_H39
  rect 0.889x0.356 smd: 1(-0.85,-0.425) 2(0.85,-0.425) 3(0.85,0.425) 4(-0.85,0.425)
DDR4_260P_4HOLD_STD_DRAG
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 2.007x3.505 smd: 263(-37.75,12) 264(37.75,8)
DDR4_260P_20_4H_REV_DNT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 263(-33.8,12) 264(33.8,12)
DFN_6P_26_79X79_PAD_TI
  rect 0.381x0.457 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(0,0.925) 6(-0.65,0.925)
  rect 1.702x0.965 smd: 7(0,0)
DFN_7P_50_197X236
  rect 0.66x0.635 smd: 1(-1.905,-2.825) 5(1.905,2.845) 6(0.635,2.845) 7(-0.635,2.845) 8(-1.905,2.845)
  custom 0.485x0.485 smd: 2(-0.005,-2.172)
  rect 3.988x2.667 smd: 9(0,0.793)
DFN_8P_20_S79_P_INT_H39_1V
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.6x0.864 smd: 9(0,0)
  round 0.61 hole 0.305: 10(0,0)
DFN_8P_20_S79_P_SIL_H26_4V
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.702x0.864 smd: 9(0,0)
  round 0.457 hole 0.254: 10(-0.486,0.162) 11(0.162,0.162) 12(-0.162,-0.162) 13(0.486,-0.162)
DFN_8P_20_S79_PAD_INTER_H31
  rect 0.279x0.508 smd: 1(-0.75,-0.9) 2(-0.25,-0.9) 3(0.25,-0.9) 4(0.75,-0.9) 5(0.75,0.9) 6(0.25,0.9) 7(-0.25,0.9) 8(-0.75,0.9)
  rect 1.6x0.889 smd: 9(0,0)
DFN_8P_26_118X118_P_TI
  rect 0.381x0.61 smd: 1(-0.975,-1.35) 2(-0.325,-1.35) 3(0.325,-1.35) 4(0.975,-1.35) 5(0.975,1.35)
  rect 1.676x0.61 smd: 6(-0.325,1.35)
  rect 2.489x1.651 smd: 9(0,0)
DFN_9P_34_39X98_AMA
  rect 0.673x0.203 smd: 1(-0.438,1) 5(-0.438,-1) 6(0.438,-1) 10(0.438,1)
  rect 0.673x0.191 smd: 2(-0.438,0.5) 4(-0.438,-0.5) 7(0.438,-0.5) 9(0.438,0.5)
  rect 1.549x0.394 smd: 3(0,0)
DFN_10P_20_98X39_NXP
  rect 0.279x0.533 smd: 1(-1,-0.375) 2(-0.5,-0.375) 3(0,-0.375) 4(0.5,-0.375) 5(1,-0.375) 6(1,0.375) 7(0.5,0.375) 8(0,0.375) 9(-0.5,0.375) 10(-1,0.375)
DRQFN_132P_20_S433_PAD_9V
  rect 0.279x0.559 smd: A1(-3.75,-5.375) A2(-3.25,-5.375) A3(-2.75,-5.375) A4(-2.25,-5.375) A5(-1.75,-5.375) A6(-1.25,-5.375) A7(-0.75,-5.375) A8(-0.25,-5.375) A9(0.25,-5.375) A10(0.75,-5.375) A11(1.25,-5.375) A12(1.75,-5.375) A13(2.25,-5.375) A14(2.75,-5.375) A15(3.25,-5.375) A16(3.75,-5.375) A33(3.75,5.375) A34(3.25,5.375) A35(2.75,5.375) A36(2.25,5.375) A37(1.75,5.375) A38(1.25,5.375) A39(0.75,5.375) A40(0.25,5.375) A41(-0.25,5.375) A42(-0.75,5.375) A43(-1.25,5.375) A44(-1.75,5.375) A45(-2.25,5.375) A46(-2.75,5.375) A47(-3.25,5.375) A48(-3.75,5.375)
  rect 0.559x0.279 smd: A17(5.375,-3.75) A18(5.375,-3.25) A19(5.375,-2.75) A20(5.375,-2.25) A21(5.375,-1.75) A22(5.375,-1.25) A23(5.375,-0.75) A24(5.375,-0.25) A25(5.375,0.25) A26(5.375,0.75) A27(5.375,1.25) A28(5.375,1.75) A29(5.375,2.25) A30(5.375,2.75) A31(5.375,3.25) A32(5.375,3.75) A49(-5.375,3.75) A50(-5.375,3.25) A51(-5.375,2.75) A52(-5.375,2.25) A53(-5.375,1.75) A54(-5.375,1.25) A55(-5.375,0.75) A56(-5.375,0.25) A57(-5.375,-0.25) A58(-5.375,-0.75) A59(-5.375,-1.25) A60(-5.375,-1.75) A61(-5.375,-2.25) A62(-5.375,-2.75) A63(-5.375,-3.25) A64(-5.375,-3.75)
  rect 0.279x0.406 smd: B1(-4,-4.65) B2(-3.5,-4.65) B3(-3,-4.65) B4(-2.5,-4.65) B5(-2,-4.65) B6(-1.5,-4.65) B7(-1,-4.65) B8(-0.5,-4.65) B9(0,-4.65) B10(0.5,-4.65) B11(1,-4.65) B12(1.5,-4.65) B13(2,-4.65) B14(2.5,-4.65) B15(3,-4.65) B16(3.5,-4.65) B17(4,-4.65) B35(4,4.65) B36(3.5,4.65) B37(3,4.65) B38(2.5,4.65) B39(2,4.65) B40(1.5,4.65) B41(1,4.65) B42(0.5,4.65) B43(0,4.65) B44(-0.5,4.65) B45(-1,4.65) B46(-1.5,4.65) B47(-2,4.65) B48(-2.5,4.65) B49(-3,4.65) B50(-3.5,4.65) B51(-4,4.65)
  rect 0.406x0.279 smd: B18(4.65,-4) B19(4.65,-3.5) B20(4.65,-3) B21(4.65,-2.5) B22(4.65,-2) B23(4.65,-1.5) B24(4.65,-1) B25(4.65,-0.5) B26(4.65,0) B27(4.65,0.5) B28(4.65,1) B29(4.65,1.5) B30(4.65,2) B31(4.65,2.5) B32(4.65,3) B33(4.65,3.5) B34(4.65,4) B52(-4.65,4) B53(-4.65,3.5) B54(-4.65,3) B55(-4.65,2.5) B56(-4.65,2) B57(-4.65,1.5) B58(-4.65,1) B59(-4.65,0.5) B60(-4.65,0) B61(-4.65,-0.5) B62(-4.65,-1) B63(-4.65,-1.5) B64(-4.65,-2) B65(-4.65,-2.5) B66(-4.65,-3) B67(-4.65,-3.5) B68(-4.65,-4)
  rect 5.105x5.105 smd: C1(0,0)
  round 0.61 hole 0.305: C2(-1.702,1.702) C3(0,1.702) C4(1.702,1.702) C5(-1.702,0) C6(0,0) C7(1.702,0) C8(-1.702,-1.702) C9(0,-1.702) C10(1.702,-1.702)
ESD_2P_33_39X24_H17
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
ESD_2P_33_39X24_H20
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
ESD_2P_33_39X24_H24
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
FPC_12P_20_2HOD_RA_ACE_B
  rect 0.292x1.295 smd: 1(-2.75,2.8) 2(-2.25,2.8) 3(-1.75,2.8) 4(-1.25,2.8) 5(-0.75,2.8) 6(-0.25,2.8) 7(0.25,2.8) 8(0.75,2.8) 9(1.25,2.8) 10(1.75,2.8) 11(2.25,2.8) 12(2.75,2.8)
  rect 1.803x1.397 smd: 13(-4.4,0) 14(4.4,0)
FPC_18P_20_2HLD_ACES
  rect 0.292x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
FPC_18P_39_2HOLD_ACE
  rect 0.61x1.499 smd: 1(-4.25,-1.5) 2(-3.75,1.5) 3(-3.25,-1.5) 4(-2.75,1.5) 5(-2.25,-1.5) 6(-1.75,1.5) 7(-1.25,-1.5) 8(-0.75,1.5) 9(-0.25,-1.5) 10(0.25,1.5) 11(0.75,-1.5) 12(1.25,1.5) 13(1.75,-1.5) 14(2.25,1.5) 15(2.75,-1.5) 16(3.25,1.5) 17(3.75,-1.5) 18(4.25,1.5)
  rect 0.787x1.499 smd: 19(-5.25,-1.5) 20(-5.25,1.5) 21(5.25,-1.5) 22(5.25,1.5)
FPC_26P_39_4HOLD_CVI
  rect 0.61x1.499 smd: 1(-6.25,-1.4) 2(-5.75,1.4) 3(-5.25,-1.4) 4(-4.75,1.4) 5(-4.25,-1.4) 6(-3.75,1.4) 7(-3.25,-1.4) 8(-2.75,1.4) 9(-2.25,-1.4) 10(-1.75,1.4) 11(-1.25,-1.4) 12(-0.75,1.4) 13(-0.25,-1.4) 14(0.25,1.4) 15(0.75,-1.4) 16(1.25,1.4) 17(1.75,-1.4) 18(2.25,1.4) 19(2.75,-1.4) 20(3.25,1.4) 21(3.75,-1.4) 22(4.25,1.4) 23(4.75,-1.4) 24(5.25,1.4) 25(5.75,-1.4) 26(6.25,1.4)
  rect 0.787x1.499 smd: 27(-7.25,-1.4) 28(-7.25,1.4) 29(7.25,-1.4) 30(7.25,1.4)
FPC_40P_20_2HD_RA_ENTERY
  rect 0.305x0.787 smd: 1(-9.75,2.5) 2(-9.25,2.5) 3(-8.75,2.5) 4(-8.25,2.5) 5(-7.75,2.5) 6(-7.25,2.5) 7(-6.75,2.5) 8(-6.25,2.5) 9(-5.75,2.5) 10(-5.25,2.5) 11(-4.75,2.5) 12(-4.25,2.5) 13(-3.75,2.5) 14(-3.25,2.5) 15(-2.75,2.5) 16(-2.25,2.5) 17(-1.75,2.5) 18(-1.25,2.5) 19(-0.75,2.5) 20(-0.25,2.5) 21(0.25,2.5) 22(0.75,2.5) 23(1.25,2.5) 24(1.75,2.5) 25(2.25,2.5) 26(2.75,2.5) 27(3.25,2.5) 28(3.75,2.5) 29(4.25,2.5) 30(4.75,2.5) 31(5.25,2.5) 32(5.75,2.5) 33(6.25,2.5) 34(6.75,2.5) 35(7.25,2.5) 36(7.75,2.5) 37(8.25,2.5) 38(8.75,2.5) 39(9.25,2.5) 40(9.75,2.5)
  rect 0.406x0.787 smd: 41(-10.75,0) 42(10.75,0)
FPC_56P_20_2HD_ACES
  rect 0.305x0.991 smd: 1(-13.75,3.3) 2(-13.25,3.3) 3(-12.75,3.3) 4(-12.25,3.3) 5(-11.75,3.3) 6(-11.25,3.3) 7(-10.75,3.3) 8(-10.25,3.3) 9(-9.75,3.3) 10(-9.25,3.3) 11(-8.75,3.3) 12(-8.25,3.3) 13(-7.75,3.3) 14(-7.25,3.3) 15(-6.75,3.3) 16(-6.25,3.3) 17(-5.75,3.3) 18(-5.25,3.3) 19(-4.75,3.3) 20(-4.25,3.3) 21(-3.75,3.3) 22(-3.25,3.3) 23(-2.75,3.3) 24(-2.25,3.3) 25(-1.75,3.3) 26(-1.25,3.3) 27(-0.75,3.3) 28(-0.25,3.3) 29(0.25,3.3) 30(0.75,3.3) 31(1.25,3.3) 32(1.75,3.3) 33(2.25,3.3) 34(2.75,3.3) 35(3.25,3.3) 36(3.75,3.3) 37(4.25,3.3) 38(4.75,3.3) 39(5.25,3.3) 40(5.75,3.3) 41(6.25,3.3) 42(6.75,3.3) 43(7.25,3.3) 44(7.75,3.3) 45(8.25,3.3) 46(8.75,3.3) 47(9.25,3.3) 48(9.75,3.3) 49(10.25,3.3) 50(10.75,3.3) 51(11.25,3.3) 52(11.75,3.3) 53(12.25,3.3) 54(12.75,3.3) 55(13.25,3.3) 56(13.75,3.3)
  rect 0.787x2.007 smd: 57(-15.45,0) 58(15.45,0)
HOLE_C59D59N
  round 1.499 hole 1.499 unplated: (0,0)
HOLE_O59X108DO59X108N
  oval 1.499x2.743 hole 1.499 unplated: (0,0)
HOLE_O335X217DO335X217N
  oval 8.509x5.512 hole 5.512 unplated: (0,0)
INDUCTO_2P_98X79_CYNTEC_H47
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
INDUCTOR_2P_79X63_CY
  rect 0.66x1.702 smd: 1(-0.886,0) 2(0.886,0)
INDUCTOR_2P_150X150_CYN
  rect 0.991x3.81 smd: 1(-1.4,0) 2(1.4,0)
INDUCTOR_2P_197X185
  rect 2.007x2.489 smd: 1(-2.5,0) 2(2.5,0)
INDUCTOR_2P_213X205
  rect 1.905x2.489 smd: 1(-2.047,0) 2(2.047,0)
INDUCTOR_2P_278X260_H118
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
INDUCTOR_2P_287X260
  rect 2.845x2.997 smd: 1(-3.025,0) 2(3.025,0)
L0603
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
L0603_POLAR
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
L0805_H41
  rect 1.27x1.27 smd: 1(-1.041,0) 2(1.041,0)
L0806_H39
  rect 1.499x1.6 smd: 1(-1.15,0) 2(1.15,0)
L1008_TAIYO_H47
  rect 1.245x2.007 smd: 1(-1.267,0) 2(1.267,0)
LAN_JACK_13P_2H_ALL_S_LF5
  round 1.346 hole 0.762: 1(-3.57,9.5) 2(-2.55,10.6) 3(-1.53,9.5) 4(-0.51,10.6) 5(0.51,9.5) 6(1.53,10.6) 7(2.55,9.5) 8(3.57,10.6)
  oval 1.651x3.708 hole 0.457: 9(-10.05,0) 10(10.05,0)
  round 1.549 hole 0.965: A1(-6.865,13.1) A2(-5.72,11.1) A3(-4.575,13.1) B1(4.575,13.1) B2(6.865,13.1)
LGA_12P_20_79X79_ST
  rect 0.254x0.279 smd: 1(-0.75,-0.763) 2(-0.25,-0.763) 3(0.25,-0.763) 4(0.75,-0.763) 7(0.75,0.763) 8(0.25,0.763) 9(-0.25,0.763) 10(-0.75,0.763)
  rect 0.279x0.254 smd: 5(0.763,-0.25) 6(0.763,0.25) 11(-0.763,0.25) 12(-0.763,-0.25)
NB_AUDIO_JACK_8P_2HOLD_RA
  round 1.245 hole 1.245 unplated: (0,-3) (0,3)
  oval 0.914x1.702 hole 0.508: 1(3.8,6.1)
  oval 0.864x1.651 hole 0.457: 2(-3.7,-1.5) 3(3.7,-3.8) 4(-2.7,-3.6) 5(-2.2,6.1) 6(-3.8,6.1) 7(4.6,0.5) 8(-4.6,1.5)
NB_BTOB_80P_20_2HOLD_F_SAM
  oval 1.245x1.473 hole 1.245 unplated: (-11,0)
  round 1.473 hole 1.473 unplated: (11,0)
  rect 0.305x1.499 smd: 1(9.75,-1) 2(9.75,2.7) 3(9.25,-1) 4(9.25,2.7) 5(8.75,-1) 6(8.75,2.7) 7(8.25,-1) 8(8.25,2.7) 9(7.75,-1) 10(7.75,2.7) 11(7.25,-1) 12(7.25,2.7) 13(6.75,-1) 14(6.75,2.7) 15(6.25,-1) 16(6.25,2.7) 17(5.75,-1) 18(5.75,2.7) 19(5.25,-1) 20(5.25,2.7) 21(4.75,-1) 22(4.75,2.7) 23(4.25,-1) 24(4.25,2.7) 25(3.75,-1) 26(3.75,2.7) 27(3.25,-1) 28(3.25,2.7) 29(2.75,-1) 30(2.75,2.7) 31(2.25,-1) 32(2.25,2.7) 33(1.75,-1) 34(1.75,2.7) 35(1.25,-1) 36(1.25,2.7) 37(0.75,-1) 38(0.75,2.7) 39(0.25,-1) 40(0.25,2.7) 41(-0.25,-1) 42(-0.25,2.7) 43(-0.75,-1) 44(-0.75,2.7) 45(-1.25,-1) 46(-1.25,2.7) 47(-1.75,-1) 48(-1.75,2.7) 49(-2.25,-1) 50(-2.25,2.7) 51(-2.75,-1) 52(-2.75,2.7) 53(-3.25,-1) 54(-3.25,2.7) 55(-3.75,-1) 56(-3.75,2.7) 57(-4.25,-1) 58(-4.25,2.7) 59(-4.75,-1) 60(-4.75,2.7) 61(-5.25,-1) 62(-5.25,2.7) 63(-5.75,-1) 64(-5.75,2.7) 65(-6.25,-1) 66(-6.25,2.7) 67(-6.75,-1) 68(-6.75,2.7) 69(-7.25,-1) 70(-7.25,2.7) 71(-7.75,-1) 72(-7.75,2.7) 73(-8.25,-1) 74(-8.25,2.7) 75(-8.75,-1) 76(-8.75,2.7) 77(-9.25,-1) 78(-9.25,2.7) 79(-9.75,-1) 80(-9.75,2.7)
NB_C0402_H22_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_C0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_C0603_H34_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_C0603_H35_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_C0603_H39_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_C0805_H55_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
NB_C3528_H79
  rect 1.905x2.21 smd: 1(1.816,0) 2(-1.816,0)
NB_C7343D_H79
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
NB_D_SUB_9P_2HD_M_CON_LF2
  rect 1.194x1.194 hole 0.787: 1(5.555,-3.16)
  round 1.194 hole 0.787: 2(2.78,-3.16) 3(0.005,-3.16) 4(-2.77,-3.16) 5(-5.545,-3.16) 6(4.167,-3.16) 7(1.392,-3.16) 8(-1.383,-3.16) 9(-4.157,-3.16)
  oval 1.245x3.073 hole 0.66: 10(14.995,0) 11(-14.995,0)
NB_D_SUB_15P_2HD_SYN_LF2
  oval 1.016x1.219 hole 0.711: 1(-4.58,-3.2) 2(-2.29,-3.2) 3(0,-3.2) 4(2.29,-3.2) 5(4.58,-3.2) 6(-5.725,-3.2) 7(-3.435,-3.2) 8(-1.145,-3.2) 9(1.145,-3.2) 10(3.435,-3.2)
  round 1.295 hole 0.711: 11(-4.58,-1.7) 12(-2.29,-1.7) 13(0,-1.7) 14(2.29,-1.7) 15(4.58,-1.7)
  oval 1.372x3.251 hole 0.61: 16(-14.995,0) 17(14.995,0)
NB_FPC_6P_20_2HD_RA_ACES_B
  rect 0.305x1.295 smd: 1(-1.25,2.8) 2(-0.75,2.8) 3(-0.25,2.8) 4(0.25,2.8) 5(0.75,2.8) 6(1.25,2.8)
  rect 1.803x1.397 smd: 7(-2.9,0) 8(2.9,0)
NB_FPC_8P_20_2HD_RA_ACES_B
  rect 0.305x1.295 smd: 1(-1.75,2.8) 2(-1.25,2.8) 3(-0.75,2.8) 4(-0.25,2.8) 5(0.25,2.8) 6(0.75,2.8) 7(1.25,2.8) 8(1.75,2.8)
  rect 1.803x1.397 smd: 9(-3.4,0) 10(3.4,0)
NB_FPC_10P_20_2HD_RA_ACS_B
  rect 0.305x1.295 smd: 1(-2.25,2.8) 2(-1.75,2.8) 3(-1.25,2.8) 4(-0.75,2.8) 5(-0.25,2.8) 6(0.25,2.8) 7(0.75,2.8) 8(1.25,2.8) 9(1.75,2.8) 10(2.25,2.8)
  rect 1.803x1.397 smd: 11(-3.9,0) 12(3.9,0)
NB_FPC_10P_20_2HOLD_RA_TE
  rect 0.305x1.295 smd: 1(-2.25,3.3) 2(-1.75,3.3) 3(-1.25,3.3) 4(-0.75,3.3) 5(-0.25,3.3) 6(0.25,3.3) 7(0.75,3.3) 8(1.25,3.3) 9(1.75,3.3) 10(2.25,3.3)
  rect 2.489x1.905 smd: 11(-4.4,0) 12(4.4,0)
NB_FPC_16P_20_2HOLD_RA_AC_B
  rect 0.292x1.295 smd: 1(-3.75,2.8) 2(-3.25,2.8) 3(-2.75,2.8) 4(-2.25,2.8) 5(-1.75,2.8) 6(-1.25,2.8) 7(-0.75,2.8) 8(-0.25,2.8) 9(0.25,2.8) 10(0.75,2.8) 11(1.25,2.8) 12(1.75,2.8) 13(2.25,2.8) 14(2.75,2.8) 15(3.25,2.8) 16(3.75,2.8)
  rect 1.803x1.397 smd: 17(-5.4,0) 18(5.4,0)
NB_FPC_18P_20_2HOLD_ACE_B
  rect 0.305x0.889 smd: 1(-4.25,3.05) 2(-3.75,3.05) 3(-3.25,3.05) 4(-2.75,3.05) 5(-2.25,3.05) 6(-1.75,3.05) 7(-1.25,3.05) 8(-0.75,3.05) 9(-0.25,3.05) 10(0.25,3.05) 11(0.75,3.05) 12(1.25,3.05) 13(1.75,3.05) 14(2.25,3.05) 15(2.75,3.05) 16(3.25,3.05) 17(3.75,3.05) 18(4.25,3.05)
  rect 0.991x2.007 smd: 19(-6.35,0) 20(6.35,0)
NB_FPC_38P_20_2HD_RA_ACES_B
  rect 0.305x1.092 smd: 1(-9.25,2.15) 2(-8.75,2.15) 3(-8.25,2.15) 4(-7.75,2.15) 5(-7.25,2.15) 6(-6.75,2.15) 7(-6.25,2.15) 8(-5.75,2.15) 9(-5.25,2.15) 10(-4.75,2.15) 11(-4.25,2.15) 12(-3.75,2.15) 13(-3.25,2.15) 14(-2.75,2.15) 15(-2.25,2.15) 16(-1.75,2.15) 17(-1.25,2.15) 18(-0.75,2.15) 19(-0.25,2.15) 20(0.25,2.15) 21(0.75,2.15) 22(1.25,2.15) 23(1.75,2.15) 24(2.25,2.15) 25(2.75,2.15) 26(3.25,2.15) 27(3.75,2.15) 28(4.25,2.15) 29(4.75,2.15) 30(5.25,2.15) 31(5.75,2.15) 32(6.25,2.15) 33(6.75,2.15) 34(7.25,2.15) 35(7.75,2.15) 36(8.25,2.15) 37(8.75,2.15) 38(9.25,2.15)
  rect 2.21x3.2 smd: 39(-11.23,0) 40(11.23,0)
NB_H_C217D91_116_P2_S
  round 2.819 hole 2.311: 1(0,0)
NB_H_C217D98_P2_S
  round 2.997 hole 2.489: 1(0,0)
NB_H_C287D110_P2_S
  round 3.302 hole 2.794: 1(0,0)
NB_H_C287D177_P2_S
  round 5.004 hole 4.496: 1(0,0)
NB_H_CB256D181_P2_S
  round 5.105 hole 4.597: 1(0,0)
NB_HDMI_19P_4HOLD_RA_LF2
  round 0.787 hole 0.533: 1(-4.5,5.32) 2(-4,6.87) 3(-3.5,5.32) 4(-3,6.87) 5(-2.5,5.32) 6(-2,6.87) 7(-1.5,5.32) 8(-1,6.87) 9(-0.5,5.32) 10(0,6.87) 11(0.5,5.32) 12(1,6.87) 13(1.5,5.32) 14(2,6.87) 15(2.5,5.32) 16(3,6.87) 17(3.5,5.32) 18(4,6.87) 19(4.5,5.32)
  oval 1.346x3.15 hole 0.762: 20(-9.15,0) 21(9.15,0) 22(-9.15,7.1) 23(9.15,7.1)
NB_INDUCTOR_2P_287X260_H94
  rect 2.845x2.997 smd: 1(-3.025,0) 2(3.025,0)
NB_INDUCTOR_2P_427X394
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
NB_L0402_H22_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_L0603_H37_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_MINI_PCI_67P_20_4HD_LO
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 12(-6.5,-1.725) 13(-6.25,4.725) 14(-6,-1.725) 15(-5.75,4.725) 16(-5.5,-1.725) 17(-5.25,4.725) 18(-5,-1.725) 19(-4.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 59(5.25,4.725) 60(5.5,-1.725) 61(5.75,4.725) 62(6,-1.725) 63(6.25,4.725) 64(6.5,-1.725) 65(6.75,4.725) 66(7,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NB_MINI_PCI_67P_20_4HD_LTS
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 59(5.25,4.725) 60(5.5,-1.725) 61(5.75,4.725) 62(6,-1.725) 63(6.25,4.725) 64(6.5,-1.725) 65(6.75,4.725) 66(7,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NB_NUT_C197BD122_LF2
  round 3.861 hole 3.099: 1(0,0)
NB_NUT_C217B176D146H264_LF2
  round 4.47 hole 3.708: 1(0,0)
NB_NUT_C236D150_H161_LF2
  round 5.994 hole 3.81: 1(0,0)
NB_NUT_CT197BD126_H358_LF2
  round 3.962 hole 3.2: 1(0,0)
NB_NUT_CT236B156D126_LF2
  round 3.962 hole 3.2: 1(0,0)
NB_OPEN2_5MIL_PT
  custom 0.181x0.181 smd: 1(0,-0.508) 2(0,0.508)
NB_PWR_FB_SHORT_PT
  rect 0.229x0.635 smd: 1(-0.203,0) 2(0.203,0)
NB_QFN_10P_18_118X118_SILE
  rect 0.254x0.61 smd: 1(-1.077,1.775) 2(-0.627,1.775) 3(-0.178,1.775) 4(0.273,1.775) 5(0.722,1.775) 6(1.172,1.775)
  rect 1.118x0.229 smd: 7(1.136,1.111)
  rect 0.864x2.007 smd: 8(1.009,-0.228)
  custom 0.47x0.47 smd: 9(0,0)
  rect 0.787x1.143 smd: 10(-0.959,0.179)
NB_R0402_H15_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_R0402_H16_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_R0402_H24_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_R0402_SHORT
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
NB_R0402_SHORT_25MIL
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
NB_R0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
NB_R0603_H22_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_R0603_H24_SMALL
  rect 0.559x0.889 smd: 1(-0.67,0) 2(0.67,0)
NB_R0805_H24_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
NB_SIM_8P_28_10HD_PLAS
  rect 0.508x0.889 smd: 1(2.055,-0.11) 2(0.655,-0.11) 3(-0.745,-0.11) 4(-2.145,-0.11) 5(1.355,-0.11) 6(-0.045,-0.11) 7(-1.445,-0.11) 8(-2.845,-0.11) 9(-3.545,-0.11) 10(2.755,-0.11)
  rect 1.092x1.118 smd: 11(5.51,0)
  rect 1.041x1.118 smd: 12(-4.625,0)
  rect 0.381x1.6 smd: 13(7.165,-2.4)
  rect 0.381x1.245 smd: 14(-7.165,-3.035)
  rect 0.381x1.499 smd: 15(7.165,-9.26) 16(-7.165,-9.26)
  rect 0.94x1.092 smd: 17(6.875,-15.06)
  rect 1.092x1.092 smd: 18(-6.8,-15.06)
NB_SOT23_S6_FITI_H57
  rect 0.61x1.118 smd: 1(-0.95,-1.451) 2(0,-1.451) 3(0.95,-1.451) 4(0.95,1.451) 5(0,1.451) 6(-0.95,1.451)
NB_TPC26T_68
  round 0.66 smd: 1(0,0)
NB_TPC28T_68
  round 0.711 smd: 1(0,0)
NB_USB_1X4P_4H_RA_FXC_LF2
  rect 1.473x1.473 hole 0.889: 1(3.5,3.35)
  round 1.473 hole 0.889: 2(1,3.35) 3(-1,3.35) 4(-3.5,3.35)
  rect 1.448x2.591 smd: 5(-7.775,-5.05) 6(7.775,-5.05)
  oval 1.295x2.286 hole 0.711: 7(-7.75,0) 8(7.75,0)
NB_USB_9P_4HLD_RA_FOX_LF2
  rect 1.295x1.295 hole 0.711: 1(3.5,8.7)
  round 1.295 hole 0.711: 2(1,8.7) 3(-1,8.7) 4(-3.5,8.7)
  round 0.991 hole 0.686: 5(-4,7.2) 6(-2,7.2) 7(0,7.2) 8(2,7.2) 9(4,7.2)
  oval 1.194x2.311 hole 0.787: 10(-6.4,7.8) 11(6.4,7.8)
  oval 1.143x3.15 hole 0.559: 12(-7.85,0) 13(7.85,0)
NB_WTOB_10P_24_2HLD_AES
  rect 0.406x0.61 smd: 1(2.7,1.375) 2(2.1,1.375) 3(1.5,1.375) 4(0.9,1.375) 5(0.3,1.375) 6(-0.3,1.375) 7(-0.9,1.375) 8(-1.5,1.375) 9(-2.1,1.375) 10(-2.7,1.375)
  rect 0.711x1.041 smd: 11(3.65,0) 12(-3.65,0)
OSC_4P_126X98_ECERA_H45
  rect 1.499x1.194 smd: 1(-1.06,-0.8) 2(1.06,-0.8) 3(1.06,0.8) 4(-1.06,0.8)
POLYSWITCH_2P_179X128_POLY
  rect 1.397x3.15 smd: 1(-2.425,0) 2(2.425,0)
POWER33_5P
  rect 0.432x0.711 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.538x0.538 smd: 5(0,0)
POWERDI5_3P_157X256
  rect 1.397x0.787 smd: 1(-0.9,-3.87) 2(0.9,-3.87)
  rect 3.607x4.699 smd: 3(0,0)
POWERPAIR_8P_2PAD_VISHAY
  rect 0.457x0.457 smd: 1(-0.975,-1.386) 2(-0.325,-1.386) 3(0.325,-1.386) 4(0.975,-1.386) 5(0.975,1.386) 6(0.325,1.386) 7(-0.325,1.386) 8(-0.975,1.386)
  rect 2.438x1.041 smd: 9(0,0.434)
  rect 2.438x0.559 smd: 10(0,-0.671)
QFN_14P_20_118X98_PAD
  rect 0.61x0.279 smd: 1(-1.35,-0.25) 7(1.35,-0.25) 8(1.35,0.25) 14(-1.35,0.25)
  rect 0.279x0.61 smd: 2(-1,-1.1) 3(-0.5,-1.1) 4(0,-1.1) 5(0.5,-1.1) 6(1,-1.1) 9(1,1.1) 10(0.5,1.1) 11(0,1.1) 12(-0.5,1.1) 13(-1,1.1)
  rect 1.651x1.143 smd: 15(0,0)
QFN_16P_20_S118_PAD_MACO_4V
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.676x1.676 smd: 17(0,0)
  round 0.61 hole 0.305: 18(-0.53,0.53) 19(0.53,0.53) 20(-0.53,-0.53) 21(0.53,-0.53)
QFN_16P_20_S118_PAD_RIC_H31
  rect 0.279x0.61 smd: 1(-0.75,-1.35) 2(-0.25,-1.35) 3(0.25,-1.35) 4(0.75,-1.35) 9(0.75,1.35) 10(0.25,1.35) 11(-0.25,1.35) 12(-0.75,1.35)
  rect 0.61x0.279 smd: 5(1.35,-0.75) 6(1.35,-0.25) 7(1.35,0.25) 8(1.35,0.75) 13(-1.35,0.75) 14(-1.35,0.25) 15(-1.35,-0.25) 16(-1.35,-0.75)
  rect 1.651x1.651 smd: 17(0,0)
QFN_20P_16_S118_PAD_H31_2V
  rect 0.229x0.61 smd: 1(-0.8,-1.35) 2(-0.4,-1.35) 3(0,-1.35) 4(0.4,-1.35) 5(0.8,-1.35) 11(0.8,1.35) 12(0.4,1.35) 13(0,1.35) 14(-0.4,1.35) 15(-0.8,1.35)
  rect 0.61x0.229 smd: 6(1.35,-0.8) 7(1.35,-0.4) 8(1.35,0) 9(1.35,0.4) 10(1.35,0.8) 16(-1.35,0.8) 17(-1.35,0.4) 18(-1.35,0) 19(-1.35,-0.4) 20(-1.35,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
  round 0.61 hole 0.305: 22(0.521,0.521) 23(-0.521,-0.521)
QFN_24P_20_S157_PAD_H31_4V
  rect 0.279x0.61 smd: 1(-1.25,-1.85) 2(-0.75,-1.85) 3(-0.25,-1.85) 4(0.25,-1.85) 5(0.75,-1.85) 6(1.25,-1.85) 13(1.25,1.85) 14(0.75,1.85) 15(0.25,1.85) 16(-0.25,1.85) 17(-0.75,1.85) 18(-1.25,1.85)
  rect 0.61x0.279 smd: 7(1.85,-1.25) 8(1.85,-0.75) 9(1.85,-0.25) 10(1.85,0.25) 11(1.85,0.75) 12(1.85,1.25) 19(-1.85,1.25) 20(-1.85,0.75) 21(-1.85,0.25) 22(-1.85,-0.25) 23(-1.85,-0.75) 24(-1.85,-1.25)
  rect 2.667x2.667 smd: 25(0,0)
  round 0.61 hole 0.305: 26(-1.029,1.029) 27(1.029,1.029) 28(1.029,-1.029) 29(-1.029,-1.029)
QFN_28P_16_157X157_PAD_4VIA
  rect 0.222x0.61 smd: 1(-1.2,-1.85) 2(-0.8,-1.85) 3(-0.4,-1.85) 4(0,-1.85) 5(0.4,-1.85) 6(0.8,-1.85) 7(1.2,-1.85) 15(1.2,1.85) 16(0.8,1.85) 17(0.4,1.85) 18(0,1.85) 19(-0.4,1.85) 20(-0.8,1.85) 21(-1.2,1.85)
  rect 0.61x0.222 smd: 8(1.85,-1.2) 9(1.85,-0.8) 10(1.85,-0.4) 11(1.85,0) 12(1.85,0.4) 13(1.85,0.8) 14(1.85,1.2) 22(-1.85,1.2) 23(-1.85,0.8) 24(-1.85,0.4) 25(-1.85,0) 26(-1.85,-0.4) 27(-1.85,-0.8) 28(-1.85,-1.2)
  rect 2.667x2.667 smd: 29(0,0)
  round 0.61 hole 0.305: 30(-1.029,1.029) 31(1.029,1.029) 32(-1.029,-1.029) 33(1.029,-1.029)
QFN_32P_20_197X197_PAD_RIC
  rect 0.279x0.61 smd: 1(-1.75,-2.35) 2(-1.25,-2.35) 3(-0.75,-2.35) 4(-0.25,-2.35) 5(0.25,-2.35) 6(0.75,-2.35) 7(1.25,-2.35) 8(1.75,-2.35) 17(1.75,2.35) 18(1.25,2.35) 19(0.75,2.35) 20(0.25,2.35) 21(-0.25,2.35) 22(-0.75,2.35) 23(-1.25,2.35) 24(-1.75,2.35)
  rect 0.61x0.279 smd: 9(2.35,-1.75) 10(2.35,-1.25) 11(2.35,-0.75) 12(2.35,-0.25) 13(2.35,0.25) 14(2.35,0.75) 15(2.35,1.25) 16(2.35,1.75) 25(-2.35,1.75) 26(-2.35,1.25) 27(-2.35,0.75) 28(-2.35,0.25) 29(-2.35,-0.25) 30(-2.35,-0.75) 31(-2.35,-1.25) 32(-2.35,-1.75)
  rect 3.658x3.658 smd: 33(0,0)
QFN_32P_20_S197_PAD_NAT
  rect 0.279x0.559 smd: 1(-1.75,-2.3) 8(1.75,-2.3) 17(1.75,2.3) 24(-1.75,2.3)
  rect 0.279x0.61 smd: 2(-1.25,-2.275) 3(-0.75,-2.275) 4(-0.25,-2.275) 5(0.25,-2.275) 6(0.75,-2.275) 7(1.25,-2.275) 18(1.25,2.275) 19(0.75,2.275) 20(0.25,2.275) 21(-0.25,2.275) 22(-0.75,2.275) 23(-1.25,2.275)
  rect 0.559x0.279 smd: 9(2.3,-1.75) 16(2.3,1.75) 25(-2.3,1.75) 32(-2.3,-1.75)
  rect 0.61x0.279 smd: 10(2.275,-1.25) 11(2.275,-0.75) 12(2.275,-0.25) 13(2.275,0.25) 14(2.275,0.75) 15(2.275,1.25) 26(-2.275,1.25) 27(-2.275,0.75) 28(-2.275,0.25) 29(-2.275,-0.25) 30(-2.275,-0.75) 31(-2.275,-1.25)
  rect 2.591x2.591 smd: 33(0,0)
QFN_36P_20_S236_PAD_SSC_8V
  rect 0.279x0.787 smd: 1(-2,-2.75) 2(-1.5,-2.75) 3(-1,-2.75) 4(-0.5,-2.75) 5(0,-2.75) 6(0.5,-2.75) 7(1,-2.75) 8(1.5,-2.75) 9(2,-2.75) 19(2,2.75) 20(1.5,2.75) 21(1,2.75) 22(0.5,2.75) 23(0,2.75) 24(-0.5,2.75) 25(-1,2.75) 26(-1.5,2.75) 27(-2,2.75)
  rect 0.787x0.279 smd: 10(2.75,-2) 11(2.75,-1.5) 12(2.75,-1) 13(2.75,-0.5) 14(2.75,0) 15(2.75,0.5) 16(2.75,1) 17(2.75,1.5) 18(2.75,2) 28(-2.75,2) 29(-2.75,1.5) 30(-2.75,1) 31(-2.75,0.5) 32(-2.75,0) 33(-2.75,-0.5) 34(-2.75,-1) 35(-2.75,-1.5) 36(-2.75,-2)
  rect 3.861x3.861 smd: 37(0,0)
  round 0.61 hole 0.305: 38(-1.625,1.625) 39(-1.118,1.625) 40(1.118,1.625) 41(1.625,1.625) 42(-1.625,-1.625) 43(-1.118,-1.625) 44(1.118,-1.625) 45(1.625,-1.625)
QFN_40P_16_197X197_PAD_8V
  rect 0.222x0.61 smd: 1(-1.8,-2.35) 2(-1.4,-2.35) 3(-1,-2.35) 4(-0.6,-2.35) 5(-0.2,-2.35) 6(0.2,-2.35) 7(0.6,-2.35) 8(1,-2.35) 9(1.4,-2.35) 10(1.8,-2.35) 21(1.8,2.35) 22(1.4,2.35) 23(1,2.35) 24(0.6,2.35) 25(0.2,2.35) 26(-0.2,2.35) 27(-0.6,2.35) 28(-1,2.35) 29(-1.4,2.35) 30(-1.8,2.35)
  rect 0.61x0.222 smd: 11(2.35,-1.8) 12(2.35,-1.4) 13(2.35,-1) 14(2.35,-0.6) 15(2.35,-0.2) 16(2.35,0.2) 17(2.35,0.6) 18(2.35,1) 19(2.35,1.4) 20(2.35,1.8) 31(-2.35,1.8) 32(-2.35,1.4) 33(-2.35,1) 34(-2.35,0.6) 35(-2.35,0.2) 36(-2.35,-0.2) 37(-2.35,-0.6) 38(-2.35,-1) 39(-2.35,-1.4) 40(-2.35,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.61 hole 0.305: 42(-1.499,1.499) 43(-0.991,1.499) 44(0.991,1.499) 45(1.499,1.499) 46(-1.499,-1.499) 47(-0.991,-1.499) 48(0.991,-1.499) 49(1.499,-1.499)
QFN_48P_16_S236_PAD_IE_4V
  rect 0.222x0.61 smd: 1(-2.2,-2.85) 2(-1.8,-2.85) 3(-1.4,-2.85) 4(-1,-2.85) 5(-0.6,-2.85) 6(-0.2,-2.85) 7(0.2,-2.85) 8(0.6,-2.85) 9(1,-2.85) 10(1.4,-2.85) 11(1.8,-2.85) 12(2.2,-2.85) 25(2.2,2.85) 26(1.8,2.85) 27(1.4,2.85) 28(1,2.85) 29(0.6,2.85) 30(0.2,2.85) 31(-0.2,2.85) 32(-0.6,2.85) 33(-1,2.85) 34(-1.4,2.85) 35(-1.8,2.85) 36(-2.2,2.85)
  rect 0.61x0.222 smd: 13(2.85,-2.2) 14(2.85,-1.8) 15(2.85,-1.4) 16(2.85,-1) 17(2.85,-0.6) 18(2.85,-0.2) 19(2.85,0.2) 20(2.85,0.6) 21(2.85,1) 22(2.85,1.4) 23(2.85,1.8) 24(2.85,2.2) 37(-2.85,2.2) 38(-2.85,1.8) 39(-2.85,1.4) 40(-2.85,1) 41(-2.85,0.6) 42(-2.85,0.2) 43(-2.85,-0.2) 44(-2.85,-0.6) 45(-2.85,-1) 46(-2.85,-1.4) 47(-2.85,-1.8) 48(-2.85,-2.2)
  rect 2.997x2.997 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-1.194,1.194) 51(1.194,1.194) 52(-1.194,-1.194) 53(1.194,-1.194)
QFN_48P_16_S236_PAD_REA_9V
  rect 0.222x0.61 smd: 1(-2.2,-2.85) 2(-1.8,-2.85) 3(-1.4,-2.85) 4(-1,-2.85) 5(-0.6,-2.85) 6(-0.2,-2.85) 7(0.2,-2.85) 8(0.6,-2.85) 9(1,-2.85) 10(1.4,-2.85) 11(1.8,-2.85) 12(2.2,-2.85) 25(2.2,2.85) 26(1.8,2.85) 27(1.4,2.85) 28(1,2.85) 29(0.6,2.85) 30(0.2,2.85) 31(-0.2,2.85) 32(-0.6,2.85) 33(-1,2.85) 34(-1.4,2.85) 35(-1.8,2.85) 36(-2.2,2.85)
  rect 0.61x0.222 smd: 13(2.85,-2.2) 14(2.85,-1.8) 15(2.85,-1.4) 16(2.85,-1) 17(2.85,-0.6) 18(2.85,-0.2) 19(2.85,0.2) 20(2.85,0.6) 21(2.85,1) 22(2.85,1.4) 23(2.85,1.8) 24(2.85,2.2) 37(-2.85,2.2) 38(-2.85,1.8) 39(-2.85,1.4) 40(-2.85,1) 41(-2.85,0.6) 42(-2.85,0.2) 43(-2.85,-0.2) 44(-2.85,-0.6) 45(-2.85,-1) 46(-2.85,-1.4) 47(-2.85,-1.8) 48(-2.85,-2.2)
  rect 4.648x4.648 smd: 49(0,0)
  round 0.61 hole 0.305: 50(-1.27,-1.27) 51(0,-1.27) 52(1.27,-1.27) 53(-1.27,0) 54(0,0) 55(1.27,0) 56(-1.27,1.27) 57(0,1.27) 58(1.27,1.27)
QFN_64P_20_S354_PAD_SL_8V
  rect 0.279x0.61 smd: 1(-3.75,-4.35) 2(-3.25,-4.35) 3(-2.75,-4.35) 4(-2.25,-4.35) 5(-1.75,-4.35) 6(-1.25,-4.35) 7(-0.75,-4.35) 8(-0.25,-4.35) 9(0.25,-4.35) 10(0.75,-4.35) 11(1.25,-4.35) 12(1.75,-4.35) 13(2.25,-4.35) 14(2.75,-4.35) 15(3.25,-4.35) 16(3.75,-4.35) 33(3.75,4.35) 34(3.25,4.35) 35(2.75,4.35) 36(2.25,4.35) 37(1.75,4.35) 38(1.25,4.35) 39(0.75,4.35) 40(0.25,4.35) 41(-0.25,4.35) 42(-0.75,4.35) 43(-1.25,4.35) 44(-1.75,4.35) 45(-2.25,4.35) 46(-2.75,4.35) 47(-3.25,4.35) 48(-3.75,4.35)
  rect 0.61x0.279 smd: 17(4.35,-3.75) 18(4.35,-3.25) 19(4.35,-2.75) 20(4.35,-2.25) 21(4.35,-1.75) 22(4.35,-1.25) 23(4.35,-0.75) 24(4.35,-0.25) 25(4.35,0.25) 26(4.35,0.75) 27(4.35,1.25) 28(4.35,1.75) 29(4.35,2.25) 30(4.35,2.75) 31(4.35,3.25) 32(4.35,3.75) 49(-4.35,3.75) 50(-4.35,3.25) 51(-4.35,2.75) 52(-4.35,2.25) 53(-4.35,1.75) 54(-4.35,1.25) 55(-4.35,0.75) 56(-4.35,0.25) 57(-4.35,-0.25) 58(-4.35,-0.75) 59(-4.35,-1.25) 60(-4.35,-1.75) 61(-4.35,-2.25) 62(-4.35,-2.75) 63(-4.35,-3.25) 64(-4.35,-3.75)
  rect 4.801x4.801 smd: 65(0,0)
  round 0.61 hole 0.305: 66(-2.095,2.095) 67(-1.587,2.095) 68(1.587,2.095) 69(2.095,2.095) 70(-2.095,-2.095) 71(-1.587,-2.095) 72(1.587,-2.095) 73(2.095,-2.095)
R0402
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
R0402_H16
  rect 0.635x0.635 smd: 1(-0.445,0) 2(0.445,0)
R0603_H24
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
R1206_H26
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
R1206_H33
  rect 1.041x1.6 smd: 1(-1.52,0) 2(1.52,0)
SC59_DI
  rect 1.118x0.61 smd: 1(1.451,-0.95) 2(1.451,0.95) 3(-1.451,0)
SC70_S5
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
SC70_S6
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
SOCKET_8P_50_LOTE
  rect 0.508x1.499 smd: 1(-1.905,-4) 2(-0.635,-4) 3(0.635,-4) 4(1.905,-4) 5(1.905,4) 6(0.635,4) 7(-0.635,4) 8(-1.905,4)
SOD323
  rect 1.092x0.508 smd: 1(1.3,0) 2(-1.3,0)
SOD523
  rect 0.635x0.508 smd: 1(0.82,0) 2(-0.82,0)
SOIC_8P_26_118X110_MAXI_H39
  rect 0.356x1.092 smd: 1(-0.975,-1.465) 2(-0.325,-1.465) 3(0.325,-1.465) 4(0.975,-1.465) 5(0.975,1.465) 6(0.325,1.465) 7(-0.325,1.465) 8(-0.975,1.465)
SOIC_8P_26_122X193
  rect 0.356x1.448 smd: 1(-0.975,-2.335) 2(-0.325,-2.335) 3(0.325,-2.335) 4(0.975,-2.335) 5(0.975,2.335) 6(0.325,2.335) 7(-0.325,2.335) 8(-0.975,2.335)
SOIC_8P_50_196X236
  rect 0.61x1.549 smd: 1(-1.905,-2.835) 2(-0.635,-2.835) 3(0.635,-2.835) 4(1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
SOIC_8P_50_197X236
  rect 0.61x1.524 smd: 1(-1.905,-2.857) 2(-0.635,-2.857) 3(0.635,-2.857) 4(1.905,-2.857) 5(1.905,2.858) 6(0.635,2.858) 7(-0.635,2.858) 8(-1.905,2.858)
SOIC_8P_50_197X236_IDT
  rect 0.635x1.549 smd: 1(-1.905,-2.835) 2(-0.635,-2.835) 3(0.635,-2.835) 4(1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
SOIC_8P_50_213X311
  rect 0.635x1.88 smd: 1(-1.905,-3.62) 2(-0.635,-3.62) 3(0.635,-3.62) 4(1.905,-3.62) 5(1.905,3.62) 6(0.635,3.62) 7(-0.635,3.62) 8(-1.905,3.62)
SOIC_28P_26_386X252
  rect 0.356x1.499 smd: 1(-4.225,-3.06) 2(-3.575,-3.06) 3(-2.925,-3.06) 4(-2.275,-3.06) 5(-1.625,-3.06) 6(-0.975,-3.06) 7(-0.325,-3.06) 8(0.325,-3.06) 9(0.975,-3.06) 10(1.625,-3.06) 11(2.275,-3.06) 12(2.925,-3.06) 13(3.575,-3.06) 14(4.225,-3.06) 15(4.225,3.06) 16(3.575,3.06) 17(2.925,3.06) 18(2.275,3.06) 19(1.625,3.06) 20(0.975,3.06) 21(0.325,3.06) 22(-0.325,3.06) 23(-0.975,3.06) 24(-1.625,3.06) 25(-2.275,3.06) 26(-2.925,3.06) 27(-3.575,3.06) 28(-4.225,3.06)
SON_14P_16_118X79_PAD
  rect 0.197x0.762 smd: 1(-1.2,-1.025) 2(-0.8,-1.025) 3(-0.4,-1.025) 4(0,-1.025) 5(0.4,-1.025) 6(0.8,-1.025) 7(1.2,-1.025) 8(1.2,1.025) 9(0.8,1.025) 10(0.4,1.025) 11(0,1.025) 12(-0.4,1.025) 13(-0.8,1.025) 14(-1.2,1.025)
  rect 2.591x0.864 smd: 15(0,0)
SOP_8P_SPE_FAIRCHILD
  rect 0.66x0.635 smd: 1(-1.905,-2.835) 5(1.905,2.835) 6(0.635,2.835) 7(-0.635,2.835) 8(-1.905,2.835)
  custom 0.485x0.485 smd: 2(0,-2.18)
  rect 3.988x2.159 smd: 9(0,0.525)
SOP_9P_16_177X138_8V
  rect 0.197x0.61 smd: 1(-1.6,-1.6) 2(-1.2,-1.6) 7(-1.2,1.6) 8(-1.6,1.6)
  rect 0.171x0.61 smd: 3(-0.813,-1.6) 6(-0.813,1.6)
  custom 0.15x0.15 smd: 4(0.601,-1.6) 5(0.601,1.6)
  rect 4.039x1.956 smd: 9(0,0)
  round 0.61 hole 0.305: 10(-1.714,0.673) 11(-1.206,0.673) 12(1.206,0.673) 13(1.714,0.673) 14(-1.714,-0.673) 15(-1.206,-0.673) 16(1.206,-0.673) 17(1.714,-0.673)
SOT23
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
SOT23_2D4_H43
  rect 0.711x1.016 smd: 1(-0.95,-1.301) 2(0.95,-1.301) 3(0,1.301)
SOT23_FAIR
  rect 1.067x0.686 smd: 1(1.276,-0.95) 2(1.276,0.95) 3(-1.276,0)
SOT23_H43
  rect 1.27x0.686 smd: 1(1.041,-0.95) 2(1.041,0.95) 3(-1.041,0)
SOT23_S6_FITI_H51
  rect 0.61x1.118 smd: 1(-0.95,-1.451) 2(0,-1.451) 3(0.95,-1.451) 4(0.95,1.451) 5(0,1.451) 6(-0.95,1.451)
SOT23_VISHAY
  rect 1.041x0.635 smd: 1(1.275,-0.95) 2(1.275,0.95) 3(-1.275,0)
SOT26_H55
  rect 0.635x1.118 smd: 1(-0.95,-1.451) 2(0,-1.451) 3(0.95,-1.451) 4(0.95,1.451) 5(0,1.451) 6(-0.95,1.451)
SOT323
  rect 0.914x0.813 smd: 1(0.97,-0.65) 2(0.97,0.65) 3(-0.97,0)
SOT323_INFINEON_H43
  rect 0.94x0.508 smd: 1(1.19,-0.65) 2(1.19,0.65) 3(-1.19,0)
SOT323_ONSEMI
  rect 0.559x0.94 smd: 1(-0.65,-1.19) 2(0.65,-1.19) 3(0,1.19)
SOT353_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(-0.65,1.19)
SOT363_PHILIPS
  rect 0.356x0.94 smd: 1(-0.65,-1.19) 2(0,-1.19) 3(0.65,-1.19) 4(0.65,1.19) 5(0,1.19) 6(-0.65,1.19)
SOT666_H20
  rect 0.229x0.762 smd: 1(-0.5,-0.78) 2(0,-0.78) 3(0.5,-0.78) 4(0.5,0.78) 5(0,0.78) 6(-0.5,0.78)
SW_3P_98_2HD_RA_DIPTR
  round 1.041 hole 1.041 unplated: (-3.4,0) (3.4,0)
  rect 1.194x2.489 smd: 1(-2.5,2.75) 2(0,2.75) 3(2.5,2.75)
SW_4P_189X189
  rect 1.372x0.889 smd: 1(-2.116,1.95) 2(-2.116,-1.95) 3(2.116,1.95) 4(2.116,-1.95)
TRANS_24P_50_650X370
  rect 0.762x1.219 smd: 1(-6.985,-4.35) 2(-5.715,-4.35) 3(-4.445,-4.35) 4(-3.175,-4.35) 5(-1.905,-4.35) 6(-0.635,-4.35) 7(0.635,-4.35) 8(1.905,-4.35) 9(3.175,-4.35) 10(4.445,-4.35) 11(5.715,-4.35) 12(6.985,-4.35) 13(6.985,4.35) 14(5.715,4.35) 15(4.445,4.35) 16(3.175,4.35) 17(1.905,4.35) 18(0.635,4.35) 19(-0.635,4.35) 20(-1.905,4.35) 21(-3.175,4.35) 22(-4.445,4.35) 23(-5.715,4.35) 24(-6.985,4.35)
unnamed
  round 4.064 hole 4.064 unplated: (0,0)
unnamed#3
  round 1.016 smd: 1(0,0)
VX_C0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_C7343D_H79
  rect 2.032x2.616 smd: 1(3.265,0) 2(-3.265,0)
VX_R0402_SMALL
  rect 0.432x0.508 smd: 1(-0.432,0) 2(0.432,0)
VX_R0805_H24_SMALL
  rect 0.813x1.397 smd: 1(-0.9,0) 2(0.9,0)
VX_XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
WTOB_2P_49_2HD_RA_TYCO
  rect 0.787x1.6 smd: 1(0.625,2.9) 2(-0.625,2.9)
  rect 2.108x2.997 smd: 3(3.175,0) 4(-3.175,0)
WTOB_4P_31_2HOLD_ACES
  rect 0.508x0.991 smd: 1(1.2,1.45) 2(0.4,1.45) 3(-0.4,1.45) 4(-1.2,1.45)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
WTOB_4P_49_2HD_ACE
  rect 0.787x1.6 smd: 1(1.875,2.9) 2(0.625,2.9) 3(-0.625,2.9) 4(-1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
WTOB_5P_49_2HD_RA_MOLEX
  rect 0.787x1.6 smd: 1(2.5,2.9) 2(1.25,2.9) 3(0,2.9) 4(-1.25,2.9) 5(-2.5,2.9)
  rect 2.108x2.997 smd: 6(-5.05,0) 7(5.05,0)
WTOB_5P_49_2HOLD_RA_ACES
  rect 0.787x1.905 smd: 1(2.5,4.925) 2(1.25,4.925) 3(0,4.925) 4(-1.25,4.925) 5(-2.5,4.925)
  rect 1.295x3.353 smd: 6(-5.35,0) 7(5.35,0)
WTOB_7P_59_ACE
  rect 0.838x7.01 smd: 1(4.5,0) 2(3,0) 3(1.5,0) 4(0,0) 5(-1.5,0) 6(-3,0) 7(-4.5,0)
WTOB_10P_39_2HD_CLUX
  rect 0.61x1.549 smd: 1(4.5,2.525) 2(3.5,2.525) 3(2.5,2.525) 4(1.5,2.525) 5(0.5,2.525) 6(-0.5,2.525) 7(-1.5,2.525) 8(-2.5,2.525) 9(-3.5,2.525) 10(-4.5,2.525)
  rect 1.194x1.803 smd: 11(5.8,0) 12(-5.8,0)
WTOB_13P_59
  rect 0.838x7.01 smd: 1(9,0) 2(7.5,0) 3(6,0) 4(4.5,0) 5(3,0) 6(1.5,0) 7(0,0) 8(-1.5,0) 9(-3,0) 10(-4.5,0) 11(-6,0) 12(-7.5,0) 13(-9,0)
WTOB_50P_20_5HOLD_ACES
  rect 0.254x1.295 smd: 1(12.25,1.95) 2(11.75,1.95) 3(11.25,1.95) 4(10.75,1.95) 5(10.25,1.95) 6(9.75,1.95) 7(9.25,1.95) 8(8.75,1.95) 9(8.25,1.95) 10(7.75,1.95) 11(7.25,1.95) 12(6.75,1.95) 13(6.25,1.95) 14(5.75,1.95) 15(5.25,1.95) 16(4.75,1.95) 17(4.25,1.95) 18(3.75,1.95) 19(3.25,1.95) 20(2.75,1.95) 21(2.25,1.95) 22(1.75,1.95) 23(1.25,1.95) 24(0.75,1.95) 25(0.25,1.95) 26(-0.25,1.95) 27(-0.75,1.95) 28(-1.25,1.95) 29(-1.75,1.95) 30(-2.25,1.95) 31(-2.75,1.95) 32(-3.25,1.95) 33(-3.75,1.95) 34(-4.25,1.95) 35(-4.75,1.95) 36(-5.25,1.95) 37(-5.75,1.95) 38(-6.25,1.95) 39(-6.75,1.95) 40(-7.25,1.95) 41(-7.75,1.95) 42(-8.25,1.95) 43(-8.75,1.95) 44(-9.25,1.95) 45(-9.75,1.95) 46(-10.25,1.95) 47(-10.75,1.95) 48(-11.25,1.95) 49(-11.75,1.95) 50(-12.25,1.95)
  rect 1.194x3.2 smd: 51(14.65,0) 52(-14.65,0)
  rect 2.311x1.295 smd: 53(11.4,-1.95) 54(0,-1.95) 55(-11.4,-1.95)
XTAL_2P_126X59
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTAL_4P_126X98_HELE
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTAL_4P_126X98_HELE_H31
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTAL_4P_126X98_RAK
  rect 1.397x1.143 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTAL_4P_272X55
  rect 1.194x0.61 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)

## Nets
0.6V_DDR_VTT_ON: PR5409.1 R28.2 R32.1 R9399.2 U5.4
1.2VP_S5: PC5415.1 PR5407.2 PU5401.8
3.3V_CAM2_EN#: R3603.1 U37.B32
3.3V_CAM_EN#: R2602.1 RC198.2 UC1.AT15
3.3V_HDD_EN: R9563.2 UC1.AN5
3.3V_TP_EN: RC477.1 UC1.AM5
3.3V_TS_EN: Q17.2 RC478.1 UC1.AP5
3.3V_WWAN_EN: RC191.2 U37.B42 U51.5
3V_5V_EN: PC5319.1 PR5313.2 PU5301.6 PU5301.20
3V_5V_PGOOD: PR5304.1 PR5306.1 PU5301.7
3V_BST2_1: PC5311.2 PR5303.2
3V_BST2_2: PR5303.1 PU5301.9
3V_FB2_1: PC5317.2 PJP5305.1 PR5310.2
3V_FB2_2: PC5317.1 PR5310.1 PR5312.2 PU5301.4
3V_HG: PQ5302.1 PU5301.10
3V_LG: PQ5302.8 PU5301.11
3V_SW: PC5311.1 PL5304.1 PQ5302.9 PR5305.1 PU5301.8
5V_BST1_1: PC5310.1 PR5302.1
5V_BST1_2: PR5302.2 PU5301.17
5V_FB1_1: PC5316.1 PJP5303.2 PR5309.1
5V_FB1_2: PC5316.2 PR5309.2 PR5311.2 PU5301.2
5V_HG: PQ5301.1 PU5301.16
5V_LG: PQ5301.8 PU5301.15
5V_SW: PC5310.2 PL5301.2 PQ5301.9 PR5301.1 PU5301.18
5V_VO1: PJP5304.2 PU5301.14
+0.6V_DDR_VTT: CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD59.1 JDIMM1.258 JDIMM2.258 PJP5403.1
+0.6V_DDR_VTTP: PC5406.1 PC5407.1 PJP5403.2 PU5401.2 PU5401.20
+0.9V_LAN: C117.1 C180.1 C183.1 C184.1 C185.1 C186.1 C187.1 L27.2 U21.8 U21.11 U21.16 U21.22 U21.37 U21.40 U21.43 U21.46 U21.47
+1.0V_AMPHYPLL: C9631.1 C9632.1 RC419.2 UC1.K15 UC1.L15
+1.0V_APLL: C9656.1 C9959.1 RC444.2 UC1.V15
+1.0V_APLLEBB: C9636.1 RC446.2 UC1.N18
+1.0V_CLK1: RC450.2 UC1.A14
+1.0V_CLK2: C9647.1 RC435.2 UC1.K19
+1.0V_CLK3: RC451.2 UC1.L21
+1.0V_CLK4: C9648.1 RC436.2 UC1.N20
+1.0V_CLK5: C9649.1 RC52.2 RC437.2 UC1.L19
+1.0V_CLK6: C9650.1 RC438.2 UC1.A10
+1.0V_DTS: RC440.2 UC1.T1
+1.0V_MPHYAON: C9628.1 RC439.2 UC1.K17 UC1.L1
+1.0V_MPHYGT: C9629.1 C9630.1 C9633.1 C9842.2 PJP5908.2 RC419.1 RC446.1 RC447.1 U45.8 U45.9 UC1.N15 UC1.N16 UC1.N17 UC1.P15 UC1.P16
+1.0V_PLL: RC454.2 UC1.K20 UC1.K21
+1.0V_PRIM: C9625.1 PJP5501.2 PJP5813.1 PJP5908.1 RC418.1 RC435.1 RC436.1 RC437.1 RC438.1 RC439.1 RC440.1 RC442.1 RC444.1 RC450.1 RC451.1 U45.6 U45.7 U6217.1 U6217.2 U6217.6 U6217.7 UC1.AB17 UC1.AB19 UC1.AB20 UC1.P18 UC1.Y18
+1.0V_PRIM_4: RC418.2 UC1.AK20
+1.0V_PRIM_CORE: C9626.1 PJP5604.2 RC442.2 UC1.AF18 UC1.AF19 UC1.V20 UC1.V21
+1.0V_PRIM_COREP: PC5613.1 PC5614.1 PC5617.1 PJP5604.1 PL5602.2 PU5602.1 PU5602.5
+1.0V_PRIM_XDP: CC10.1 CC11.1 JXDP1.43 JXDP1.44 PJP5813.2 RC362.1 RC386.1
+1.0V_RUN: C9950.2 L7107.1 PJP5708.1 PJP5912.1 PJP5913.1 R9647.2 U6221.1 U6221.2
+1.0V_RUN_VMM: C9851.1 L77.1 L78.1 PJP5912.2 U6221.6
+1.0V_RUN_VMM_EN: PC5726.1 PR5717.1 PR5719.2 PR6092.2 PU5904.7
+1.0V_RUN_VMM_FB: PC5733.1 PR5716.1 PR5720.1 PU5904.1
+1.0V_RUN_VMM_LX: PL5704.1 PR5718.2 PU5904.6
+1.0V_RUN_VMM_VIN: PC5725.1 PC5735.1 PC5736.1 PC5739.1 PJP5707.1 PU5904.3
+1.0V_RUNP: PC5731.1 PC5732.1 PC5733.2 PC5734.1 PC5737.1 PC5738.1 PJP5708.2 PJP5913.2 PL5704.2 PR5720.2
+1.0V_SRAM: C9635.1 RC447.2 UC1.AF20 UC1.AF21 UC1.T19 UC1.T20
+1.0V_VCCST: C389.1 C9608.1 C9611.1 PC5802.2 PR5802.2 PR5803.1 PR5804.2 PR5805.1 R9546.2 RC80.1 RC113.1 RC244.1 RC249.1 RC382.2 RC454.1 RC455.1 RC457.1 U6217.13 U6217.14 UC1.A18
