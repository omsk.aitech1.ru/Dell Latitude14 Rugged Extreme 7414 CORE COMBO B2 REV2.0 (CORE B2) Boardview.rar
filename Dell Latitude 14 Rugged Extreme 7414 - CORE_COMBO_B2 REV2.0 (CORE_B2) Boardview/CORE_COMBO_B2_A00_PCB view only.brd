# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISH_I2C2_SDA_R: length 3.1
  BOTTOM w0.108: JWWAN1.42 99.69,131.83 98.92,132.6 R219.2 R217.1
ISH_UART0_CTS#: length 189.5
  TOP w0.108: v1(163.5,106.07) 163.5,106.29 162.96,106.83 162.12,106.83 160.59,105.3 159.08,105.3 158.35,104.57 151.38,104.57 150,103.19 150,101.09 147.24,98.34 145.84,98.34 v1(144.23,96.73) ; v2(31.05,114.14) v1(31.05,113.4)
  IN4 w0.089: v1(163.5,106.07) 163.5,106.11 162.54,107.07 161.33,107.07 158.91,109.5 158.91,110.97 150.95,118.93 146.75,118.93 146.4,119.29 142.83,119.29 142.42,119.7 138.53,119.7 137.29,120.94 133.6,120.94 132.85,121.69 123.37,121.69 122.76,122.3 119.58,122.3 119.22,122.66 107.7,122.66 106.25,124.11 103.58,124.11 103.28,123.81 101.23,123.81 101,123.58 96.4,123.58 94.89,122.07 92.4,122.07 91.95,122.53 88.39,122.53 87.87,123.05 85.59,123.05 84.16,124.48 84.16,125.08 82.46,126.78 78.83,126.78 78.62,126.99 66.97,126.99 55.92,115.93 48.92,115.93 48.42,115.43 45.24,115.43 42.62,112.81 31.64,112.81 v1(31.05,113.4)
  BOTTOM w0.076: 140.85,94.04 140.73,93.92 138.65,93.92 138.2,93.46 137.7,93.46 137.62,93.5 137.44,93.5 137.31,93.46 137.06,93.46 136.95,93.5 136.43,93.5 136.03,93.9 UC1.U4
  BOTTOM w0.108: v1(144.23,96.73) 143.54,96.73 140.85,94.04 ; RC606.2 28.38,114.59 29.58,113.4 v1(31.05,113.4)
ISH_UART0_CTS#_R: length 12.9
  BOTTOM w0.108: v2(29.53,112.1) 29.53,113.04 27.96,114.61 27.96,115.42 28.38,115.84 RC606.1 28.38,119.86 30.28,121.77 JWLAN1.62
ISH_UART0_RTS#: length 188.9
  TOP w0.108: v1(163.5,105.46) 163.09,105.87 163.09,106.24 162.77,106.56 162.18,106.56 160.69,105.07 159.18,105.07 158.44,104.33 151.59,104.33 150.23,102.97 150.23,101 147.3,98.06 146.28,98.06 v1(144.94,96.73)
  IN4 w0.089: v1(163.5,105.46) 163.9,105.86 163.9,106.24 162.81,107.33 161.78,107.33 159.17,109.95 159.17,111.02 151.04,119.15 146.84,119.15 146.07,119.91 138.62,119.91 137.38,121.15 133.69,121.15 132.94,121.91 123.46,121.91 122.85,122.52 119.67,122.52 119.31,122.88 107.79,122.88 106.34,124.33 103.49,124.33 103.21,124.04 101.13,124.04 100.9,123.81 96.33,123.81 94.81,122.3 92.49,122.3 92.03,122.75 88.48,122.75 87.92,123.31 85.64,123.31 84.38,124.57 84.38,125.17 82.55,126.99 78.92,126.99 78.71,127.2 66.88,127.2 55.83,116.15 48.83,116.15 48.37,115.69 45.19,115.69 42.53,113.02 32.12,113.02 v1(31.71,113.43)
  BOTTOM w0.076: 140.64,94.12 138.62,94.12 138.13,93.63 137.74,93.63 137.65,93.67 137.41,93.67 137.29,93.63 137.09,93.63 136.98,93.67 136.77,93.67 UC1.U3
  BOTTOM w0.108: v1(144.94,96.73) 144.53,97.14 143.66,97.14 140.64,94.12 ; v2(31.81,112.76) 31.81,113.33 v1(31.71,113.43) 31.33,113.81 30.59,113.81 29.65,114.75 29.5,114.75 RC607.2
ISH_UART0_RTS#_R: length 10.6
  BOTTOM w0.108: v2(29.75,113.91) 29.63,113.91 28.82,114.71 28.82,115.49 29.2,115.86 RC607.1 29.25,116.25 29.22,116.27 29.22,116.62 28.71,117.13 28.71,119.8 30.18,121.27 JWLAN1.64
ISH_UART0_RXD: length 190.9
  TOP w0.108: v2(28.27,113.92) v1(27.8,113.45) ; v1(162.68,106.07) 162.41,106.07 160.58,104.25 160.58,103.34 160.27,103.02 156.01,103.02 155.19,103.84 151.79,103.84 150.72,102.77 150.72,100.79 147.5,97.57 146.49,97.57 v1(145.64,96.73)
  IN4 w0.089: v1(27.8,113.45) 29.7,113.45 30.82,112.34 42.81,112.34 43.83,113.35 45.99,113.35 47.05,114.42 49.1,114.42 50.02,115.33 55.98,115.33 65.99,125.34 72.32,125.34 72.62,125.04 73.68,125.04 74.06,125.42 77.86,125.42 78.1,125.66 81.32,125.66 85.88,121.1 95.38,121.1 96.49,122.21 100.53,122.21 101.59,123.27 106,123.27 106.01,123.28 106.41,123.28 110.37,119.32 118.78,119.32 119.85,120.38 119.85,121.12 120.53,121.81 121.6,121.81 122.71,120.7 123.18,120.7 123.71,121.22 131.46,121.22 132.21,120.47 137.1,120.47 138.34,119.23 142.21,119.23 142.62,118.82 146.2,118.82 146.56,118.46 149.29,118.46 152.51,115.24 153.59,115.24 158.39,110.43 158.39,109.35 161.67,106.07 v1(162.68,106.07)
  BOTTOM w0.076: 141.16,95.14 140.17,95.14 139.39,94.36 138.63,94.36 138.17,93.9 UC1.U1
  BOTTOM w0.108: v1(145.64,96.73) 145.02,97.35 143.45,97.35 141.23,95.14 141.16,95.14 ; v1(27.8,113.45) 26.48,113.45 26.35,113.58 RC604.2
ISH_UART0_RXD_R: length 12.7
  BOTTOM w0.108: v2(24.88,114.92) 24.88,115.41 25.33,115.86 RC604.1 26.52,115.86 26.85,116.2 26.94,116.2 27.27,116.53 27.27,120.13 29.9,122.77 JWLAN1.58
ISH_UART0_TXD: length 190.6
  TOP w0.108: v1(146.25,96.73) 147.35,96.73 151.21,100.59 151.21,102.31 152.25,103.35 154.69,103.35 155.51,102.53 160.47,102.53 161.07,103.14 161.07,103.98 162.56,105.46 v1(162.69,105.46)
  IN4 w0.089: v1(162.69,105.46) 161.62,105.46 157.92,109.16 157.92,110.24 153.39,114.77 152.31,114.77 149.09,117.99 146.36,117.99 146.01,118.35 142.43,118.35 142.01,118.76 138.14,118.76 136.9,120 132.02,120 131.26,120.75 124,120.75 123.47,120.23 122.47,120.23 121.37,121.32 120.86,121.32 120.33,120.79 120.33,120.1 119.07,118.85 110.16,118.85 106.2,122.8 101.85,122.8 100.65,121.6 96.55,121.6 95.58,120.63 85.69,120.63 81.13,125.19 78.3,125.19 78.06,124.95 74.25,124.95 73.88,124.58 72.32,124.58 72.03,124.87 66.19,124.87 56.17,114.86 50.21,114.86 49.29,113.93 47.25,113.93 46.21,112.88 44.02,112.88 43.01,111.87 29.68,111.87 v1(28.54,113.02)
  BOTTOM w0.076: UC1.U2 137.46,94.16 138.2,94.16 138.56,94.53 139.28,94.53 140.12,95.37 141.01,95.37
  BOTTOM w0.108: 141.01,95.37 141.12,95.37 143.31,97.56 145.42,97.56 v1(146.25,96.73) ; RC605.2 27.37,114.49 28.54,113.32 v1(28.54,113.02) v2(27.79,112.27)
ISH_UART0_TXD_R: length 11.5
  BOTTOM w0.108: v2(26.84,114.03) 26.84,115.41 27.3,115.86 RC605.1 27.4,115.86 27.85,116.31 27.85,120.02 30.09,122.27 JWLAN1.60
ISUMN_GT: length 50.4
  TOP w0.229: 70.01,94.21 70.35,94.54 PJP5906.1
  TOP w0.254: v1(70.06,91.48) 70.06,91.22 69.84,91 PR5845.2 PH5805.2 71.5,91.34 70.01,92.83 70.01,94.21 ; PC5831.1 PC5832.1 66.04,111.79 v1(65.9,111.64) 65.82,111.64 PC5839.2 PR5847.2 64.43,109.46 PR5853.2 64.35,109.34 v2(63.49,108.47)
  IN1 w0.254: v1(65.9,111.64) 57.44,103.19 57.44,93.02 57.52,92.94 57.52,91.6 58.38,90.74 69.47,90.74 70.06,91.33 v1(70.06,91.48)
ISUMN_IA: length 48.5
  TOP w0.108: PC5830.2 75.16,109.41 v2(74.95,109.21)
  TOP w0.229: 111.75,118.38 111.95,118.17 PJP5902.1
  TOP w0.254: v1(80.69,111.35) 80.69,110.69 PR5836.1 81.7,109.69 81.7,109.08 81.19,108.57 79.56,108.57 79.18,108.95 PR5838.1 79.16,109.41 PC5826.2 PC5827.2 PC5830.2 ; 111.75,118.38 109,118.38 108.4,117.78 PH5803.1 106.88,117.78 PR5839.1 106.28,117.21 v1(105.5,117.21)
  IN1 w0.254: v1(80.69,111.35) 80.95,111.1 94.1,111.1 95.11,112.12 102.33,112.12 102.8,112.59 102.8,117.06 103.47,117.72 105.29,117.72 105.5,117.51 v1(105.5,117.21)
ISUMN_VSA: length 69.7
  TOP w0.229: PJP5904.1 125.94,118.05 125.26,118.73
  TOP w0.254: 125.26,118.73 124.2,118.73 PH5802.1 122.22,117.27 PR5821.1 121.58,117.77 121.23,118.11 121.23,118.95 121.73,119.44 v1(121.83,119.44) ; v1(78.14,118.96) 78.14,118.3 PC5807.2 PC5810.2 PR5815.1 79.18,116.47 v2(79.23,116.42) 79.59,116.07 PC5809.2 80.23,115.98 PR5818.1
  IN1 w0.254: v1(121.83,119.44) 121.83,120.64 118.75,123.71 117.79,123.71 115.91,125.59 113.24,125.59 112.25,126.58 112.25,127.77 109.86,130.16 107.74,130.16 106.54,128.97 106.54,128.16 105.89,127.5 100.09,127.5 97.9,125.32 97.9,123.92 93.43,119.45 85.23,119.45 83.87,118.09 79.02,118.09 v1(78.14,118.96)
ISUMP_GT: length 44.4
  TOP w0.222: PU5801.7 68.88,113.05 68.84,113.01 68.01,113.01 67.61,112.61 PC5831.2
  TOP w0.254: PR5911.1 68.5,89.83 PR5844.1 PR5845.1 68.97,91.09 v1(69.4,91.52) ; PC5831.2 PC5832.2 66.99,111.28 66.36,111.28 v1(66.2,111.11)
  IN1 w0.254: v1(66.2,111.11) 57.95,102.86 57.95,93.23 58.3,92.88 58.3,91.53 58.59,91.25 69.26,91.25 69.4,91.39 v1(69.4,91.52)
  BOTTOM w0.108: v1(69.4,91.52) 70.05,90.87 v2(71.38,90.87)
ISUMP_IA: length 43.6
  TOP w0.222: PU5801.19 72.96,110.73 73.42,110.27
  TOP w0.254: PR5843.2 107.76,120.69 107.45,120.38 107.45,120.17 PR5903.1 PR5839.2 106.34,118.66 105.75,118.07 v5(105.7,118.07) 105.4,118.07 104.84,117.51 v1(104.84,117.21) ; v1(77.6,110.22) 77.54,110.27 PC5827.1 PC5830.1 73.42,110.27
  IN1 w0.254: v1(77.6,110.22) 80.58,110.22 80.95,110.59 94.31,110.59 95.32,111.61 102.54,111.61 103.31,112.38 103.31,116.78 103.74,117.21 v1(104.84,117.21)
ISUMP_VSA: length 73.5
  TOP w0.222: 74.52,114.25 PU5801.27
  TOP w0.254: PR5823.2 121.46,116.87 120.72,117.6 120.72,119.33 v1(121.32,119.93) 121.35,119.95 122,119.95 122.49,119.47 122.49,119.28 PR5907.1 122.6,118.63 PR5821.2 ; v1(76.44,114.69) 76.42,114.69 75.98,114.25 74.52,114.25 ; v2(76.44,118.15) 77.29,117.3 PC5810.1 PC5807.1 77.46,118.91 v1(77.51,118.96)
  IN1 w0.254: v1(77.51,118.96) 77.51,118.88 78.81,117.58 84.08,117.58 85.44,118.94 93.64,118.94 98.41,123.71 98.41,125.11 100.3,126.99 106.1,126.99 107.05,127.95 107.05,128.75 107.95,129.66 109.65,129.66 111.75,127.56 111.75,126.37 113.03,125.08 115.68,125.08 117.61,123.15 118.42,123.15 120.33,121.25 120.33,120.74 121.14,119.93 v1(121.32,119.93)
  IN3 w0.254: v1(77.51,118.96) 77.51,115.91 76.44,114.85 v1(76.44,114.69)
ITP_PMODE: length 109.8
  TOP w0.076: v3(133.79,100.45) 131.71,102.53 131.32,102.53 130.76,103.1 130.76,104 131.03,104.28 133.84,104.28 135.37,105.8 135.37,106.16
  TOP w0.108: v1(129.55,119.49) 129.55,116.02 131.56,114.01 131.56,113.33 131.99,112.9 134.22,112.9 134.68,112.44 134.68,110.34 RC386.2 135.22,109.36 135.34,109.23 135.34,108.83 135.55,108.62 135.55,106.34 135.37,106.16 ; v1(78.82,126.08) v2(78.09,125.34) 78.09,122.65 79.74,120.99 79.74,119.14 79.68,119.08 v1(79.68,118.91)
  IN1 w0.089: v1(78.82,126.08) 78.82,128.15 81.85,131.18 81.85,133.79 85.26,137.19 89.94,137.19 91.53,135.6 93.38,135.6 94.66,134.33 v1(96.73,134.33)
  IN2 w0.089: v1(96.73,134.33) 96.73,126.53 99.02,124.24 99.02,124.22 100.24,123 103.44,123 103.64,123.2 106.48,123.2 106.82,122.85 114.09,122.85 115.33,124.09 120.56,124.09 122.22,122.43 126.61,122.43 v1(129.55,119.49)
  BOTTOM w0.076: v3(133.79,100.45) 133.79,100.43 UC1.E8
  BOTTOM w0.108: v1(79.68,118.91) 79.68,118.74 79.8,118.62 JXDP1.46
JDIMM1_EVENT#: length 5
  TOP w0.108: v2(114.64,40.81) 114.81,40.81 v1(115.24,40.37) 115.37,40.37 115.76,39.98 115.76,39.54 RD61.1
  BOTTOM w0.108: JDIMM1.134 114.51,39.64 v1(115.24,40.37)
JDIMM2_EVENT#: length 4.2
  TOP w0.108: RD4.1 114.41,28.33 v2(114.41,27.52) 114.66,27.27 v1(115.02,27.27)
  BOTTOM w0.108: JDIMM2.134 114.52,26.77 v1(115.02,27.27)
JTAG_CLK: length 114.7
  TOP w0.108: RP2.5 224.13,63.53 224.65,64.05 224.65,65.29 v1(224.88,65.52) ; v1(230.69,59.49) 230.48,59.49 229.62,58.63 U38.B56 ; v1(151.25,77.08) 151.25,76.92 151.64,76.54 JDEG1.4
  IN2 w0.089: v1(221.03,53.15) 218.15,53.15 215.79,50.79 208.4,50.79 205.79,53.4 194.32,53.4 193.49,54.24 190.09,54.24 188.69,55.65 187.57,55.65 185.97,57.25 185.16,57.25 184.73,57.67 182.35,57.67 177.83,62.19 176.13,62.19 172.5,65.83 172.5,68.41 168.41,72.51 168.05,72.51 165.78,74.78 153.14,74.78 151.25,76.66 v1(151.25,77.08)
  IN4 w0.089: v1(224.88,65.52) 224.62,65.27 224.62,63.79 225.08,63.34 225.72,63.34 227.34,61.71 227.67,61.71 227.9,61.48 227.9,61.25 229.67,59.49 v1(230.69,59.49)
  BOTTOM w0.108: v1(221.03,53.15) 221.03,54.13 v2(221.36,54.46) 221.66,54.76 222.43,54.76 222.85,55.19 222.85,57.79 222.27,58.37 222.27,61.41 222.4,61.54 222.4,63.56 224.36,65.52 v1(224.88,65.52)
JTAG_RST#: length 14.9
  TOP w0.108: v1(232.18,63.26) 232.18,63.48 C362.1 ; R384.2 230.6,66.4 v1(230.6,66.15) ; R384.2 R380.2 ; R384.2 231.39,67.18 231.39,68.48 231.46,68.54 v2(231.46,68.95) JTAG1.1 ; v1(232.6,60.11) 232,60.71 U38.B47
  IN4 w0.089: v1(232.6,60.11) 232.2,60.51 232.2,61.6 231.78,62.02 231.78,62.86 v1(232.18,63.26) 230.19,65.26 230.19,65.73 v1(230.6,66.15)
JTAG_TDI: length 105
  TOP w0.108: v1(150.43,77.08) 150.43,76.74 150.64,76.54 JDEG1.2 ; v1(223.39,60.69) 223.39,61.03 223.1,61.32 RP2.1 223.4,61.84 223.99,61.25 226.2,61.25 226.88,60.57 226.88,60.16 227.66,59.38 U38.A51
  IN2 w0.089: v1(222.18,52.06) 221.78,52.46 218.29,52.46 216.27,50.44 208.25,50.44 205.64,53.05 194.18,53.05 193.34,53.89 189.95,53.89 188.54,55.29 187.43,55.29 185.83,56.89 185.01,56.89 184.59,57.32 182.2,57.32 177.76,61.76 176.06,61.76 172.09,65.74 172.09,68.17 168.59,71.67 166.79,71.67 164.1,74.36 152.97,74.36 150.48,76.85 150.48,77.03 v1(150.43,77.08)
  BOTTOM w0.108: v1(223.39,60.69) 223.1,60.4 223.1,58.81 223.98,57.93 224.13,57.93 224.37,57.69 224.37,56.15 224.06,55.84 224.06,54.32 v2(223.78,54.04) 223.3,53.56 223.3,52.85 222.92,52.47 222.59,52.47 v1(222.18,52.06)
JTAG_TDO: length 112.4
  TOP w0.108: v1(230.69,60.11) 230.69,60.11 229.71,59.13 U38.B55 ; v1(224.22,64.25) 224.05,64.42 RP2.7 ; JDEG1.5 152.14,76.54 151.66,77.01 151.66,77.3 v1(151.25,77.71)
  IN2 w0.089: v1(221.65,53.2) 221.65,53.2 221.65,53.2 221.3,53.55 218.22,53.55 215.64,50.97 208.51,50.97 205.9,53.58 194.4,53.58 193.56,54.42 190.17,54.42 188.76,55.82 187.65,55.82 186.05,57.42 185.23,57.42 184.81,57.85 182.53,57.85 179.39,60.99 179.39,61.59 174.57,66.41 173.64,66.41 172.78,67.27 172.78,68.39 168.48,72.68 168.12,72.68 165.83,74.98 153.34,74.98 151.65,76.67 151.65,77.31 v1(151.25,77.71)
  IN4 w0.089: v1(230.69,60.11) 231.09,59.71 231.09,59.32 230.86,59.09 229.8,59.09 228.07,60.82 227.4,60.82 225.99,62.22 225.99,62.66 225.77,62.89 225.77,62.9 225.54,63.13 225.03,63.13 224.22,63.95 v1(224.22,64.25)
  BOTTOM w0.108: v1(224.22,64.25) 223.91,64.25 v2(223.33,63.67) 222.61,62.95 222.61,61.46 222.48,61.32 222.48,58.46 223.06,57.88 223.06,55.05 221.65,53.65 221.65,53.2 v1(221.65,53.2)
JTAG_TMS: length 110.6
  TOP w0.108: U38.A53 v1(227.99,58.38) ; v1(150.43,77.71) 150.84,77.3 150.84,76.84 151.14,76.54 JDEG1.3 ; RP2.3 v1(224.06,62.73)
  IN2 w0.089: v1(150.43,77.71) 150.83,77.31 150.83,76.83 153.13,74.53 164.17,74.53 166.86,71.84 168.67,71.84 172.26,68.25 172.26,65.81 176.14,61.94 177.83,61.94 182.27,57.49 184.66,57.49 185.08,57.07 185.9,57.07 187.5,55.47 188.62,55.47 190.02,54.06 193.41,54.06 194.25,53.23 205.72,53.23 208.33,50.62 215.99,50.62 218.01,52.64 222.24,52.64 v1(222.82,52.06)
  IN4 w0.089: v1(224.06,62.73) 224.98,61.81 224.98,59.46 226.46,57.98 227.58,57.98 v1(227.99,58.38)
  BOTTOM w0.108: v1(224.06,62.73) 224.5,62.29 224.5,60.52 223.39,59.42 223.39,58.81 224.07,58.14 224.22,58.14 224.65,57.71 224.65,56.05 224.36,55.75 224.36,53.86 223.86,53.37 223.86,52.36 v2(223.56,52.06) v1(222.82,52.06)
KB_DET#: length 70.2
  TOP w0.108: v1(151.32,51.55) 149.62,51.55 147.45,49.38 JKB1.1 145.34,49.38 v2(144.89,48.93)
  IN1 w0.089: v1(151.32,51.55) 151.06,51.8 151.06,52.69 151.97,53.6 151.97,58.55 v1(151.93,58.6)
  IN4 w0.089: v1(151.93,58.6) 152.75,58.6 153.86,59.7 153.86,66.64 151.87,68.63 151.87,70.8 153.43,72.35 155.08,72.35 155.17,72.44 155.18,72.44 156.18,73.44 156.18,75.92 156.5,76.24 156.5,77.87 155.1,79.27 155.1,81.77 154.74,82.14 154.32,82.14 v1(153.92,82.54)
  BOTTOM w0.076: UC1.BB7 134.37,80.08 134.52,79.93 134.81,79.93 135.8,78.94 137.86,78.94 139.22,80.3 139.81,80.3 140.02,80.51 141.07,80.51 141.16,80.42
  BOTTOM w0.108: 141.16,80.42 143.39,78.19 148.46,78.19 149.2,78.94 149.2,80.93 149.77,81.5 151.37,81.5 RC608.1 152.41,82.54 153.2,82.54 153.31,82.65 153.81,82.65 v1(153.92,82.54)
LAN_ACTLED_YEL#: length 53.5
  TOP w0.254: C9505.1 183.4,137.96 v1(183.7,137.66) ; v1(160.62,133.85) 160.59,133.85 160.32,133.58 Q32.3
  TOP w0.279: R2803.1 C9505.1
  IN2 w0.254: v1(160.62,133.85) 160.21,133.44 160.21,131.16 161.1,130.27 161.1,129.61 162.09,128.62 162.09,125.56 162.69,124.96 162.69,124.26 163.13,123.83 165.05,123.83 167.47,121.4 173.29,121.4 174.18,122.29 176.46,122.29 177.35,123.18 178.5,123.18 179.11,122.57 182.03,122.57 185.48,126.02 185.48,133.85 185.08,134.25 185.08,136.13 183.7,137.5 v1(183.7,137.66)
  BOTTOM w0.254: v2(183.7,136.79) v1(183.7,137.66)
LAN_DISABLE#_R: length 192.3
  TOP w0.108: v1(142.33,122.52) 141.94,122.52 141.21,123.25 141.21,123.51 R713.1 140.7,124.37 R180.2 R182.2 140.7,126.53 141.82,127.65 141.82,128.28 142.12,128.59 143.98,128.59 144.15,128.77 U21.3 ; U37.B53 255.73,57.08 256.01,57.36 256.01,57.84 255.84,58 255.84,58.45 255.57,58.72 254.82,58.72 253.2,60.34 253.2,61.05 252.82,61.43 v1(252.82,63.06)
  IN2 w0.089: v1(142.33,122.52) 144.28,120.56 144.28,120.11 145.38,119.01 155.45,119.01 158.76,115.69 164.71,115.69 167.36,113.04 174.28,113.04 175.58,111.74 176.28,111.04 183.29,111.04 188.94,105.39 188.94,96.79 189.31,96.42 189.31,95.93 189.97,95.27 189.97,91.52 190.25,91.24 190.25,88.9 189.79,88.44 189.79,86.4 188.45,85.07 188.45,78.16 185.21,74.92 185.21,65.66 187.05,63.82 187.14,63.82 190.51,60.45 194.47,60.45 197.05,57.87 201.9,57.87 204.02,59.98 205.6,59.98 206.24,60.62 212.71,60.62 214.22,62.13 217.01,62.13 217.99,63.11 219.22,63.11 220.75,64.64 223.29,64.64 223.75,65.11 230.78,65.11 231.13,65.46 231.13,65.74 231.94,66.56 242.64,66.56 246.9,62.29 252.46,62.29 252.82,62.65 v1(252.82,63.06)
  BOTTOM w0.108: v2(252.59,62.37) 252.82,62.6 v1(252.82,63.06)
LAN_TEST_EN: length 2.6
  TOP w0.108: U21.30 145.75,136.38 v2(145.65,136.48) 145.38,136.76 R184.2
LAN_TX0+: length 42.4
  TOP w0.102: L2800.12 179,123.92 178.16,123.08 177.2,123.08 176,121.88 175.29,121.88 174.59,121.17 174.59,119.04 173.47,117.92 172.35,117.92 172.03,118.24 171.4,118.24 D2800.1 171.27,118.24 169.92,118.24 169.38,117.69 167.49,117.69 167.06,118.12 165.34,118.12 ; v6(165.34,118.1) 165.34,118.12 ; 165.34,118.12 160.08,118.12 158.47,119.73 158.35,119.85 158.35,119.85 158.24,119.97 158.24,119.99 158.12,120.11 156.25,121.98 153.72,124.5 153.72,125.51 151.52,127.71 151.52,128.52 151.4,128.64 150.11,129.94 148.9,129.94 148.9,129.94 U21.13
LAN_TX0-: length 42.4
  TOP w0.102: U21.14 150.27,130.34 151.69,128.93 151.93,128.69 151.93,127.88 154.13,125.68 154.13,124.67 156.65,122.15 156.65,122.15 158.06,120.74 158.64,120.16 158.64,120.14 158.76,120.02 160.25,118.53 163.61,118.53 ; 163.61,118.53 167.23,118.53 167.66,118.1 168.36,118.1 D2800.6 168.51,118.1 169.07,118.1 169.62,118.64 172.2,118.64 172.52,118.33 173.3,118.33 174.18,119.21 174.18,121.34 175.12,122.28 175.83,122.28 177.03,123.48 177.99,123.48 178.49,123.98 178.49,124.43 178.34,124.58 178.12,124.58 178.04,124.5 177.84,124.5 177.73,124.6 L2800.11 ; 163.61,118.53 v6(163.61,118.56)
LAN_TX1+: length 37.3
  TOP w0.102: L2800.8 173.92,124.3 172.74,123.11 172.74,120.55 172.38,120.18 171.44,120.18 D2800.3 171.23,120.18 170.61,120.18 170.04,119.6 167.64,119.6 167.41,119.6 167.07,119.27 160.95,119.27 160.47,119.75 160.07,119.75 159.47,120.35 159.47,121.16 159.16,121.48 158.36,121.48 157.39,122.45 157.39,123.66 155.81,125.23 ; 155.81,125.23 v6(155.81,125.18) ; 155.81,125.23 152.67,128.38 152.67,129.6 150.73,131.54 148.88,131.54 148.87,131.54 U21.17
LAN_TX1-: length 37.3
  TOP w0.102: L2800.7 172.65,124.55 172.78,124.42 172.93,124.42 173.04,124.52 173.31,124.52 173.37,124.47 173.37,124.32 172.33,123.28 172.33,120.71 172.21,120.59 172.04,120.59 172.04,120.59 170.44,120.59 169.87,120.01 168.5,120.01 D2800.4 168.37,120.01 167.81,120.01 167.24,120.01 166.91,119.67 161.12,119.67 160.56,120.23 160.17,120.23 159.88,120.52 159.88,121.33 159.33,121.88 158.53,121.88 157.8,122.62 157.8,123.83 157.35,124.27 ; U21.18 150.9,131.94 153.08,129.77 153.08,128.55 157.35,124.27 ; v6(157.39,124.27) 157.35,124.27
LAN_TX2+: length 33.3
  TOP w0.102: 154.85,127.93 154.98,127.8 158.66,124.12 158.66,123.59 160.89,121.36 160.89,120.97 161.19,120.67 162.03,120.67 162.15,120.55 163.25,120.55 163.97,121.28 164.89,121.28 D2801.1 165.03,121.28 165.92,121.28 166.41,120.79 169.5,120.79 171.38,122.67 171.38,125.38 ; 154.85,127.93 v6(154.82,127.93) ; 154.85,127.93 153.81,128.96 153.81,130.07 151.18,132.7 148.81,132.7 148.77,132.74 U21.20
LAN_TX2-: length 33.2
  TOP w0.102: U21.21 148.95,133.14 148.98,133.11 151.35,133.11 154.22,130.24 154.22,129.13 156.41,126.94 ; L2800.5 170.11,124.63 170.22,124.52 170.55,124.52 170.98,124.09 170.98,122.84 169.34,121.2 166.57,121.2 166.09,121.69 163.81,121.69 163.08,120.96 162.31,120.96 D2801.6 161.93,121.08 161.36,121.08 161.3,121.14 161.3,121.53 159.07,123.76 159.07,124.29 156.41,126.94 ; 156.41,126.94 v6(156.45,126.94)
LAN_TX3+: length 25.8
  TOP w0.102: 166.3,125.38 166.3,124 165.71,123.41 165.26,123.41 D2801.3 164.67,123.41 163.48,123.41 162.7,122.63 161.34,122.63 159.93,124.04 159.93,124.54 154.96,129.51 154.96,130.7 152.42,133.24 151.71,133.94 151.37,133.94 v6(151.34,133.92) 151.32,133.94 U21.23
LAN_TX3-: length 25.7
  TOP w0.102: L2800.1 165.03,124.55 165.14,124.45 165.42,124.45 165.54,124.58 165.76,124.58 165.9,124.44 165.9,124.17 165.54,123.81 163.31,123.81 162.61,123.11 D2801.4 161.43,123.11 160.34,124.21 160.34,124.71 155.36,129.68 155.36,130.87 151.88,134.35 149.65,134.35 v6(149.64,134.36) 149.63,134.35 148.85,134.35 148.84,134.34 U21.24
LAN_WAKE#: length 286.9
  TOP w0.108: v1(142.35,73.17) 142.13,72.95 140.49,72.95 v1(139.72,73.71) ; 157.41,108.41 v1(157.41,108.41) ; 157.41,108.41 157.92,108.91 157.92,111.11 152.46,116.57 150.49,116.57 147.38,119.68 147.38,120 147.02,120.36 143.87,120.36 143.36,120.87 142.06,120.87 141.8,121.14 141.8,122.03 R176.2 140.14,123.69 140.14,124.52 140.22,124.6 140.22,126.98 R9639.1 ; 157.41,108.41 157.88,108.41 158.66,109.18 158.66,110.43 159.14,110.91 160.51,110.91 162.36,109.06 162.36,107.91 163.01,107.25 163.14,107.25 163.92,106.47 163.92,104.84 161.78,102.7 161.78,101.77 162.8,100.75 162.88,100.75 163.46,100.17 v1(163.46,99.58) ; U38.B27 238.26,57.13 237.96,56.83 v1(237.54,56.83) ; v1(180.15,96.76) 180.15,96.15 v2(180.38,95.92) 180.48,95.82 R9501.1
  IN1 w0.076: v3(129.25,86.01) 128.72,85.47 128.72,82.13 129.65,81.2 130.45,81.2 131.99,79.67 131.99,79.3 132.9,78.38 132.9,76.63 133.67,75.86 134.4,75.86 135.06,75.2 136.03,75.2 136.38,74.84
  IN1 w0.089: v1(139.72,73.71) 138.59,72.58 137.5,72.58 136.41,73.67 136.41,74.82 136.38,74.84 ; v1(153.73,99.4) 154.21,99.4 156.47,101.66 156.47,107.47 v1(157.41,108.41) ; v1(163.46,99.58) 163.46,96.19 162.3,95.03 162.3,93.78 163.64,92.44 163.64,84.7 163.64,84.7 163.64,84.37 162.35,83.08 159.79,83.08 159.37,82.67 159.37,82.21 158.86,81.69 158.86,81.42 158.62,81.19 158.04,81.19 156.12,79.27 156.12,76.4 150.32,70.61 147.96,70.61 146.91,71.65 142.87,71.65 142.43,72.1 142.43,73.09 v1(142.35,73.17)
  IN2 w0.089: v1(237.54,56.83) 238.81,56.83 239.81,55.84 242.49,55.84 244.25,54.07 246.68,54.07 250,57.39 v1(251.39,57.39)
  IN3 w0.089: v1(163.46,99.58) 163.46,98.92 165.92,96.46 168.16,96.46 169.5,97.8 176.47,97.8 177.13,97.14 179.77,97.14 v1(180.15,96.76) 180.15,96.75 181.03,95.87 183.07,95.87 184.98,93.96 186.62,93.96 187.92,92.65 187.92,78.98 190.14,76.75 190.14,70.73 191.01,69.86 191.01,69.01 194.22,65.79 194.69,65.79 197.12,63.36 206.53,63.36 207.92,64.75 213.18,64.75 217.97,69.55 239.8,69.55 240.29,69.05 242.02,69.05 248.19,62.88 v1(249.9,62.88)
  BOTTOM w0.076: v3(129.25,86.01) UC1.AM15
  BOTTOM w0.108: R9640.1 153.73,99.78 v1(153.73,99.4) ; RP4808.7 137.59,76.25 137.95,76.61 140.48,76.61 140.93,76.16 140.93,74.87 140.37,74.31 140.37,74.3 139.87,73.8 139.86,73.8 139.77,73.71 v1(139.72,73.71) ; v1(249.9,62.88) 249.9,62.8 251.06,61.64 251.06,59.25 251.8,58.51 251.8,57.8 v1(251.39,57.39)
LANCLK_REQ#_R: length 6.4
  TOP w0.108: v2(138.01,128.59) 138.5,129.07 139.38,129.07 R169.2 139.96,128.64 140.78,129.45 140.78,130.14 141.11,130.47 141.8,130.47 142.33,129.94 U21.48
LCD_CBL_DET#: length 168.2
  TOP w0.108: v1(149.92,87.24) v2(149.92,86.25) 150.94,85.23 v1(150.94,84.54)
  IN2 w0.089: v1(148.06,59.87) 147.06,59.87 146.67,59.48 142.65,59.48 142.15,58.97 136.28,58.97 132.68,62.58 118.89,62.58 118.26,61.96 106.69,61.96 83.81,84.84 83.81,85.42 81.23,88 74.07,88 71.04,91.03 71.04,92.13 64.5,98.67 57.21,98.67 v1(56.61,99.27)
  IN4 w0.089: v1(149.92,87.24) 150.03,87.13 150.03,81.5 145.55,77.03 145.55,74.17 145.89,73.83 147.91,73.83 v1(149.67,72.07)
  BOTTOM w0.076: 141.16,91.17 140.73,91.17 140.19,90.64 139.18,90.64 138.85,90.31 136.49,90.31 UC1.AC3
  BOTTOM w0.108: v1(149.67,72.07) 150.1,71.63 150.1,68.11 148.42,66.43 148.42,60.23 v1(148.06,59.87) ; v1(56.61,99.27) 56.61,99.26 56.45,99.1 C9912.1 56.53,99.81 57.04,99.81 57.53,100.3 JEDP1.1 ; v1(149.92,87.24) 148.78,88.38 148.78,88.84 146.47,91.15 144.66,91.15 144.66,91.15 143.88,91.15 143.88,91.15 143.77,91.15 143.77,91.15 143.7,91.15 143.19,90.64 142.37,90.64 141.84,91.17 141.16,91.17 ; v1(150.94,84.54) 151.05,84.66 RP9.7
LCD_T11: length 276
  TOP w0.108: v1(51.98,89.12) 52.33,88.76 v2(52.33,88.33) ; v1(266.46,53.07) 266.21,52.83 U37.A23
  IN2 w0.089: v1(51.98,89.12) 51.98,89.65 53.95,91.62 55.81,91.62 56.34,92.16 59.68,92.16 60.56,91.28 65.45,91.28 66.38,90.34 66.38,89.74 71.31,84.81 71.87,84.81 73.29,83.38 73.29,80.87 78.2,75.96 87.74,75.96 105.96,57.75 132.04,57.75 135.41,54.38 145.86,54.38 146.77,53.46 146.77,50.71 157.59,39.89 170.92,39.89 173.75,37.07 177.08,37.07 180.45,33.7 219.21,33.7 221.34,31.57 230.38,31.57 231.78,30.17 235.07,30.17 235.49,30.6 239.89,30.6 241.18,31.88 245.13,31.88 245.94,31.07 254.31,31.07 255.1,31.87 266.3,31.87 v1(266.81,32.37)
  IN4 w0.089: v1(266.81,32.37) 261.59,37.6 261.59,38.46 262.72,39.59 262.81,39.59 265.31,42.09 265.31,45.38 265.54,45.61 265.54,52.16 v1(266.46,53.07)
  BOTTOM w0.108: v1(51.98,89.12) 52.21,89.12 53.33,88 U6223.2
LCD_TST: length 287.6
  TOP w0.108: v1(263.21,60.69) 263.21,61.28 R309.2 262.53,61.12 U37.A36
  IN2 w0.089: v1(50.74,99.94) 50.74,99.04 51.95,97.83 65.01,97.83 70.86,91.98 70.86,90.95 74.03,87.78 81.2,87.78 83.63,85.35 83.63,84.77 106.62,61.78 118.62,61.78 119.24,62.4 132.6,62.4 136.21,58.8 142.23,58.8 142.73,59.3 146.74,59.3 147.08,59.64 147.72,59.64 147.89,59.47 148.22,59.47 148.81,60.06 148.81,60.5 149.33,61.02 151.35,61.02 152.5,59.86 157.14,59.86 159.44,62.16 160.58,62.16 163.62,59.12 164.91,59.12 166.75,57.28 170.08,57.28 170.76,56.6 170.76,54.84 172.81,52.79 175.66,52.79 183.31,45.14 195.04,45.14 197.3,47.4 202.73,47.4 205.4,44.74 209.19,44.74 209.34,44.89 219.9,44.89 222.36,42.43 230.96,42.43 233.32,40.07 239.79,40.07 241.6,41.87 241.94,41.87 249.62,41.87 250.35,42.6 252.78,42.6 253.22,42.16 253.22,41.61 253.9,40.94 255.77,40.94 257.56,42.73 262.61,42.73 263.28,43.4 267.86,43.4 267.87,43.39 268.2,43.39 268.2,43.4 268.26,43.4 268.67,43.8 269.96,43.8 271.84,45.69 271.84,47.11 272.34,47.61 272.34,54.84 269.28,57.9 v1(268.67,57.9)
  IN3 w0.089: v1(268.67,57.9) 268.67,59.47 268.69,59.49 268.69,59.82 268.32,60.19 263.71,60.19 v1(263.21,60.69)
  BOTTOM w0.108: JEDP1.13 51.53,100.73 v1(50.74,99.94) ; v2(269.34,57.9) v1(268.67,57.9)
LCD_VCC_TEST_EN: length 291
  TOP w0.108: U37.A40 260.53,59.57 v1(260.56,59.6)
  IN2 w0.089: v1(55.18,89.82) 55.18,90.46 55.76,91.04 65.43,91.04 66.18,90.29 66.18,89.68 71.29,84.58 71.84,84.58 73.11,83.31 73.11,80.79 78.12,75.78 87.67,75.78 105.93,57.53 131.86,57.53 135.21,54.17 145.81,54.17 146.37,53.62 146.37,50.74 149.82,47.28 149.82,45.88 157.74,37.96 171.97,37.96 174.61,35.31 176.56,35.31 178.36,33.52 219.11,33.52 221.24,31.39 230.1,31.39 231.72,29.77 240.08,29.77 241.3,31 245.18,31 245.28,30.89 254.43,30.89 255.16,31.63 266.73,31.63 267.25,32.15 267.25,34.5 266.39,35.36 266.39,36.48 267,37.09 269.06,37.09 270.2,38.23 272.13,38.23 272.48,37.89 272.79,37.89 273.14,38.23 273.14,54.3 268.52,58.92 261.25,58.92 v1(260.56,59.6)
  BOTTOM w0.108: v1(260.56,59.6) 260.56,58.84 v2(260.54,58.81) ; D2.1 56.59,89.79 56.32,89.52 55.47,89.52 v1(55.18,89.82)
LED_10_GRN#: length 5.2
  TOP w0.254: Q33.3 159.59,131.96 159.32,131.69 159.32,129.58 C9506.1 R9401.2 v2(160.41,128.31)
LED_100_ORG#: length 3.7
  TOP w0.254: v2(162.9,135.12) 162.9,135.93 R9443.2 C9507.1 161.86,135.88 162.11,135.62 162.11,135.12 161.87,134.88 Q32.6
LED_DET#: length 55.1
  TOP w0.108: R478.1 260.28,6.34 260.59,6.64 261.99,6.64 262.17,6.47 v1(264.09,6.47) ; U37.A11 261.53,47.76 v1(261.81,47.49)
  IN4 w0.089: v1(261.81,47.49) 261.41,47.09 261.41,46.5 259.63,44.72 259.63,42.98 261.07,41.55 261.07,39.43 260.11,38.48 260.11,35.9 261.17,34.84 261.17,32 260.14,30.96 260.14,25.57 260.84,24.87 260.84,22.49 263.69,19.64 263.69,6.87 v1(264.09,6.47)
  BOTTOM w0.108: v1(264.09,6.47) 264.48,6.47 265.18,7.17 JLED1.1 265.18,8.69 265.33,8.84 266.16,8.84 v2(266.28,8.95)
LED_SATA_DIAG_OUT#: length 32.3
  TOP w0.254: v1(260.37,46.92) 260.59,46.92 261.03,47.36 U37.A10 ; D24.2 260.24,19.98 v2(260.28,20.03) 260.72,20.46 v1(260.84,20.46)
  IN4 w0.254: v1(260.84,20.46) 258.72,22.58 258.72,26.24 259.42,26.94 259.42,31.3 259.75,31.63 259.75,34.96 259.36,35.36 259.36,40.63 259.03,40.96 259.03,45.57 v1(260.37,46.92)
LED_WWAN_OUT#: length 101.6
  TOP w0.254: Q30.4 25.53,129.21 25.54,129.2 R226.2 25.28,128.39 v2(24.62,128.39) 24.24,128.77 v1(24.24,128.94)
  IN4 w0.254: v1(100.57,124.33) 100.38,124.14 96.15,124.14 94.6,122.59 93.64,122.59 92.04,124.19 91.48,124.19 91.12,123.84 91.12,123.38 90.87,123.13 88.6,123.13 88.02,123.71 85.66,123.71 84.67,124.69 84.67,125.29 82.67,127.29 79.05,127.29 78.8,127.54 66.77,127.54 57.27,118.04 46.05,118.04 41.64,113.63 33.23,113.63 32.85,114.01 30.31,114.01 28.36,115.96 28.36,123.41 24.67,127.1 24.67,128.51 v1(24.24,128.94)
  BOTTOM w0.254: JWWAN1.10 100.79,124.12 v1(100.57,124.33)
LID_CL#: length 221.1
  TOP w0.108: R325.2 249.69,58.28 248.61,58.28 248.14,57.82 248.14,57.19 248.6,56.73 248.6,53.71 249.41,52.9 249.41,52.39 250.17,51.63 250.17,50.79 v1(250.56,50.41) ; v1(151.93,51.55) 151.44,51.06 149.54,51.06 147.44,48.97 146.46,48.97 145.94,48.45 144.56,48.45 144.05,48.97 143.44,48.97 138.52,53.89 134.83,53.89 v2(132.09,56.63) 130.51,58.21 117.83,58.21 116.3,59.74 JLID1.3
  IN1 w0.089: v1(151.93,51.55) 153.67,53.3 153.67,63.92 153.22,64.38 150.07,64.38 v1(149.26,65.19)
  IN3 w0.089: v1(231.59,48.63) 232.07,49.11 236.95,49.11 238.19,47.87 239.94,47.87 240.27,48.2 242.53,48.2 243.93,49.59 244.59,49.59 245.68,50.69 249.67,50.69 249.95,50.41 v1(250.56,50.41) ; v1(183.75,56.48) 181.82,56.48 179.24,59.06 170.77,59.06 170.48,58.77 166.5,58.77 166.15,59.12 159.7,59.12 154.11,64.7 154.11,64.74 153.99,64.87 149.59,64.87 v1(149.26,65.19)
  IN4 w0.089: v1(231.59,48.63) 231.25,48.97 226.15,48.97 225.81,49.31 216.55,49.31 215.94,49.92 202.38,49.92 198.42,53.89 188.83,53.89 186.12,56.6 184.39,56.6 184.27,56.48 v1(183.75,56.48) 183.75,57.76 183.36,58.15 183.35,58.15 183.11,58.38 183.11,59.38 177.23,65.27 177.23,72.63 180.43,75.83 180.43,85.18 179.77,85.84 179.77,87.49 179.64,87.62 179.08,87.62 v1(178.57,88.13)
  BOTTOM w0.108: v1(178.57,88.13) 178.47,88.23 JIOR1.39
LID_CL_SIO#: length 8.4
  TOP w0.108: v1(256.19,56.63) 256.19,56.6 256.17,56.58 U37.B54 ; v1(253.63,58.03) 253.38,58.28 C337.1 252.97,58.74 252.79,58.92 251.7,58.92 R325.1 R322.2
  BOTTOM w0.108: v1(256.19,56.63) 256.02,56.63 v2(255.41,57.24) 254.42,57.24 v1(253.63,58.03)
LID_DB_DET#: length 199
  TOP w0.108: U37.A55 254.75,54.33 254.18,53.76 v1(254.01,53.76) ; JLID1.1 115.3,60.16 117.66,57.8 129.45,57.8 v2(130.26,56.99) 133.74,53.51 138.61,53.51 143.35,48.76 143.96,48.76 144.48,48.24 146.03,48.24 146.54,48.76 147.69,48.76 149.64,50.71 151.14,50.71 v1(151.32,50.53) ; v1(249.24,53.96) 249.24,55.49 249.62,55.87 R9407.2
  IN1 w0.089: v1(249.36,24.25) 248.96,24.65 244.56,24.65 243.16,23.25 213.83,23.25 209.29,27.79 198.74,27.79 197.23,29.31 188.19,29.31 185.58,31.92 174.99,31.92 174.74,32.17 174.74,32.55 174.33,32.96 168.65,32.96 168.43,33.18 167.47,33.18 167.24,32.95 167.24,32.87 166.75,32.38 164.49,32.38 164.15,32.72 164.15,35.46 162.33,37.28 160.9,37.28 152.77,45.41 152.77,49.09 v1(151.32,50.53) ; v1(249.24,53.96) 249.64,54.36 253.41,54.36 v1(254.01,53.76)
  BOTTOM w0.108: v1(249.24,53.96) 249.49,53.71 249.49,50.58 249.13,50.22 249.13,46.48 248.92,46.27 248.92,43.99 249.8,43.11 249.8,40.67 249.51,40.37 249.51,34.86 249.98,34.39 249.98,26.74 249.72,26.48 249.72,25.92 249.98,25.66 249.98,24.87 v1(249.36,24.25)
LINE1_REF_L: length 6.4
  TOP w0.305: R9442.1 19.32,140.91 19.82,140.41 D2700.1
  TOP w0.381: D2700.1 21.62,141.47 v2(24.29,141.47)
LINE1_REF_R: length 3.2
  TOP w0.254: D2700.2 20.3,138.51 19.49,137.71 v2(18.76,137.71) 18.73,137.73 R2704.1
LOM_ACTLED_YEL#: length 18.3
  TOP w0.254: Q32.4 161.07,133.58 160.33,132.83 158.81,132.83 158.3,133.34 158.3,133.85 v1(157.92,134.23) ; U21.26 147.35,135.37 147.53,135.55 149.11,135.55 149.29,135.73 v1(149.29,136.03)
  IN2 w0.254: v1(149.29,136.03) 149.52,136.26 155.51,136.26 156.27,135.5 157.41,135.5 157.92,134.99 v1(157.92,134.23)
  BOTTOM w0.254: v2(158.63,134.23) v1(157.92,134.23)
LOM_LAN_WAKE#: length 4.3
  TOP w0.108: R9639.2 141.03,127.37 141.59,127.93 141.59,128.44 141.97,128.82 143.62,128.82 143.75,128.95 U21.2
LOM_SPD10LED_GRN#: length 17.8
  TOP w0.254: Q33.4 158.19,131.96 158.43,132.2 158.43,132.55 157.01,133.97 155.92,133.97 155.13,134.76 ; 155.13,134.76 v2(157.28,136.91) 157.47,137.11 U24.2 ; 155.13,134.76 152.92,134.76 152.39,135.29 149.57,135.29 149.27,134.99 U21.25
LOM_SPD100LED_ORG#: length 18.8
  TOP w0.254: U24.1 159.78,137.76 160.28,137.25 160.28,136.76 160.28,136.76 160.28,136.46 159.83,136.01 159.83,135.12 159.59,134.88 Q32.1 v2(157.82,134.88) 157.18,134.88 v1(157.16,134.86) ; U21.27 146.95,135.7 147.31,136.06 v1(148.68,136.06)
  IN2 w0.254: v1(157.16,134.86) 156.91,135.12 156.02,135.12 155.26,135.88 150.07,135.88 149.72,135.52 148.88,135.52 148.65,135.75 148.65,136.03 v1(148.68,136.06)
LPC_LAD0: length 189.1
  TOP w0.108: U37.A27 266.28,54.83 v1(266.39,54.73) ; v1(265.87,38.34) 265.22,37.69 U6202.6 ; v1(267.27,40.25) 267.27,42.14 267.4,42.27 U26.27 ; v3(140.98,77.56) 140.6,77.94 139.76,77.94 139.23,77.41 138.61,77.41 138.53,77.33 JDEG2.2 ; v1(240.71,59.83) 240.71,59.62 240.47,59.38 U38.A30
  IN3 w0.089: v1(266.39,54.73) 265.21,54.73 264.5,54.01 263.39,54.01 262.93,54.48 258.14,54.48 257.71,54.91 255.88,54.91 255.37,55.42 251.02,55.42 249.72,56.73 248.1,56.73 247.08,57.75 245.07,57.75 243.67,59.15 243.67,59.46 243.3,59.83 v1(240.71,59.83) 240.23,60.31 239.28,60.31 238.09,61.51 228.24,61.51 227.64,60.91 226.38,60.91 225.64,60.17 223.45,60.17 223.19,59.91 219.42,59.91 217.1,57.6 208.44,57.6 207.01,56.17 190.13,56.17 188.16,58.14 188.16,59.26 186.62,60.8 185.31,60.8 183.15,62.96 181.96,62.96 176.83,68.09 175.32,68.09 171.49,71.91 166.31,71.91 165.12,73.1 158.14,73.1 157,74.24 153.4,74.24 152.58,75.07 149.54,75.07 147.35,77.25 143.9,77.25 142.84,78.32 141.26,78.32 140.98,78.04 v3(140.98,77.56)
  IN4 w0.089: v1(265.87,38.34) 265.87,38.85 v1(267.27,40.25) 267.64,40.25 271.08,43.69 271.08,46.98 268.58,49.48 268.58,54.33 267.89,55.02 266.68,55.02 v1(266.39,54.73)
  BOTTOM w0.076: v3(140.98,77.56) 140.98,77.18 140.76,76.96 134.6,76.96 134.17,77.39 132.25,77.39 131.15,78.49 131.15,78.49 130.46,79.18 130.46,79.18 130.45,79.19 130.45,79.72 130.26,79.91 130.26,80.19 130.29,80.27 130.29,80.52 130.26,80.65 130.26,80.82 130.32,81 130.42,81.12 130.53,81.23 UC1.AY13
  BOTTOM w0.108: v2(267.27,40.91) v1(267.27,40.25)
LPC_LAD1: length 187.4
  TOP w0.108: v3(139.84,77.48) 139.63,77.48 139.53,77.38 JDEG2.4 ; U26.24 268.57,43.92 268.42,44.07 268.31,44.07 v1(268.03,43.79) ; U37.A26 266.09,54.33 266.63,53.79 v1(266.63,53.72) ; U6202.7 v1(264.72,37.71) ; v1(239.62,61.2) 238.64,61.2 238.22,60.78 238.22,60.52 237.95,60.26 237.48,60.26 237.35,60.13 237.35,59.6 237.53,59.42 238.08,59.42 238.29,59.63 U38.B32
  IN3 w0.089: v3(139.84,77.48) 139.84,77.79 140.65,78.6 142.94,78.6 143.84,77.7 147.38,77.7 149.79,75.28 152.67,75.28 153.49,74.46 157.09,74.46 157.49,74.05 164.6,74.05 166.52,72.13 171.63,72.13 174.05,69.71 175.66,69.71 182.19,63.18 183.24,63.18 185.4,61.02 186.71,61.02 188.41,59.31 188.41,58.19 190.22,56.38 206.92,56.38 208.36,57.82 216.79,57.82 220.17,61.19 226.22,61.19 226.9,61.88 238.94,61.88 v1(239.62,61.2) 240.12,60.69 241.06,60.69 241.59,60.16 243.44,60.16 245.02,58.59 247.41,58.59 248.09,57.9 248.09,57.24 248.34,56.99 251.88,56.99 252.05,57.16 256.23,57.16 256.6,56.78 256.6,55.97 257.44,55.13 257.8,55.13 258.11,54.82 262.19,54.82 262.37,55 264.72,55 265.06,55.33 266.56,55.33 266.79,55.11 266.79,54.56 266.63,54.41 v1(266.63,53.72)
  IN4 w0.089: v1(264.72,37.71) 264.33,38.1 264.33,39.4 264.59,39.66 265.74,39.66 268.03,41.95 v1(268.03,43.79) 268.2,43.79 268.81,44.4 268.81,45.26 267.78,46.29 267.78,53.2 267.27,53.72 v1(266.63,53.72)
  BOTTOM w0.076: UC1.BA13 130.53,80.53 130.79,80.26 130.79,79.32 131.48,78.63 131.48,78.62 132.37,77.73 134.31,77.73 134.75,77.29 139.64,77.29 v3(139.84,77.48)
  BOTTOM w0.108: v2(263.67,38.76) v1(264.72,37.71)
LPC_LAD2: length 182.5
  TOP w0.076: v3(140.4,77.56) 140.53,77.43 JDEG2.6
  TOP w0.108: v1(240.09,59.83) 240.04,59.88 U38.A31 ; U6202.8 264.22,38.22 264.34,38.34 v1(264.73,38.34) ; U26.21 270.07,44.48 v1(270.13,44.54) ; U37.B26 264.7,53.58 264.49,53.79 264.12,53.79 v1(263.71,53.38)
  IN3 w0.089: v3(140.4,77.56) 140.83,77.13 141.13,77.13 141.36,77.36 141.36,77.9 141.46,78 142.77,78 143.97,76.81 147.3,76.81 149.26,74.85 152.49,74.85 153.31,74.03 156.91,74.03 158.05,72.89 165.03,72.89 166.22,71.7 171.4,71.7 175.23,67.87 176.74,67.87 181.87,62.75 183.06,62.75 185.22,60.58 186.53,60.58 187.87,59.24 187.87,58.12 190.04,55.95 207.1,55.95 208.53,57.39 217.45,57.39 219.72,59.66 223.24,59.66 223.54,59.96 228.41,59.96 229.74,61.29 237.87,61.29 239.33,59.83 v1(240.09,59.83) 240.09,59.3 240.22,59.17 242.55,59.17 243.06,58.66 243.67,58.66 244.8,57.53 246.99,57.53 248.08,56.43 249.7,56.43 250.93,55.21 255.23,55.21 255.74,54.7 257.62,54.7 258.05,54.26 262.84,54.26 v1(263.71,53.38)
  IN4 w0.089: v1(264.73,38.34) 270.13,43.74 v1(270.13,44.54) 268.18,46.48 268.18,47.15 268.14,47.19 268.14,47.52 268.18,47.57 268.18,48.42 268.01,48.59 268.01,48.92 268.18,49.09 268.18,53.66 267.73,54.12 265.87,54.12 264.74,52.98 264.11,52.98 v1(263.71,53.38)
  BOTTOM w0.076: v3(140.4,77.56) 140.4,77.23 140.29,77.12 134.69,77.12 134.26,77.55 132.32,77.55 131.32,78.56 131.32,78.56 130.62,79.26 130.62,79.8 130.53,79.89 UC1.BB13
  BOTTOM w0.108: v1(264.73,38.34) 265,38.61 265.17,38.61 v2(265.56,38.99)
LPC_LAD3: length 189
  TOP w0.108: v1(272.29,44.85) 271.67,44.85 271.07,44.25 U26.19 ; v1(237.75,59.83) 238.01,59.83 238.31,60.13 U38.B33 ; v1(264.32,53.38) 264.63,53.08 U37.B25 ; v1(141.77,77.51) 141.53,77.27 JDEG2.8 ; U6202.9 v1(263.72,37.64)
  IN3 w0.089: v1(264.32,53.38) 263.92,52.98 263.24,52.98 262.18,54.05 257.96,54.05 257.53,54.48 255.63,54.48 255.12,54.99 250.59,54.99 249.37,56.21 248,56.21 246.9,57.31 242.39,57.31 240.9,58.8 238.78,58.8 v1(237.75,59.83) 237.23,59.3 231.08,59.3 230.86,59.09 229.15,59.09 228.51,59.73 223.61,59.73 223.33,59.44 219.81,59.44 217.54,57.17 208.62,57.17 207.19,55.73 189.95,55.73 187.57,58.11 187.57,59.23 186.44,60.37 185.13,60.37 183.03,62.47 181.84,62.47 176.65,67.65 175.14,67.65 171.31,71.48 166.13,71.48 164.94,72.67 157.96,72.67 156.82,73.81 153.22,73.81 152.42,74.61 145.78,74.61 142.89,77.51 v1(141.77,77.51)
  IN4 w0.089: v1(264.32,53.38) 266.17,55.23 268.18,55.23 268.79,54.62 268.79,49.57 271.46,46.9 271.46,45.67 v1(272.29,44.85) 272.29,41.71 267.4,36.82 264.54,36.82 v1(263.72,37.64)
  BOTTOM w0.076: UC1.AY12 131.1,81.52 130.78,81.2 130.78,80.91 130.96,80.73 130.96,79.39 131.65,78.7 131.65,78.69 132.41,77.93 134.35,77.93 134.82,77.45 139.3,77.45 139.8,77.96 140.91,77.96
  BOTTOM w0.108: v1(141.77,77.51) 141.32,77.96 140.91,77.96 ; v2(263.59,36.87) 263.72,37 v1(263.72,37.64)
LPC_LDRQ1#: length 3.6
  TOP w0.108: v1(266.38,52.22) 266.27,52.33 U37.A22 ; v1(267.14,50.79) 267.69,51.33 RP4807.7
  BOTTOM w0.108: v1(267.14,50.79) 267.14,51.46 v2(267.07,51.53) v1(266.38,52.22)
LPC_LFRAME#: length 188
  TOP w0.108: U6202.11 v1(262.72,37.64) ; U26.23 269.07,44.38 268.88,44.57 v1(268.41,44.57) ; v1(237.66,58.59) 238.2,59.13 U38.B31 ; JDEG2.10 142.53,75.76 143.17,75.12 143.17,74.38 142.86,74.08 140.27,74.08 139.56,74.79 138.24,74.79 137.73,75.3 137.73,77.21 138.33,77.81 v3(139.05,77.81) ; v1(266.38,51.61) 266.16,51.83 U37.A21
  IN3 w0.089: v1(266.38,51.61) 265.81,52.18 263.26,52.18 262.33,53.12 258.28,53.12 257.14,54.27 255.54,54.27 255.03,54.77 250.5,54.77 249.35,55.93 247.97,55.93 247.41,56.48 242.91,56.48 240.8,58.59 v1(237.66,58.59) 237.15,59.09 231.17,59.09 230.95,58.87 229.06,58.87 228.42,59.51 223.7,59.51 223.42,59.23 219.9,59.23 217.63,56.95 208.71,56.95 207.28,55.52 189.86,55.52 187.36,58.02 187.36,59.14 186.35,60.15 185.04,60.15 183.1,62.09 181.57,62.09 176.24,67.43 175.07,67.43 171.22,71.27 166.02,71.27 164.83,72.45 157.87,72.45 156.73,73.6 153.14,73.6 152.34,74.4 145.69,74.4 144.74,75.35 143.65,75.35 142.59,76.4 139.98,76.4 139.05,77.33 v3(139.05,77.81)
  IN4 w0.089: v1(262.72,37.64) 263.92,38.84 263.92,39.51 264.37,39.97 265.74,39.97 267.59,41.81 267.59,44.12 268.03,44.57 v1(268.41,44.57) 268.41,45.2 267.54,46.07 267.54,49.75 266.38,50.92 v1(266.38,51.61)
  BOTTOM w0.076: UC1.BA12 131.12,81.03 131.12,79.46 131.81,78.77 131.81,78.76 132.48,78.1 134.42,78.1 134.89,77.62 138.86,77.62 v3(139.05,77.81)
  BOTTOM w0.108: v2(261.91,37.61) 262.69,37.61 v1(262.72,37.64)
LX_1VS_VCCIO: length 3.4
  BOTTOM w0.254: v2(175.07,82.41) 175.07,82.13 174.2,81.27 PL5601.1
LX_+1VALWP: length 11
  TOP w0.508: PR5503.2 138.83,120.48 v2(139.03,120.28)
  IN1 w0.508: v1(133.67,123.18) 134.55,123.18 134.86,123.48 134.86,126.28 132.91,128.23 132.29,128.23 131.63,128.89 v1(130.34,128.89)
  vias: v2(134.12,122.62) v2(136,122.57)
M_CLK_DDR0: length 53.2
  IN4 w0.102: v3(107.29,83.5) 106.92,83.13 106.92,80.69 108.95,78.65 108.95,75.35 108.74,75.13 108.74,67.44 108.02,66.73 108.02,56.43 112,52.46 112,49.05 112.22,48.83 112.83,48.83 112.96,48.7 112.96,48.33 112.83,48.2 112.22,48.2 112,47.98 112,47.55 113.43,46.12 113.43,43.67 114.56,42.53 115.24,42.53 115.5,42.79 115.5,43.78 115.61,43.88 v1(116.01,43.88)
  BOTTOM w0.102: JDIMM1.137 115.26,44.04 115.43,43.88 v1(116.01,43.88) ; UC1.AT53 107.4,83.5 v3(107.29,83.5)
M_CLK_DDR1: length 53
  IN4 w0.102: v1(116.01,41.76) 114.33,41.76 112.72,43.38 112.72,45.79 111.29,47.21 111.29,48.05 110.96,48.38 110.96,52.49 107.31,56.14 107.31,67.02 108.03,67.73 108.03,75.51 108.5,75.99 108.5,78.37 105.87,81 105.87,83.5 105.89,83.52 105.89,83.68 v3(106.38,84.17)
  BOTTOM w0.102: v3(106.38,84.17) 106.51,84.17 UC1.AT55 ; JDIMM1.138 115.51,39.42 115.68,39.59 115.68,40.65 116.22,41.19 116.22,41.56 v1(116.01,41.76)
M_CLK_DDR2: length 68.5
  IN1 w0.076: v3(111.87,84.8) 111.79,84.8 111.5,84.51 111.5,82.52 111.48,82.51 111.48,81.83 111.5,81.82 111.5,81.78 111.52,81.75 111.52,81.74
  IN1 w0.102: 111.52,81.74 111.52,80.92 112.02,80.42 112.02,75.55 112.39,75.18 112.39,70.09 112.85,69.62 112.85,56.65 115.6,53.9 116.07,53.9 116.29,53.68 116.29,53.21 116.07,52.98 115.4,52.98 115.27,52.86 115.27,52.58 115.37,52.48 116.2,52.48 116.42,52.26 116.42,51.78 116.2,51.56 115.32,51.56 115.22,51.46 115.22,51.16 115.32,51.05 116.15,51.05 116.42,50.79 116.42,50.39 116.17,50.14 115.33,50.14 115.23,50.04 115.23,49.62 115.59,49.26 115.59,48.45 115.23,48.09 115.23,47.86 114.84,47.48 114.84,46.86 115.03,46.67 115.34,46.67 115.6,46.93 116.09,46.93 116.29,46.72 116.29,46.14 116.88,45.56 116.88,43.56 117.26,43.18 117.26,39.51 116.9,39.15 116.9,35.66 117.34,35.23 117.34,31.43 117.01,31.1 116.87,31.1 v1(116.52,30.75)
  BOTTOM w0.102: JDIMM2.137 115.27,32.38 115.41,32.23 115.41,31.29 115.78,30.93 116.34,30.93 v1(116.52,30.75) ; UC1.AP45 v3(111.87,84.8)
M_CLK_DDR3: length 67.6
  IN1 w0.076: v3(110.94,84.8) 111.36,85.22 111.36,85.44 111.75,85.83 112.01,85.83 112.24,85.59 112.24,82.43 112.04,82.23 112.04,81.33 112.32,81.05 112.32,80.57 112.3,80.55 112.3,80.51 112.28,80.49 112.28,80.48
  IN1 w0.102: 112.28,80.48 112.28,75.77 112.89,75.16 112.89,70.3 113.36,69.83 113.36,57.33 117.23,53.46 117.23,46.69 117.94,45.98 117.94,38.43 117.41,37.89 117.41,35.87 117.84,35.44 117.84,29.89 117.33,29.38 117.1,29.38 v1(116.9,29.58)
  BOTTOM w0.102: v1(116.9,29.58) 116.68,29.36 116.47,29.36 116.3,29.36 115.66,28.72 115.66,28.47 115.66,28.47 115.66,26.33 115.52,26.18 JDIMM2.138 ; UC1.AP46 v3(110.94,84.8)
M_CLK_DDR#0: length 53.1
  IN4 w0.102: v1(116.01,44.49) 115.61,44.08 115.52,44.08 115.3,43.86 115.3,42.88 115.16,42.74 114.65,42.74 113.63,43.75 113.63,46.21 112.2,47.64 112.2,47.89 112.3,47.99 112.91,47.99 113.17,48.25 113.17,48.78 112.91,49.04 112.3,49.04 112.2,49.14 112.2,52.54 108.23,56.52 108.23,66.64 108.94,67.35 108.94,75.05 109.16,75.27 109.16,78.74 107.12,80.77 107.12,82.31 107.22,82.41 107.55,82.41 107.65,82.51 107.65,82.76 107.55,82.87 v3(107.29,82.87)
  BOTTOM w0.102: v1(116.01,44.49) 115.84,44.49 115.74,44.39 115.74,44.18 115.64,44.08 115.51,44.08 115.47,44.13 115.47,45.5 115.57,45.6 115.66,45.6 115.76,45.7 JDIMM1.139 ; UC1.AU53 107.53,83.2 107.29,82.96 v3(107.29,82.87)
M_CLK_DDR#1: length 53.1
  IN4 w0.102: v1(116.01,42.37) 115.8,42.37 115.7,42.27 115.7,42.06 115.59,41.96 114.42,41.96 112.92,43.46 112.92,45.87 111.49,47.3 111.49,48.13 111.16,48.46 111.16,52.57 107.52,56.22 107.52,66.94 108.23,67.65 108.23,75.43 108.7,75.9 108.7,78.45 106.08,81.08 106.08,83.42 106.19,83.54 v3(106.39,83.54)
  BOTTOM w0.102: v3(106.39,83.54) 106.5,83.54 UC1.AU55 ; v1(116.01,42.37) 116.42,41.96 116.42,41.1 115.89,40.57 115.89,39.57 116.01,39.44 JDIMM1.140
M_CLK_DDR#2: length 68.4
  IN1 w0.076: v3(111.86,85.43) 111.51,85.08 111.51,84.76 111.33,84.58 111.33,82.59 111.32,82.58 111.32,81.74
  IN1 w0.102: v1(116.52,31.38) 116.6,31.31 116.93,31.31 117.13,31.51 117.13,35.14 116.7,35.58 116.7,39.24 117.05,39.59 117.05,43.09 116.67,43.47 116.67,45.47 116.09,46.06 116.09,46.64 116,46.72 115.68,46.72 115.43,46.47 114.95,46.47 114.64,46.77 114.64,47.56 115.02,47.94 115.02,48.17 115.39,48.54 115.39,49.17 115.02,49.54 115.02,50.12 115.24,50.34 116.09,50.34 116.22,50.47 116.22,50.7 116.07,50.85 115.24,50.85 115.02,51.07 115.02,51.55 115.24,51.77 116.11,51.77 116.22,51.87 116.22,52.17 116.11,52.27 115.29,52.27 115.07,52.49 115.07,52.94 115.31,53.19 115.99,53.19 116.09,53.29 116.09,53.59 115.99,53.7 115.52,53.7 112.65,56.57 112.65,69.54 112.18,70 112.18,75.1 111.81,75.47 111.81,80.34 111.32,80.83 111.32,81.74
  BOTTOM w0.102: UC1.AN45 v3(111.86,85.43) ; v1(116.52,31.38) 116.26,31.13 115.86,31.13 115.62,31.37 115.62,32.23 115.77,32.38 JDIMM2.139
M_CLK_DDR#3: length 67.6
  IN1 w0.076: 112.48,80.48 112.48,81.12 112.2,81.4 112.2,82.16 112.41,82.36 112.41,85.66 112.08,85.99 111.68,85.99 111.1,85.41 v3(110.96,85.41)
  IN1 w0.102: 112.48,80.48 112.48,75.86 113.1,75.24 113.1,70.38 113.56,69.92 113.56,57.42 117.43,53.54 117.43,46.77 118.15,46.06 118.15,38.34 117.61,37.81 117.61,35.96 118.05,35.52 118.05,29.8 117.42,29.17 117.13,29.17 v1(116.9,28.94)
  BOTTOM w0.102: UC1.AN46 v3(110.96,85.41) ; JDIMM2.140 116.02,26.18 115.87,26.33 115.87,28.55 115.87,28.64 116.39,29.16 116.69,29.16 v1(116.9,28.94)
MASK_BASE_LEDS#: length 251.2
  TOP w0.108: v1(257.14,57.44) 257.44,57.44 257.78,57.79 U37.B48 ; Q28.2 v1(265.24,11.42) ; Q25.2 Q25.5 271.84,13.72 271.57,13.99 268.5,13.99 268.21,14.29 v2(267.42,14.29) 266.94,14.29 266.65,13.99 261.08,13.99 v1(260.79,13.7) ; R310.2 v1(255.71,60.64)
  TOP w0.254: Q33.5 158.56,131.31 158.81,131.56 158.81,131.94 159.32,132.45 160.72,132.45 v1(161.1,132.83) 161.35,133.08 162.06,133.08 162.24,133.26 162.24,134.13 162.14,134.23 Q32.5 161.1,134.23 160.98,134.35 160.21,134.35 160.08,134.23 Q32.2
  IN1 w0.254: v1(161.1,132.83) 160.59,132.32 160.59,131.69 161.73,130.54 161.73,129.4 162.11,129.02 162.11,125.28 163.32,124.07 163.77,124.07 164.28,124.07 167.41,120.94 167.88,120.48 167.88,119.4 169.52,117.75 169.78,117.49 169.78,106.1 171.75,104.13 172.76,104.13 174.69,102.2 174.69,100.05 175.28,99.45 177.66,99.45 179.23,97.88 v1(179.23,97.74)
  IN2 w0.089: v1(180.5,92.23) 180.08,91.82 180.08,84.86 181.7,83.24 181.7,71.86 183.93,69.63 183.93,65.68 186.68,62.93 186.77,62.93 190.14,59.56 194.1,59.56 196.68,56.98 204.44,56.98 205.81,58.35 205.81,58.87 206.67,59.73 212.72,59.73 213.55,58.9 217.5,58.9 221.92,63.32 226.59,63.32 227.18,63.91 243.98,63.91 247.2,60.7 251.74,60.7 252.16,60.29 252.72,60.29 253.46,61.03 255.33,61.03 v1(255.71,60.64)
  IN4 w0.089: v1(260.79,13.7) 262.03,14.94 262.03,17.8 256.22,23.61 256.22,33.8 255.21,34.81 255.21,37.64 255.53,37.96 255.53,40.05 255,40.58 255,45.87 254.53,46.34 254.53,48.85 255.29,49.61 255.29,53.74 256.66,55.11 256.66,56.96 v1(257.14,57.44)
  BOTTOM w0.108: v1(180.5,92.23) 180.5,92.27 180.45,92.23 JIOR1.31 ; v1(260.79,13.7) 264.78,13.7 265.24,13.25 v1(265.24,11.42) ; v1(255.71,60.64) 255.03,59.96 255.03,59.55 v1(257.14,57.44)
  BOTTOM w0.254: v1(179.23,97.74) 179.73,97.24 180.41,97.24 180.66,97 180.66,95.62 180.5,95.46 180.5,92.27
MASK_BAT_LEDS#: length 61.8
  TOP w0.108: U37.A46 257.53,59.15 256.47,60.22 v1(256.2,60.22) 254.91,60.22 254.52,60.61 254.52,60.77 254.09,61.2 254.09,61.41 R9684.2 ; Q23.5 v1(260.79,11.95) Q23.2
  IN4 w0.089: v1(260.79,11.95) 262.21,13.37 262.21,18.13 258.46,21.88 258.46,26.36 258.67,26.57 258.67,27.36 257.88,28.15 257.88,31.21 259.31,32.64 259.31,34.87 259.1,35.08 259.1,40.52 258.77,40.85 258.77,45.68 259,45.91 259,48.38 259.49,48.88 259.49,56.18 258.27,57.4 258.27,58.15 v1(256.2,60.22)
  BOTTOM w0.108: v2(256.2,59.32) v1(256.2,60.22)
MASK_SATA_LED#: length 34.4
  TOP w0.254: v1(260.26,49.55) 260.26,49.39 260.28,49.36 U37.B9 ; Q3602.5 261.15,19.89 v1(261.69,20.43)
  IN4 w0.254: v1(260.26,49.55) 260.86,48.95 260.86,46.69 259.37,45.2 259.37,41.1 259.7,40.77 259.7,35.85 260.87,34.68 260.87,32.26 259.76,31.15 259.76,25.58 260.41,24.93 260.41,21.71 v1(261.69,20.43)
ME_FW_EC: length 163.3
  TOP w0.108: RC401.1 v1(185.9,119.28) 185.9,118.77 186.03,118.65 JFWP1.1 ; v1(254.27,49.47) 254.27,49.52 254.59,49.83 U37.A64
  IN1 w0.089: v1(185.9,119.28) 186.24,118.94 186.24,107.89 185.53,107.18 185.53,80.93 181.6,77.01 181.6,66.33 187.83,60.1 187.83,58.13 191.09,54.87 191.09,51.78 190.87,51.57 190.87,49.32 191.69,48.5 194.35,48.5 194.79,48.05 205.55,48.05 206.18,48.68 217.88,48.68 219.11,49.91 219.11,56.03 221.01,57.92 225.09,57.92 225.5,57.51 227.21,57.51 227.73,56.99 228.26,56.99 228.68,57.41 236.05,57.41 236.78,58.14 238.47,58.14 239.13,57.48 247.24,57.48 248.04,56.68 251.65,56.68 252.12,57.16 254.35,57.16 256.17,55.33 v1(256.18,55.33)
  IN4 w0.089: v1(254.27,49.47) 254.27,49.52 255.08,50.33 255.08,54.24 v1(256.18,55.33)
  BOTTOM w0.108: v1(256.18,55.33) 255.46,55.33 v2(255.36,55.44)
ME_FWP: length 107.2
  TOP w0.108: v1(184.47,119.39) 184.8,119.72 184.8,120.55 184.93,120.69 RC401.2 185.81,121.15 JFWP1.2 ; RC9.1 137.73,66.79 140.81,69.87 141.26,69.87 142.36,70.97 144.16,70.97 145.42,69.71 145.76,69.71 v1(146.37,69.1)
  IN1 w0.089: v1(184.47,119.39) 183.96,118.89 183.96,118.42 185.35,117.02 185.35,108.26 184.64,107.54 184.64,84.11 184.08,83.55 183.14,83.55 v1(182.69,83.1) ; v1(146.37,69.1) 146.67,69.1 147.28,68.49 155.46,68.49 156.88,69.91 156.88,73.24 158.94,75.3 158.94,76.9 160.31,78.26 160.31,78.4 v1(161.63,79.72)
  IN3 w0.089: v1(182.69,83.1) 182.13,83.66 176.42,83.66 174.66,81.9 168.34,81.9 168.01,82.23 163.64,82.23 163.1,82.78 160.34,82.78 159.88,82.32 159.88,80.17 160.34,79.72 v1(161.63,79.72)
  BOTTOM w0.108: v2(147.1,69.1) v1(146.37,69.1)
