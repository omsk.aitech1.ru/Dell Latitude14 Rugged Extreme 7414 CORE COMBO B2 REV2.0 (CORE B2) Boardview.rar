# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SATA_LED#: length 229.1
  TOP w0.108: Q3602.4 v1(261.8,19.6)
  IN2 w0.089: v1(269.94,56.43) 269.17,57.19 268.6,57.19 267.05,58.74 261.18,58.74 260.9,59.02 258.3,59.02 258.28,59 252.18,59 252.17,59.02 249.34,59.02 246.8,56.48 244.68,56.48 243.69,57.48 239.62,57.48 237.94,59.16 236.92,59.16 236.9,59.14 232.37,59.14 232.36,59.13 232.18,59.13 231.96,58.91 229.48,58.91 228.8,59.6 225.72,59.6 224.41,58.29 221.79,58.29 221.38,57.88 220.59,57.88 220.46,57.75 213.07,57.75 212.94,57.87 210.72,57.87 210.48,58.12 210.48,58.37 210.21,58.63 208.94,58.63 206.38,56.07 195.43,56.07 194.59,56.91 191.2,56.91 189.75,58.36 188.87,58.36 185.68,61.55 184.53,61.55 179.94,66.13 179.94,83.41 179,84.35 179,85.82 178.65,86.17 178.55,86.17 177.53,87.19 177.53,92.22 177.53,92.51 173.15,96.9 173.04,97 172.84,97.21 169.22,97.21 169.22,97.21 169.02,97.21 168.87,97.21 168.73,97.21 167.67,96.15 163.51,96.15 161.82,97.84 158.16,97.84 156.95,96.64 155.99,96.64 154.98,97.65 151.8,97.65 150.29,99.16 143.62,99.16 139.5,103.28 139.5,103.42 v3(139.13,103.8)
  IN3 w0.089: v1(269.94,56.43) 270.06,56.3 270.06,54.77 270.97,53.86 270.97,51.6 269.69,50.32 269.69,46.22 268.94,45.47 268.94,43.91 269.24,43.61 269.24,29.53 267.32,27.6 267.32,23.22 264.74,20.64 262.84,20.64 v1(261.8,19.6)
  BOTTOM w0.076: v3(139.13,103.8) 139.65,103.28 139.65,100.4 138.49,99.24 138.49,98.91 138.11,98.54 UC1.H1
  BOTTOM w0.108: v2(270.62,56.43) v1(269.94,56.43) ; v3(139.13,103.8) 138.62,104.31 138.62,106.87 139.07,107.32 139.07,107.69 139.08,107.7 139.08,108.29 RC314.1
PCH_SMB_ALERT#: length 19.6
  IN3 w0.089: v1(146.89,96.05) 145.12,94.29 144.74,94.29 143.25,92.8 141.16,92.8 140.9,92.55 132.07,92.55 131.71,92.9 131.71,93.72 v3(132.27,94.28)
  BOTTOM w0.076: v3(132.27,94.28) 132.27,94.27 132.51,94.51 UC1.R10
  BOTTOM w0.108: v1(146.89,96.05) 147.23,96.05 RC347.1
PCH_SPI_CLK: length 136
  TOP w0.108: v1(190.08,138.8) 190.13,138.85 v2(190.74,138.85)
  IN1 w0.089: v1(156.9,123.58) 156.38,123.06 156.38,116.82 163.99,109.21 163.99,107.16 163.09,106.26 163.09,104.12 161.78,102.81 161.78,100.77 161.4,100.38 161.4,99.19 159.91,97.69 159.66,97.69 159.15,97.19 159.15,96.47 156.68,94 156.68,93.53 156.02,92.86 153.15,92.86 150.9,90.62 149.49,90.62 148.91,90.03 148.27,90.03 146.09,87.85 142.38,87.85 141.31,86.78 141.31,86.4 140.57,85.66 v3(140.57,84.24)
  IN3 w0.089: v1(156.9,123.58) 157.33,124.01 159.61,124.01 162.6,121.03 182.65,121.03 185.18,123.56 185.18,136.24 186.61,137.66 186.61,139.03 186.86,139.28 188.48,139.28 188.96,138.8 v1(190.08,138.8)
  BOTTOM w0.076: v3(140.57,84.24) 140.98,83.83 140.98,83.58 140.42,83.01 138.22,83.01 138.07,82.86 137.15,82.86 UC1.AV2
  BOTTOM w0.108: v1(156.9,123.58) 156.72,123.58 156.52,123.38 156.52,122.44 R9503.2 157.19,121.78 157.19,120.51 157.48,120.22 157.48,117.34 157.35,117.21 155,117.21 154.54,117.67 154.54,120.13 153.25,121.42 150.51,121.42 149.75,120.67 147.66,120.67 147.35,120.35 R9510.2 ; R9522.2 190.08,139 v1(190.08,138.8)
PCH_SPI_CLK_0_R: length 3.6
  BOTTOM w0.108: JSPI1.6 156.85,120.03 156.43,120.45 156.43,121.03 R9503.1 R57.2
PCH_SPI_CLK_1_R: length 6
  BOTTOM w0.108: U2.6 148.02,118.86 147.36,119.51 146.97,119.51 R9510.1 R45.2 145.17,120.49 144.38,120.49 144.11,120.21 v2(143.88,120.21)
PCH_SPI_CLK_2_R: length 3.2
  BOTTOM w0.108: R9522.1 190.46,141.14 v2(190.49,141.16) 190.56,141.24 190.56,141.94 191.06,142.44 U25.19
PCH_SPI_CS#0: length 41.5
  IN1 w0.089: v3(138.36,83.94) 137.36,84.94 137.36,88.11 139.15,89.9 143.44,89.9 144.19,90.65 144.19,91.94 145.02,92.77 145.02,93.89 146.54,95.42 147.17,95.42 148.5,96.75 151.89,96.75 151.89,96.75 153,96.75 157.71,101.46 v1(158.76,101.46)
  IN3 w0.089: v1(158.76,101.46) 158.81,101.51 158.81,104.81 159.7,105.7 v7(159.7,106.8)
  BOTTOM w0.076: UC1.AU3 136.81,83.56 137.33,83.56 137.43,83.6 137.51,83.63 137.72,83.73 138.16,83.73 v3(138.36,83.94)
  BOTTOM w0.108: R9512.1 159.54,106.95 v7(159.7,106.8)
PCH_SPI_CS#0_R: length 2.6
  BOTTOM w0.108: JSPI1.1 159.39,109.52 159.54,109.36 R9512.2
PCH_SPI_CS#1: length 49
  TOP w0.108: v2(156.81,107.19) v1(157.46,107.19)
  IN1 w0.089: v1(157.46,107.19) 157.46,101.51 152.91,96.97 151.8,96.97 151.8,96.96 148.41,96.96 147.09,95.64 146.37,95.64 144.63,93.9 144.63,92.77 143.97,92.11 143.97,90.79 143.32,90.13 139.12,90.13 137.18,88.19 137.18,84.61 138.21,83.57 138.56,83.57 v3(138.92,83.94)
  BOTTOM w0.076: v3(138.92,83.94) 138.54,83.56 137.74,83.56 137.56,83.47 137.5,83.44 UC1.AU2
  BOTTOM w0.108: v1(157.46,107.19) 157.27,107 156.21,107 155.74,107.48 155.74,108.19 155.57,108.35 153.72,108.35 152.47,109.61 152.47,110.05 R9513.1
PCH_SPI_CS#1_R: length 6.5
  BOTTOM w0.108: v2(150.4,107.15) 150.4,108.07 150.56,108.22 U2.1 150.56,111.7 150.83,111.97 151.41,111.97 R9513.2
PCH_SPI_CS#2: length 118
  IN1 w0.089: v1(156.31,97.42) 155.42,96.53 151.98,96.53 151.98,96.53 151.47,96.53 150.84,95.9 150.13,95.9 v1(149.69,96.34) 149.23,95.87 148.6,95.87 147.81,95.09 146.7,95.09 145.27,93.66 145.27,92.57 144.56,91.86 144.56,90.41 143.24,89.09 138.58,89.09 137.58,88.08 137.58,84.97 138.17,84.38 139.04,84.38 v3(139.48,83.94)
  IN3 w0.089: v1(189.75,139.56) 189.75,140.2 189.35,140.6 186.48,140.6 185.57,139.68 185.57,137.78 184.37,136.58 184.37,127.72 183.38,126.72 183.38,122.9 182.57,122.1 174.9,122.1 174.72,122.1 174.46,121.84 163.25,121.84 159.99,125.1 159.81,125.1 156.4,125.1 155.66,124.35 155.66,122.16 157.47,120.36 157.47,110.55 157.01,110.1 157.01,108.55 156.78,108.32 156.78,97.89 v1(156.31,97.42)
  BOTTOM w0.076: UC1.AU1 137.95,83.39 138.94,83.39 v3(139.48,83.94)
  BOTTOM w0.108: v2(190.76,137.76) 190.34,138.18 190.03,138.18 189.46,138.75 189.46,139.28 v1(189.75,139.56) 189.75,140.12 R9521.2 ; RC622.1 150.58,95.92 150.11,95.92 v1(149.69,96.34)
PCH_SPI_CS#2_R: length 29.6
  TOP w0.108: v1(189.01,139.74) 189.47,140.2 R9531.2 187.94,148.08 187.94,148.88 188.24,149.19 190.71,149.19 191.14,148.77 Q4200.1
  IN1 w0.089: v1(189.01,139.74) 189.01,140.1 194.19,145.28 v1(195.64,145.28)
  BOTTOM w0.108: v2(188.68,138.32) 189.01,138.65 v1(189.01,139.74) 189.01,140.75 R9521.1 189.49,141.75 190.56,142.81 U25.20 ; R9545.1 v1(195.64,145.28)
PCH_SPI_CS#2_R1: length 4
  TOP w0.108: R9531.1 187.72,146.55 187.45,146.81 Q4199.1 186.34,148.06 v2(186.07,147.79)
PCH_SPI_D0: length 245.5
  IN1 w0.089: v1(79.77,126.35) 80.27,126.86 83.02,126.86 84.44,125.44 85.63,125.44 85.99,125.08 92.59,125.08 92.96,124.72 92.96,123.37 93.45,122.88 94.59,122.88 95.82,124.11 95.82,126.23 100.65,131.05 102.17,131.05 103.01,131.89 104.18,131.89 105.27,132.98 105.27,133.83 105.92,134.48 107.45,134.48 108.38,135.41 113.63,135.41 115.37,133.67 124.53,133.67 127.32,130.88 132.64,130.88 132.94,130.59 135.98,130.59 138.33,128.23 138.33,125.81 137.77,125.25 136.88,125.25 136.62,124.99 136.62,124.66 138.43,122.85 138.43,120.09 143.75,114.77 v1(143.83,114.77) 144.51,115.46 154.59,115.46 158.59,111.46 158.59,104.02 160.38,102.23 160.38,99.31 159.62,98.55 158.58,98.55 157.95,97.92 157.95,97.04 155.41,94.5 153.19,94.5 150.96,92.27 148.81,92.27 146.23,89.68 146.23,89.28 145.61,88.66 141.95,88.66 140.55,87.26 138.8,87.26 138.49,86.96 138.49,86.48 139.36,85.61 139.36,84.9 140.02,84.23 140.02,82.65 139.66,82.3 139.29,82.3 v3(138.93,82.66)
  IN3 w0.089: v1(156.35,123.84) 156.35,123.44 156.12,123.21 156.12,122.34 156.91,121.55 159.17,121.55 159.88,120.84 159.88,120.49 161.4,118.97 165.6,118.97 166.37,118.19 173.3,118.19 174.02,118.91 181.02,118.91 181.7,118.23 184.85,118.23 185.25,118.63 185.25,119.32 v1(185.96,120.03)
  IN4 w0.089: v1(185.96,120.03) 184.03,120.03 183.65,120.41 183.08,120.41 182.65,120.84 182.65,125.32 184.95,127.62 184.95,137.37 185.92,138.34 v1(187.36,138.34)
  BOTTOM w0.076: UC1.AV3 136.51,82.3 138.16,82.3 138.34,82.12 138.4,82.12 v3(138.93,82.66)
  BOTTOM w0.108: RC380.1 79.49,126.35 v1(79.77,126.35) ; v1(143.83,114.77) 143.42,115.18 143.42,115.62 143.74,115.94 144.74,115.94 R9509.2 144.71,116.42 143.29,116.42 142.18,117.54 142.18,120.03 143.17,121.02 143.9,121.02 144.16,121.28 149.5,121.28 150.3,122.09 154.65,122.09 R9502.2 154.72,122.5 154.54,122.67 154.21,122.67 153.59,123.29 153.59,123.74 153.97,124.12 156.07,124.12 v1(156.35,123.84) ; R9514.2 187.82,139.38 187.46,139.03 187.46,138.44 v1(187.36,138.34) 186.65,138.34 v2(186.37,138.62)
PCH_SPI_D0_0_R: length 2.8
  BOTTOM w0.108: R9502.1 155.58,120.44 JSPI1.5
PCH_SPI_D0_1_R: length 4.4
  BOTTOM w0.108: U2.5 146.75,118.83 146.62,118.96 145.71,118.96 144.97,118.23 v2(144.97,117.92) R9509.1
PCH_SPI_D0_2_R: length 3.9
  BOTTOM w0.108: U25.21 190.06,142.74 189.06,141.75 188.76,141.75 v2(188.35,141.34) 188.2,141.19 R9514.1
PCH_SPI_D1: length 125.7
  IN1 w0.089: v3(140.65,82.67) 140.1,82.12 138.4,82.12 137,83.52 137,88.26 139.1,90.36 143.19,90.36 143.76,90.93 143.76,92.27 144.38,92.9 144.38,95.52 143.76,96.15 143.76,96.84 144.16,97.24 148.19,97.24 148.79,97.85 153.49,97.85 156.91,101.27 156.91,107.24 v1(157.47,107.8)
  IN3 w0.089: v1(186.62,140.17) 185.79,139.33 185.79,137.69 184.59,136.49 184.59,127.63 183.59,126.63 183.59,122.81 182.66,121.88 174.81,121.88 174.55,121.62 163.16,121.62 159.9,124.88 156.49,124.88 155.88,124.26 155.88,122.28 157.92,120.23 157.92,108.24 157.47,107.79 157.47,107.8 v1(157.47,107.8)
  BOTTOM w0.076: UC1.AW3 137.09,81.75 137.45,81.75 137.65,81.55 138.04,81.55 138.26,81.78 139.76,81.78 v3(140.65,82.67)
  BOTTOM w0.108: v1(186.62,140.17) 186.62,140.36 R9520.2 185.19,140.74 v2(185.08,140.63) ; R9507.1 152.94,109.49 153.84,108.59 155.67,108.59 155.97,108.28 155.97,107.58 156.31,107.24 156.96,107.24 157.06,107.34 157.06,107.39 v1(157.47,107.8) 157.89,107.8 R9505.1
PCH_SPI_D1_0_R: length 2.5
  BOTTOM w0.108: R9505.2 158.16,108.97 158.12,109.02 JSPI1.2
PCH_SPI_D1_1_R: length 7.4
  BOTTOM w0.108: v2(149.72,108.75) 149.72,109 149.29,109.44 U2.2 149.29,111.82 149.67,112.21 152.03,112.21 R9507.2
PCH_SPI_D1_2_R: length 3.3
  BOTTOM w0.108: R9520.1 186.24,142.25 v2(186.73,142.74) 187.17,143.18 U25.24
PCH_SPI_D2: length 180.2
  TOP w0.108: v1(85.81,121.75) 85.81,121.22 85.2,120.61 85.2,116.93 v5(86.27,115.86) 86.53,115.61 v1(86.53,115.11)
  IN1 w0.089: v3(139.51,82.66) 139.84,82.99 139.84,84.09 139.37,84.56 138.25,84.56 137.76,85.05 137.76,87.46 138.42,88.13 140.9,88.13 141.65,88.88 145.52,88.88 146.01,89.37 146.01,89.79 148.7,92.48 150.87,92.48 153.1,94.72 155.32,94.72 157.73,97.13 157.73,98.22 158.28,98.77 159.53,98.77 160.16,99.4 160.16,102.14 158.37,103.93 158.37,111.37 154.5,115.24 145.54,115.24 v1(143.83,113.53) 143.01,114.34 139.88,114.34 138.21,116.01 138.21,122.76 136.4,124.57 136.4,125.08 136.79,125.47 137.68,125.47 138.12,125.9 138.12,128.14 135.89,130.37 132.85,130.37 132.55,130.66 127.23,130.66 124.46,133.43 115.3,133.43 113.54,135.19 109.03,135.19 106.49,132.65 105.44,132.65 103.63,130.84 100.74,130.84 96.2,126.3 96.2,124.19 94.68,122.66 91.18,122.66 90.92,122.92 87.95,122.92 86.77,121.75 v1(85.81,121.75)
  IN2 w0.089: v1(86.53,115.11) 86.53,115.1 85.46,114.03 85.46,113.4 v1(85.23,113.17)
  BOTTOM w0.076: v3(139.51,82.66) 138.82,81.96 138.27,81.96 138.09,82.14 137.63,82.14 137.53,82.03 UC1.AW2
  BOTTOM w0.108: v1(85.23,113.17) 85.23,113.3 RC368.2 ; R9506.1 156.21,108.05 156.21,108.38 155.77,108.82 154.24,108.82 153.91,109.16 153.91,111.77 152.84,112.84 152.84,114.16 152.26,114.75 145.2,114.75 R1.2 R9508.1 144.05,113.75 v1(143.83,113.53)
PCH_SPI_D2_0_R: length 2.5
  BOTTOM w0.108: JSPI1.3 156.85,109.44 156.64,109.23 R9506.2
PCH_SPI_D2_1_R: length 9.1
  BOTTOM w0.108: R9508.2 144.97,112.89 146.37,112.89 146.92,113.45 148.65,113.45 148.91,113.2 148.91,112.1 148.02,111.21 U2.3 148.02,108.85 v2(147.92,108.75)
PCH_SPI_D3: length 81.8
  IN1 w0.089: v1(156.98,122.95) 156.98,117.08 164.59,109.48 164.59,104.77 162.8,102.98 162.8,100.94 162.11,100.25 162.11,99.05 160.15,97.09 159.9,97.09 159.75,96.94 159.75,94.81 159.17,94.22 157.9,94.22 157.37,93.69 157.37,93.37 156.27,92.27 153.4,92.27 151.15,90.02 149.78,90.02 147.01,87.25 143.38,87.25 141.34,85.21 141.34,84.44 v3(140.57,83.68)
  BOTTOM w0.076: UC1.AU4 136.16,83.02 138,83.02 138.2,83.23 140.12,83.23 v3(140.57,83.68)
  BOTTOM w0.108: R9511.2 150.94,120.43 150.99,120.38 R2.2 151.89,120.81 153,120.81 153.93,119.88 153.93,117.27 154.7,116.5 158.48,116.5 158.81,116.83 158.81,120.23 158.55,120.49 158.55,121.48 R9504.2 157.49,122.55 157.38,122.55 v1(156.98,122.95)
PCH_SPI_D3_0_R: length 2.6
  BOTTOM w0.108: R9504.1 157.82,120.81 158.12,120.51 JSPI1.7
PCH_SPI_D3_1_R: length 2.9
  BOTTOM w0.108: R9511.1 149.92,119.57 149.9,119.6 v2(149.46,119.6) 149.29,119.42 U2.7
PCH_SPI_DO2_XDP: length 2.9
  BOTTOM w0.108: RC368.1 84.54,115.11 83.82,115.82 83.59,115.82 83.3,116.11 JXDP1.60
PCH_SPI_DO_XDP: length 3.8
  BOTTOM w0.108: v2(79.28,128.46) 78.78,128.46 78.32,128 RC377.1 RC380.2 79.59,127.12 RC133.1
PCI_CLK_LPC0: length 14.1
  TOP w0.108: v3(133.06,79.45) 132.52,78.91 132.52,78.62 132.4,78.5 132.4,76.93 132.14,76.68 132.14,75.45 131.83,75.13 131.5,75.13 130.77,74.41 128.38,74.41 128.21,74.23 RC64.1 RC65.1 126.37,73.83 v2(126.3,73.9)
  BOTTOM w0.076: v3(133.06,79.45) 132.87,79.64 132.87,79.74 132.55,80.06 132.55,80.49 132.51,80.61 132.51,80.87 132.55,80.97 132.55,81.16 132.77,81.86 UC1.AW9
PCI_CLK_LPC1: length 11.8
  TOP w0.108: v3(133.54,79.16) 133.34,79.16 132.59,78.42 132.59,76.85 132.34,76.6 132.34,75.29 131.76,74.7 v2(131.76,74.54) 131.76,73.95 RC619.1 131.12,73.83 RC66.1 RC58.1
  BOTTOM w0.076: v3(133.54,79.16) 133.54,79.49 133.21,79.82 133.21,80.24 133.06,80.39 132.86,80.39 132.71,80.55 132.68,80.65 132.68,80.82 132.74,81 132.84,81.12 132.95,81.23 UC1.AY9
PCIE_MCARD1_DET#: length 2.5
  TOP w0.108: T7162.1 24.65,120 v1(24.22,119.57)
  BOTTOM w0.108: JWLAN1.69 24.66,120.02 v1(24.22,119.57)
PCIE_PRX_C_DTX_N9: length 3.4
  TOP w0.102: U21.39 142.32,133.54 142.13,133.74 141.83,133.74 141.53,134.05 ; 141.53,134.05 v6(141.53,134.02) ; 141.53,134.05 141.22,134.35 140.1,134.35 C176.1
PCIE_PRX_C_DTX_N11: length 18
  TOP w0.102: v1(167.83,44.82) 167.83,45.05 167.9,45.12 168.13,45.12 168.26,45.25 168.26,45.7 167.95,46.01 167.44,46.01 ; v1(163.03,46.85) 163.31,46.57 163.31,46.26 163.55,46.01 167.44,46.01 ; 167.44,46.01 v6(167.44,45.99)
  BOTTOM w0.102: v1(167.83,44.82) 167.57,45.07 CU47.2 ; v1(163.03,46.85) 163.38,47.2 163.38,48.04 160.45,50.97 156.58,50.97 156.46,50.85 JSTRG1.29
PCIE_PRX_C_DTX_N12: length 17.1
  TOP w0.102: v6(167.33,57.54) 167.33,57.57 ; 167.33,57.57 164.86,57.57 164.04,56.76 164.04,55.97 163.26,55.18 161.1,55.18 160.95,55.03 160.95,54.88 v1(161.15,54.68) ; 167.33,57.57 167.94,57.57 168.27,57.24 168.27,57.04 168.11,56.88 168.01,56.88 167.84,56.72 v1(167.84,56.43)
  BOTTOM w0.102: v1(167.84,56.43) 168.07,56.66 168.07,56.84 CU50.2 ; JSTRG1.23 156.46,53.85 156.52,53.91 160.5,53.91 160.75,54.16 160.75,54.27 v1(161.15,54.68)
PCIE_PRX_C_DTX_P9: length 3.4
  TOP w0.102: U21.38 141.92,133.94 141.31,134.56 140.31,134.56 C179.1
PCIE_PRX_C_DTX_P11: length 18
  TOP w0.102: 165.26,46.22 168.03,46.22 168.46,45.78 v1(168.46,44.82) ; 165.26,46.22 163.64,46.22 163.51,46.34 163.51,46.55 v1(163.81,46.85) ; 165.26,46.22 v6(165.26,46.24)
  BOTTOM w0.102: v1(168.46,44.82) 168.72,45.07 CU48.2 ; JSTRG1.28 156.47,51.35 156.65,51.17 160.54,51.17 163.59,48.12 163.59,47.07 v1(163.81,46.85)
PCIE_PRX_C_DTX_P12: length 17.1
  TOP w0.102: 165.49,57.77 168.02,57.77 168.47,57.33 v1(168.47,56.43) ; 165.49,57.77 v6(165.49,57.8) ; 165.49,57.77 164.77,57.77 163.84,56.84 163.84,56.05 163.17,55.39 161.01,55.39 160.74,55.11 160.74,54.88 v1(160.54,54.68)
  BOTTOM w0.102: JSTRG1.22 156.24,54.35 156.48,54.12 160.42,54.12 160.54,54.24 v1(160.54,54.68) ; v1(168.47,56.43) 168.47,56.43 168.31,56.6 168.31,56.79 CU49.2
PCIE_PRX_C_RD_DTX_N11: length 2.3
  BOTTOM w0.102: U6205.4 167.57,52.43 167.7,52.57 167.7,52.88 168.11,53.29 168.11,53.49 CU43.2
PCIE_PRX_C_RD_DTX_N12: length 2.3
  BOTTOM w0.102: U6206.4 167.55,64.05 167.7,64.2 167.7,64.42 168.24,64.96 168.24,65.05 CU33.2
PCIE_PRX_C_RD_DTX_P11: length 2.3
  BOTTOM w0.102: U6205.5 168.07,52.45 167.9,52.62 167.9,52.79 168.31,53.2 168.31,53.49 CU44.2
PCIE_PRX_C_RD_DTX_P12: length 2.3
  BOTTOM w0.102: U6206.5 168.05,64.05 167.91,64.2 167.91,64.34 168.44,64.87 168.44,65.05 CU34.2
PCIE_PRX_DTX_N5: length 142.1
  TOP w0.102: 129.56,101.04 129.56,100.14 129.05,99.63 v3(128.29,99.63) ; 129.56,101.04 v6(129.59,101.04) ; 129.56,101.04 129.56,106.01 126.71,108.85 116.08,108.85 115.77,108.55 111.41,108.55 111.03,108.17 v1(111.03,107.56)
  IN4 w0.102: v1(111.03,107.56) 111.26,107.79 111.26,108.17 111.03,108.4 109.49,108.4 108.9,107.81 106.59,107.81 105.17,109.23 105.17,111.99 104.52,112.64 89.76,112.64 89.35,113.04 86.1,113.04 85.36,112.31 80.11,112.31 78.29,114.14 77.11,114.14 76.6,113.63 69.25,113.63 67.17,115.71 65.44,115.71 64.96,115.23 59.04,115.23 57.39,113.58 51.27,113.58 50.58,112.89 49.41,112.89 49.08,113.22 48.56,113.22 47.47,112.13 44.23,112.13 43.29,111.19 28.97,111.19 26.8,113.36 26.8,114.75 27.29,115.24 27.29,122.29 24.57,125.01 24,125.01 23.38,125.62 23.38,126.78 v1(23.07,127.09)
  BOTTOM w0.102: UC1.F16 128.49,99.63 v3(128.29,99.63) ; v1(23.07,127.09) 23.33,126.84 23.33,126.56 23.53,126.35 24.33,126.35 24.5,126.52 JWLAN1.43
PCIE_PRX_DTX_N6: length 92.4
  IN4 w0.076: 128.97,101.61 127.98,100.62 127.98,99.97 127.8,99.79 127.8,99.23 127.57,99 v3(127.39,99)
  IN4 w0.102: 128.97,101.61 131.51,101.61 134.13,104.23 138.39,104.23 138.92,104.76 140.3,104.76 143.02,107.48 146.79,107.48 149.39,104.88 149.39,100.93 151.45,98.87 151.45,98.13 153.27,96.3 153.27,95.66 154.41,94.53 155.69,94.53 156.17,94.04 156.17,92.39 157.77,90.79 159.72,90.79 160.82,89.7 160.82,88.16 159.17,86.51 159.17,85.09 159.62,84.63 159.62,81.87 160.29,81.2 160.29,80.56 160.85,80 160.85,77.41 160.75,77.31 v1(160.54,77.31)
  BOTTOM w0.102: 165.17,73.93 167.71,71.39 168.17,71.39 169.15,70.4 169.15,67.86 169.56,67.45 169.56,66.14 169.72,65.98 170.96,65.98 176.52,60.42 176.52,58.13 176.63,58.01 JEPC1.7 ; 165.17,73.93 v6(165.19,73.93) ; 165.17,73.93 161.79,77.31 161.04,77.31 160.84,77.1 160.74,77.1 v1(160.54,77.31) ; UC1.G18 127.87,98.91 127.77,99 v3(127.39,99)
PCIE_PRX_DTX_N8: length 3.5
  TOP w0.102: v3(125.59,99.1) 125.16,99.53 125.16,100.5 124.55,101.11 T6217.1
  BOTTOM w0.102: UC1.G21 125.63,99.1 v3(125.59,99.1)
PCIE_PRX_DTX_N9: length 61.2
  TOP w0.102: v6(129.89,136.3) 129.89,136.32 ; 129.89,136.32 132.26,136.32 132.59,136.65 135.96,136.65 138.15,134.46 138.5,134.46 C176.2 ; 129.89,136.32 127.44,136.32 126.74,135.62 124.7,135.62 124.32,136.01 122.31,136.01 122.18,135.88 v1(122.18,135.29)
  IN3 w0.102: v3(124.67,99.67) 124.71,99.67 125.13,100.09 125.13,100.45 125.59,100.9 125.59,101.53 124.55,102.57 124.55,108.42 124.27,108.7 124.27,113.12 120.33,117.06 120.33,121.65 117.26,124.73 117.26,129.3 122.18,134.23 v1(122.18,135.29)
  BOTTOM w0.102: v3(124.67,99.67) 124.82,99.67 125.13,99.97 UC1.E22
PCIE_PRX_DTX_N10: length 49.4
  IN3 w0.102: v3(122.85,99.68) 122.38,100.14 122.38,100.45 120.97,101.86 120.97,104.84 118.73,107.07 116.29,107.07 113.78,109.59 109.71,109.59 107.71,111.59 107.71,122.11 106.89,122.92 105.81,122.92 105.69,122.8 105.69,122.62 v1(105.94,122.37)
  BOTTOM w0.102: v3(122.85,99.68) 123.19,99.34 UC1.F25 ; v1(105.94,122.37) 105.48,122.82 105.48,122.89 105.2,123.18 104.59,123.18 103.72,124.05 103.72,126.94 104.89,128.11 104.89,131.1 105.66,131.87 106.17,131.87 106.27,131.77 106.27,131.71 106.41,131.58 JWWAN1.41
PCIE_PRX_DTX_N11: length 104.5
  IN4 w0.102: v1(167.83,55.47) 167.83,55.58 167.14,56.27 167.14,57.53 167.6,57.98 167.6,65.49 165.24,67.85 165.24,70.95 164.57,71.61 164.57,73.86 164.15,74.29 164.15,90.25 159.8,94.59 159.8,95.13 158.93,96 158.4,96 156.96,97.44 156.96,97.99 155.84,99.11 155.84,101.44 152.61,104.66 152.61,106.23 150.25,108.59 150.25,109.36 150.25,109.89 149.54,110.61 146.54,110.61 145.32,111.82 141.67,111.82 139.56,109.72 124.47,109.72 123.38,108.62 123.38,106.62 122.5,105.74 121.79,105.74 121.39,105.34 121.39,100.11 121.52,99.98 121.67,99.98 v3(121.93,100.24)
  BOTTOM w0.102: v1(167.83,55.47) 168.01,55.28 168.01,55.1 CU43.1 ; UC1.E28 121.47,99.99 121.11,100.35 121.11,100.53 121.29,100.71 121.47,100.71 v3(121.93,100.24)
PCIE_PRX_DTX_N12: length 94.4
  IN4 w0.102: v3(120.1,100.21) 120.03,100.14 119.88,100.14 119.77,100.25 119.77,104.7 120.97,105.9 120.97,107.18 124.19,110.4 138.03,110.4 140.3,112.66 145.65,112.66 147.03,111.29 150,111.29 150.94,110.34 150.94,108.87 153.48,106.34 153.48,104.81 156.53,101.77 156.53,99.4 161.15,94.77 161.15,94.39 164.83,90.71 164.83,74.57 165.26,74.14 165.26,72.15 166.15,71.25 166.15,69.3 167.19,68.26 167.7,68.26 168.18,67.79 168.18,67.61 v1(168.02,67.45)
  BOTTOM w0.102: CU33.1 167.83,66.74 167.96,66.86 168.32,66.86 168.39,66.94 168.39,67.08 v1(168.02,67.45) ; UC1.E30 120.66,99.99 120.76,100.09 120.76,100.27 120.64,100.39 120.28,100.39 v3(120.1,100.21)
PCIE_PRX_DTX_P5: length 142
  TOP w0.102: v6(129.32,103.01) 129.35,103.01 ; 129.35,103.01 129.35,105.93 126.63,108.65 116.16,108.65 115.86,108.34 111.49,108.34 111.24,108.09 111.24,107.99 v1(111.67,107.56) ; 129.35,103.01 129.35,100.22 128.99,99.86 128.61,99.86 128.36,100.12 v3(128.36,100.26)
  IN4 w0.102: v1(23.73,127.09) 23.58,126.94 23.58,125.71 24.08,125.21 24.66,125.21 27.49,122.37 27.49,115.15 27.01,114.66 27.01,113.44 29.05,111.39 43.2,111.39 44.14,112.33 47.38,112.33 48.47,113.42 49.16,113.42 49.49,113.09 50.5,113.09 51.19,113.79 57.31,113.79 58.96,115.43 64.87,115.43 65.36,115.92 67.25,115.92 69.34,113.83 76.52,113.83 77.02,114.34 78.37,114.34 80.2,112.51 85.27,112.51 86.01,113.25 89.44,113.25 89.84,112.84 104.61,112.84 105.37,112.08 105.37,109.32 106.67,108.01 108.82,108.01 109.4,108.6 111.12,108.6 111.47,108.25 111.47,107.76 v1(111.67,107.56)
  BOTTOM w0.102: UC1.E16 129.07,99.99 129.14,100.06 129.14,100.32 129.02,100.45 128.54,100.45 v3(128.36,100.26) ; JWLAN1.41 24.71,127.02 24.25,126.56 23.62,126.56 23.53,126.64 23.53,126.89 v1(23.73,127.09)
PCIE_PRX_DTX_P6: length 92.3
  IN4 w0.076: v3(127.39,99.63) 127.8,100.04 127.8,100.67 127.81,100.68 127.81,100.68 128.8,101.67 128.8,101.69 128.9,101.79 128.94,101.79 128.96,101.82 128.97,101.82
  IN4 w0.102: v1(160.54,76.7) 161.05,77.22 161.05,80.09 160.49,80.65 160.49,81.29 159.83,81.95 159.83,84.72 159.37,85.18 159.37,86.42 161.02,88.08 161.02,89.78 159.81,91 157.85,91 156.37,92.48 156.37,94.13 155.77,94.73 154.49,94.73 153.48,95.75 153.48,96.38 151.65,98.21 151.65,98.95 149.59,101.01 149.59,104.97 146.87,107.68 142.94,107.68 140.22,104.97 138.84,104.97 138.31,104.43 134.05,104.43 131.43,101.82 128.97,101.82
  BOTTOM w0.102: JEPC1.6 176.13,58.07 176.31,58.26 176.31,60.34 170.88,65.77 169.63,65.77 169.35,66.05 169.35,67.37 168.95,67.77 168.95,70.32 168.08,71.18 167.63,71.18 163.66,75.15 ; v1(160.54,76.7) 160.72,76.7 161.13,77.11 161.7,77.11 163.66,75.15 ; v3(127.39,99.63) 127.69,99.34 UC1.F18 ; 163.66,75.15 v6(163.66,75.12)
PCIE_PRX_DTX_P8: length 2.4
  TOP w0.102: T6218.1 126.07,100.09 125.64,99.66 v3(125.59,99.66)
  BOTTOM w0.102: v3(125.59,99.66) 125.91,99.34 UC1.F21
PCIE_PRX_DTX_P9: length 61.2
  TOP w0.102: C179.2 138.5,134.66 138.24,134.66 136.05,136.85 132.5,136.85 132.18,136.53 128.07,136.53 ; v6(128.07,136.55) 128.07,136.53 ; 128.07,136.53 127.36,136.53 126.66,135.83 124.78,135.83 124.4,136.21 122.23,136.21 121.98,135.96 121.98,135.7 v1(121.55,135.27)
  IN3 w0.102: v3(124.67,100.29) 124.69,100.29 125.33,100.94 125.33,101.43 124.29,102.47 124.29,108.32 124.01,108.59 124.01,113.01 120.08,116.95 120.08,121.55 117,124.62 117,129.41 121.93,134.34 121.93,134.76 121.83,134.86 121.7,134.86 121.55,135.01 v1(121.55,135.27)
  BOTTOM w0.102: UC1.E23 124.37,99.99 v3(124.67,100.29)
PCIE_PRX_DTX_P10: length 49.4
  IN3 w0.102: v1(105.28,122.4) 105.43,122.56 105.43,122.9 105.71,123.18 107,123.18 107.96,122.21 107.96,111.7 109.82,109.84 113.88,109.84 116.4,107.33 118.84,107.33 121.22,104.94 121.22,101.97 122.64,100.55 122.64,100.45 122.74,100.34 122.74,100.34 v3(122.85,100.24)
  BOTTOM w0.102: UC1.E25 123.1,99.99 v3(122.85,100.24) ; v1(105.28,122.4) 105.28,122.81 105.12,122.97 104.51,122.97 103.52,123.97 103.52,127.02 104.68,128.19 104.68,131.19 105.57,132.08 JWWAN1.43
PCIE_PRX_DTX_P11: length 104.6
  IN4 w0.102: v1(168.46,55.47) 168.04,55.89 167.8,55.89 167.35,56.35 167.35,57.44 167.8,57.9 167.8,65.57 165.44,67.93 165.44,71.03 164.77,71.7 164.77,73.94 164.35,74.37 164.35,90.34 160.01,94.68 160.01,95.21 159.01,96.2 158.48,96.2 157.16,97.52 157.16,98.08 156.04,99.2 156.04,101.52 152.82,104.75 152.82,106.31 150.46,108.67 150.46,109.28 150.46,109.97 149.62,110.81 146.63,110.81 145.41,112.03 141.58,112.03 139.47,109.92 124.39,109.92 123.18,108.71 123.18,106.7 122.41,105.94 121.7,105.94 121.19,105.42 121.19,100.02 121.43,99.78 121.84,99.78 v3(121.93,99.68)
  BOTTOM w0.102: CU44.1 168.36,55.14 168.36,55.37 v1(168.46,55.47) ; UC1.E27 122.24,99.99 v3(121.93,99.68)
PCIE_PRX_DTX_P12: length 94.4
  IN4 w0.102: v3(120.1,99.63) 119.57,100.17 119.57,104.79 120.76,105.98 120.76,107.27 124.1,110.61 137.95,110.61 140.21,112.87 145.74,112.87 147.11,111.49 150.08,111.49 151.15,110.43 151.15,108.95 153.68,106.42 153.68,104.9 156.73,101.85 156.73,99.48 161.35,94.86 161.35,94.48 165.03,90.79 165.03,74.65 165.46,74.23 165.46,72.23 166.36,71.34 166.36,69.38 167.27,68.47 167.79,68.47 168.39,67.86 168.39,67.69 v1(168.63,67.45)
  BOTTOM w0.102: v1(168.63,67.45) 168.63,66.95 168.84,66.74 CU34.1 ; v3(120.1,99.63) 120.26,99.63 UC1.F30
PCIE_PRX_RD_DTX_N11: length 2.3
  BOTTOM w0.102: CU47.1 168.03,46.86 168.03,47.17 167.73,47.48 167.73,47.71 167.57,47.86 U6205.15
PCIE_PRX_RD_DTX_N12: length 2.2
  BOTTOM w0.102: CU50.1 168.12,58.51 168.12,58.75 167.7,59.16 167.7,59.32 167.55,59.47 U6206.15
PCIE_PRX_RD_DTX_P11: length 2.3
  BOTTOM w0.102: CU48.1 168.24,46.89 168.24,47.26 167.93,47.56 167.93,47.72 168.07,47.86 U6205.14
PCIE_PRX_RD_DTX_P12: length 2.2
  BOTTOM w0.102: U6206.14 168.05,59.52 167.91,59.37 167.91,59.24 168.32,58.83 168.32,58.49 CU49.1
PCIE_PTX_C_DRX_N5: length 3.1
  BOTTOM w0.102: C242.2 23.14,128.41 23.43,128.41 23.68,128.16 24.69,128.16 24.84,128.02 JWLAN1.37
PCIE_PTX_C_DRX_N6: length 6.6
  BOTTOM w0.102: JEPC1.4 175.13,57.86 174.99,58 174.99,58.74 174.59,59.14 173.46,59.14 172.93,58.62 172.93,57.14 172.81,57.01 C647.1
PCIE_PTX_C_DRX_N9: length 3.2
  TOP w0.102: 140.9,132.3 v6(140.9,132.27) ; 140.9,132.3 141.44,132.3 141.58,132.44 142.36,132.44 142.46,132.34 U21.42 ; 140.9,132.3 140.21,132.3 C181.1
PCIE_PTX_C_DRX_N10: length 2.6
  TOP w0.102: CZ58.1 106.26,133.25 105.91,133.25 v1(105.86,133.2)
  BOTTOM w0.102: JWWAN1.47 106.55,133.08 106.25,133.37 106.03,133.37 v1(105.86,133.2)
PCIE_PTX_C_DRX_N11: length 14.9
  TOP w0.102: v1(162.33,47.12) 162.04,46.83 162.04,45.91 162.42,45.53 163.57,45.53 ; v1(166.18,44.82) 165.96,45.03 165.96,45.31 165.74,45.53 163.57,45.53 ; 163.57,45.53 v6(163.57,45.56)
  BOTTOM w0.102: JSTRG1.31 156.47,49.85 156.53,49.8 159.07,49.8 159.86,49.01 161.16,49.01 162.24,47.93 162.24,47.21 v1(162.33,47.12) ; CU46.2 166.43,45.07 v1(166.18,44.82)
PCIE_PTX_C_DRX_N12: length 14.5
  TOP w0.102: v1(166.1,56.4) 165.87,56.63 165.87,56.85 165.64,57.09 165.06,57.09 164.53,56.55 164.53,55.77 163.79,55.03 ; v1(160.6,53.23) 160.66,53.29 160.66,53.86 160.96,54.17 162.93,54.17 163.79,55.03 ; 163.79,55.03 v6(163.79,55.06)
  BOTTOM w0.102: JSTRG1.25 156.46,52.85 156.61,52.7 160.43,52.7 160.6,52.88 v1(160.6,53.23) ; CU36.2 165.92,56.82 165.92,56.58 v1(166.1,56.4)
PCIE_PTX_C_DRX_P5: length 3.1
  BOTTOM w0.102: JWLAN1.35 24.86,128.52 24.71,128.37 23.76,128.37 23.51,128.61 23.14,128.61 C243.2
PCIE_PTX_C_DRX_P6: length 6.7
  BOTTOM w0.102: JEPC1.3 174.63,57.87 174.79,58.03 174.79,58.65 174.5,58.94 173.54,58.94 173.14,58.54 173.14,57.05 172.89,56.81 172.32,56.81 172.18,56.67 172.18,56.48 C648.1
PCIE_PTX_C_DRX_P9: length 3.2
  TOP w0.102: U21.41 142.44,132.74 142.35,132.65 141.5,132.65 141.35,132.5 140.21,132.5 C178.1
PCIE_PTX_C_DRX_P10: length 2.6
  TOP w0.102: CZ59.1 106.36,133.52 106.18,133.52 v1(105.85,133.85)
  BOTTOM w0.102: JWWAN1.49 106.12,133.58 v1(105.85,133.85)
PCIE_PTX_C_DRX_P11: length 14.9
  TOP w0.102: 161.83,46.34 161.83,45.83 162.33,45.33 165.66,45.33 165.76,45.23 165.76,45.03 v1(165.54,44.82) ; 161.83,46.34 161.83,46.84 v1(161.55,47.12) ; 161.83,46.34 v6(161.82,46.34)
  BOTTOM w0.102: v1(161.55,47.12) 161.55,47.23 161.65,47.33 161.91,47.33 162.04,47.45 162.04,47.84 161.07,48.81 159.78,48.81 158.99,49.59 156.66,49.59 156.41,49.35 JSTRG1.32 ; CU45.2 165.42,44.95 v1(165.54,44.82)
PCIE_PTX_C_DRX_P12: length 14.5
  TOP w0.102: v1(161.24,53.23) 161.24,53.42 161.12,53.53 160.96,53.53 160.86,53.62 160.86,53.78 161.05,53.96 161.62,53.96 ; 161.62,53.96 v6(161.62,53.92) ; 161.62,53.96 163.01,53.96 164.73,55.68 164.73,56.47 165.14,56.88 165.55,56.88 165.67,56.77 165.67,56.6 v1(165.47,56.4)
  BOTTOM w0.102: v1(165.47,56.4) 165.6,56.54 165.6,56.89 CU35.2 ; v1(161.24,53.23) 160.51,52.5 156.61,52.5 156.46,52.35 JSTRG1.26
PCIE_PTX_C_RD_DRX_N11: length 2.3
  BOTTOM w0.102: CU42.2 165.95,53.54 165.95,53.21 166.38,52.78 166.38,52.63 166.57,52.44 U6205.2
PCIE_PTX_C_RD_DRX_N12: length 2.2
  BOTTOM w0.102: U6206.2 166.55,64.05 166.41,64.2 166.41,64.5 166.12,64.79 166.12,65.02 CU32.2
PCIE_PTX_C_RD_DRX_P11: length 2.3
  BOTTOM w0.102: U6205.1 166.07,52.46 166.18,52.57 166.18,52.69 165.75,53.12 165.75,53.44 CU41.2
PCIE_PTX_C_RD_DRX_P12: length 2.2
  BOTTOM w0.102: U6206.1 166.05,64.05 166.2,64.2 166.2,64.42 165.92,64.7 165.92,65.08 CU31.2
PCIE_PTX_DRX_N5: length 139.9
  TOP w0.102: 121.21,108.17 126.22,108.17 126.81,107.58 126.81,104.92 126.93,104.79 127.04,104.79 127.16,104.91 127.16,105.47 127.29,105.6 127.52,105.6 127.6,105.53 v3(127.6,105.19) ; 121.21,108.17 v6(121.21,108.19) ; 121.21,108.17 117.09,108.17 116.22,107.3 113.46,107.3 113.26,107.1 113.07,107.1 v1(112.86,107.3)
  IN4 w0.102: v1(20.89,128.13) 20.61,128.41 20.28,128.41 20.15,128.28 20.15,127.45 20.56,127.04 21.85,127.04 22.65,126.24 22.65,125.48 24.12,124.02 24.78,124.02 26.71,122.09 26.71,115.48 26.1,114.87 26.1,113.38 28.95,110.53 36,110.53 36.36,110.17 50.85,110.17 51.69,111.01 56.12,111.01 57.14,110 60.74,110 61.33,109.41 62.08,109.41 62.66,110 66.13,110 67.8,111.67 73.49,111.67 74.18,112.36 76.07,112.36 76.9,111.52 79.87,111.52 80.48,110.91 81.65,110.91 82.56,111.82 85.56,111.82 86.3,112.56 89.03,112.56 89.43,112.15 103.09,112.15 103.53,111.72 104.26,111.72 104.68,111.29 104.68,109.03 106.39,107.33 108.49,107.33 108.74,107.09 112.65,107.09 v1(112.86,107.3)
  BOTTOM w0.076: UC1.C19 127.07,101.72 127.15,101.97 127.16,102 127.16,102.15 127.12,102.25 127.12,102.52 127.13,102.53 127.15,102.6 127.15,102.99 127.01,103.14 127.01,104.61 v3(127.6,105.19)
  BOTTOM w0.102: C242.1 21.45,128.4 21.16,128.4 v1(20.89,128.13)
PCIE_PTX_DRX_N6: length 103.9
  IN4 w0.102: v1(125.77,106.85) 129.32,106.85 131.07,105.09 138.11,105.09 138.87,105.86 139.52,105.86 142.04,108.37 147.16,108.37 148.36,107.18 149.04,107.18 150.3,105.92 150.3,101.51 153.22,98.59 153.22,97.75 155.56,95.42 156.08,95.42 157.06,94.43 157.06,92.93 158.23,91.76 160.02,91.76 161.89,89.89 161.89,87.95 160.08,86.14 160.08,85.46 160.93,84.61 160.93,83.76 161.31,83.38 161.84,83.38 162.29,82.93 162.29,76.61 159.41,73.73 159.41,66.82 161.48,64.74 161.48,61.48 164.02,58.94 164.02,55.74 164.91,54.85 169.05,54.85 169.51,55.31 169.51,56.27 v1(170.01,56.78)
  BOTTOM w0.076: UC1.D20 126.65,101.66 126.65,101.88 126.54,101.98 126.54,102.34 126.44,102.44 126.44,105.77
  BOTTOM w0.102: v1(170.01,56.78) 170.24,57.01 C647.2 ; v1(125.77,106.85) 126.12,106.49 126.12,106.09 126.44,105.77
PCIE_PTX_DRX_N8: length 8.8
  TOP w0.102: T6219.1 123.86,107.3 v1(125.16,107.3)
  BOTTOM w0.076: UC1.D21 125.42,101.1 125.42,101.67 125.33,101.93 125.33,102.18 125.36,102.3 125.36,102.49 125.33,102.58 125.33,102.94 125.48,103.09 125.48,104.1 124.75,104.84 124.75,104.97
  BOTTOM w0.102: v1(125.16,107.3) 125.03,107.18 124.96,107.18 124.75,106.97 124.75,104.97
PCIE_PTX_DRX_N9: length 62.6
  TOP w0.102: v6(121.66,134.44) 121.66,134.46 ; 121.66,134.46 124.19,134.46 124.67,134.94 127.03,134.94 127.73,135.64 132.55,135.64 132.87,135.96 135.68,135.96 137.76,133.88 137.76,132.82 138.29,132.3 138.5,132.3 C181.2 ; 121.66,134.46 120.87,134.46 120,135.34 v1(120,136.31)
  IN3 w0.102: v1(123.56,103.7) 123.12,104.14 123.12,105.55 123.38,105.81 123.38,108.09 123.2,108.27 123.2,112.73 117.41,118.53 117.41,122.56 116.27,123.71 116.27,130.04 120,133.77 v1(120,136.31)
  BOTTOM w0.102: v1(123.56,103.7) 123.99,103.28 123.99,102.48 UC1.B23
PCIE_PTX_DRX_N10: length 48.4
  TOP w0.102: v1(108.39,132.73) 108.29,132.83 CZ58.2
  IN3 w0.102: v1(108.39,132.73) 108.7,132.73 108.8,132.63 108.8,129.93 107.81,128.94 107.81,126.02 108.44,125.38 108.44,112 110.09,110.35 114.13,110.35 116.6,107.89 121.96,107.89 122.08,107.76 v1(122.08,107.2)
  BOTTOM w0.076: UC1.D23 124.75,101.1 124.75,101.67 124.84,101.93 124.84,102.18 124.81,102.3 124.81,102.49 124.86,102.62 124.86,103.74 124.18,104.42 124.18,104.69 123.56,105.32 123.56,105.4
  BOTTOM w0.102: 123.56,105.4 123.56,107.64 123.18,108.01 122.66,108.01 122.49,108.01 122.2,107.73 122.2,107.32 v1(122.08,107.2)
PCIE_PTX_DRX_N11: length 98.5
  IN4 w0.102: v1(122.55,104.09) 122.74,104.28 122.97,104.28 123.3,104.62 123.3,105.53 124.06,106.29 124.06,107.76 125.31,109 139.85,109 140.76,109.92 149.13,109.92 149.57,109.48 149.57,108.31 151.62,106.25 151.62,104.55 153.27,102.9 153.27,102.2 155.15,100.32 155.15,97.71 155.7,97.17 155.7,97.16 156.05,96.81 156.05,96.81 156.25,96.61 156.58,96.61 158.99,94.2 159.23,94.2 163.46,89.97 163.46,74 163.89,73.58 163.89,71.26 164.5,70.64 164.5,67.37 165.39,66.48 165.39,58 164.53,57.14 164.53,55.94 165.13,55.33 165.69,55.33 v1(166.09,55.74)
  BOTTOM w0.076: UC1.D24 123.72,101.21 arc(123.63,101.34) 123.6,101.49 arc(123.59,101.52) 123.57,101.56 arc(123.54,101.61) 123.53,101.67 123.53,101.89 123.56,101.92 123.56,102.91 122.77,103.7 122.77,103.87 v1(122.55,104.09)
  BOTTOM w0.102: CU42.1 165.95,55.14 165.95,55.6 v1(166.09,55.74)
PCIE_PTX_DRX_N12: length 88.6
  IN4 w0.102: v1(122.66,103.18) 122.59,103.11 122.59,102.97 122.89,102.67 123.85,102.67 124.55,103.37 124.55,107.56 125.13,108.14 131.36,108.14 133.7,105.8 137.78,105.8 141.41,109.44 147.08,109.44 148.58,107.94 149.25,107.94 150.99,106.2 150.99,102.71 152.27,101.43 153.34,101.43 154.67,100.1 154.67,97.51 155.21,96.97 155.21,96.96 155.85,96.32 155.85,96.32 156.05,96.13 156.36,96.13 157.77,94.71 157.77,93.23 158.32,92.68 160.06,92.68 162.98,89.77 162.98,75.65 161.98,74.66 161.98,74.17 162.06,74.09 162.18,74.09 162.39,73.88 v1(162.39,73.65)
  BOTTOM w0.102: v1(122.66,103.18) 123.13,102.71 UC1.A25 ; CU32.1 166.56,66.99 166.44,67.11 166.27,67.11 166.11,66.95 165.84,66.95 165.75,67.05 165.75,71.08 163.64,73.19 162.31,73.19 162.19,73.32 162.19,73.45 v1(162.39,73.65)
PCIE_PTX_DRX_P5: length 139.9
  TOP w0.102: v3(127.6,104.59) 126.85,104.59 126.6,104.83 126.6,107.5 126.14,107.96 119.43,107.96 ; 119.43,107.96 117.17,107.96 116.31,107.1 113.55,107.1 113.35,106.9 113.09,106.9 v1(112.86,106.67) ; 119.43,107.96 v6(119.43,107.93)
  IN4 w0.102: v1(112.86,106.67) 112.65,106.88 108.65,106.88 108.41,107.13 106.3,107.13 104.48,108.95 104.48,111.21 104.17,111.52 103.44,111.52 103.01,111.95 89.35,111.95 88.94,112.36 86.38,112.36 85.64,111.62 82.65,111.62 81.73,110.71 80.39,110.71 79.78,111.32 76.82,111.32 75.98,112.15 74.26,112.15 73.58,111.47 67.89,111.47 66.21,109.79 62.75,109.79 62.16,109.21 61.24,109.21 60.66,109.79 57.05,109.79 56.04,110.81 51.78,110.81 50.94,109.97 36.27,109.97 35.92,110.33 28.86,110.33 25.89,113.29 25.89,114.96 26.5,115.57 26.5,122 24.69,123.81 24.03,123.81 22.45,125.4 22.45,126.16 21.77,126.84 20.48,126.84 19.95,127.37 19.95,128.37 20.2,128.61 20.61,128.61 v1(20.89,128.89)
  BOTTOM w0.076: v3(127.6,104.59) 127.47,104.71 127.34,104.71 127.18,104.54 127.18,103.21 127.32,103.06 127.32,102.57 127.28,102.48 127.28,102.29 127.33,102.18 127.33,101.97 127.22,101.61 127.22,101.09 UC1.D19
  BOTTOM w0.102: C243.1 21.43,128.6 21.18,128.6 v1(20.89,128.89)
PCIE_PTX_DRX_P6: length 103.8
  IN4 w0.102: v1(170.01,56.15) 169.84,56.15 169.71,56.02 169.71,55.39 169.71,55.39 169.71,55.23 169.13,54.65 164.82,54.65 163.82,55.66 163.82,58.86 161.28,61.4 161.28,64.66 159.2,66.73 159.2,73.81 162.09,76.7 162.09,82.84 161.76,83.17 161.22,83.17 160.73,83.67 160.73,84.53 159.88,85.37 159.88,86.23 161.68,88.03 161.68,89.8 159.93,91.56 158.14,91.56 156.86,92.84 156.86,94.35 155.99,95.21 155.48,95.21 153.02,97.67 153.02,98.51 150.1,101.43 150.1,105.83 148.96,106.97 148.27,106.97 147.08,108.17 142.12,108.17 139.61,105.65 138.96,105.65 138.2,104.89 130.99,104.89 129.24,106.64 126.3,106.64 126.21,106.55 126.21,106.37 126.62,105.97 126.62,105.87 126.52,105.77 126.16,105.77 v1(125.72,106.21)
  BOTTOM w0.076: 126.19,105.74 126.28,105.65 126.28,102.37 126.38,102.27 126.38,101.79 UC1.C20
  BOTTOM w0.102: C648.2 170.51,56.3 170.16,56.3 v1(170.01,56.15) ; 126.19,105.74 v1(125.72,106.21)
PCIE_PTX_DRX_P8: length 6.9
  TOP w0.102: T6220.1 124.83,106.36 v1(125.16,106.69)
  BOTTOM w0.076: UC1.C21 125.58,101.59 125.58,101.7 125.49,101.96 125.49,102.15 125.53,102.27 125.53,102.52 125.49,102.61 125.49,102.87 125.66,103.04 125.66,104.16 124.95,104.87 124.95,105.13
  BOTTOM w0.102: v1(125.16,106.69) 124.95,106.49 124.95,105.13
PCIE_PTX_DRX_P9: length 62.5
  TOP w0.102: v1(120.71,136.31) 120.71,135.89 120.61,135.79 120.49,135.79 120.38,135.91 120.31,135.91 120.2,135.81 120.2,135.42 120.96,134.67 123.49,134.67 ; C178.2 138.5,132.5 138.37,132.5 137.96,132.91 137.96,133.96 135.76,136.16 132.79,136.16 132.46,135.84 127.64,135.84 126.94,135.14 124.58,135.14 124.11,134.67 123.49,134.67 ; 123.49,134.67 v6(123.49,134.68)
  IN3 w0.102: v1(123.56,104.31) 123.38,104.49 123.38,105.45 123.63,105.7 123.63,108.2 123.45,108.37 123.45,112.84 117.66,118.63 117.66,122.67 116.52,123.81 116.52,129.93 120.25,133.66 120.25,135.93 120.33,136 120.44,136 120.51,135.93 120.62,135.93 120.71,136.02 v1(120.71,136.31)
  BOTTOM w0.102: UC1.A23 124.19,102.93 124.19,103.36 123.96,103.59 123.96,103.91 v1(123.56,104.31)
PCIE_PTX_DRX_P10: length 48.2
  TOP w0.102: v1(108.39,133.34) 108.08,133.34 CZ59.2
  IN3 w0.102: v1(108.39,133.34) 108.67,133.34 108.85,133.16 108.85,132.94 109.05,132.73 109.05,129.83 108.06,128.84 108.06,126.12 108.7,125.49 108.7,112.1 110.2,110.61 114.24,110.61 116.7,108.14 121.85,108.14 122.06,108.14 122.34,107.87 122.34,107.58 122.39,107.53 122.59,107.53 122.69,107.43 v1(122.69,107.18)
  BOTTOM w0.076: 123.35,105.37 123.35,105.29 124.01,104.63 124.01,104.35 124.69,103.67 124.69,102.65 124.64,102.52 124.64,102.27 124.68,102.15 124.68,101.96 124.59,101.7 124.59,101.59 UC1.C23
  BOTTOM w0.102: v1(122.69,107.18) 122.41,107.46 122.41,107.64 122.57,107.81 123.1,107.81 123.35,107.56 123.35,105.37
PCIE_PTX_DRX_P11: length 98.5
  IN4 w0.102: v1(165.46,55.74) 165.46,55.59 165.41,55.54 165.21,55.54 164.73,56.02 164.73,57.05 165.59,57.92 165.59,66.56 164.7,67.45 164.7,70.73 164.09,71.34 164.09,73.66 163.66,74.08 163.66,90.05 159.31,94.4 159.07,94.4 156.66,96.81 156.34,96.81 156.14,97.01 156.14,97.01 155.9,97.25 155.9,97.25 155.36,97.79 155.36,100.4 153.48,102.28 153.48,102.99 151.83,104.64 151.83,106.33 149.77,108.39 149.77,109.56 149.21,110.12 140.68,110.12 139.76,109.21 125.23,109.21 123.86,107.84 123.86,106.37 123.1,105.61 123.1,104.7 122.88,104.48 122.79,104.48 v1(122.58,104.7)
  BOTTOM w0.076: UC1.C24 123.72,101.86 123.72,102.98 122.93,103.76 122.93,104.32 123,104.38 123.14,104.38 123.2,104.44 123.2,104.62 123.12,104.7 v1(122.58,104.7)
  BOTTOM w0.102: v1(165.46,55.74) 165.75,55.45 165.75,55.25 CU41.1
PCIE_PTX_DRX_P12: length 88.6
  IN4 w0.102: v1(122.05,103.24) 122.05,103.22 122.8,102.47 123.93,102.47 124.75,103.29 124.75,107.47 125.22,107.94 131.28,107.94 133.61,105.6 137.86,105.6 141.5,109.23 146.99,109.23 148.49,107.73 149.17,107.73 150.79,106.12 150.79,102.63 152.19,101.23 153.25,101.23 154.47,100.01 154.47,97.59 154.47,97.59 154.47,97.42 155.01,96.88 155.01,96.88 155.77,96.12 155.77,96.12 155.97,95.92 156.27,95.92 157.57,94.63 157.57,93.32 157.57,93.15 158.24,92.48 159.98,92.48 162.77,89.68 162.77,75.73 161.78,74.74 v1(161.78,73.65)
  BOTTOM w0.102: v1(161.78,73.65) 161.98,73.45 161.98,73.23 162.23,72.99 163.55,72.99 165.54,71 CU31.1 ; UC1.B25 123.26,102.06 122.89,102.44 122.89,102.55 122.65,102.79 122.5,102.79 122.05,103.23 v1(122.05,103.24)
PCIE_PTX_RD_DRX_N11: length 2.3
  BOTTOM w0.102: U6205.17 166.57,47.88 166.43,47.74 166.43,47.36 166.03,46.95 166.03,46.81 CU46.1
PCIE_PTX_RD_DRX_N12: length 2.2
  BOTTOM w0.102: CU36.1 165.94,58.46 165.94,58.64 166.38,59.09 166.38,59.29 166.55,59.47 U6206.17
PCIE_PTX_RD_DRX_P11: length 2.3
  BOTTOM w0.102: CU45.1 165.82,46.81 165.82,47.04 166.23,47.44 166.23,47.69 166.07,47.85 U6205.18
PCIE_PTX_RD_DRX_P12: length 2.2
  BOTTOM w0.102: U6206.18 166.05,59.47 166.18,59.34 166.18,59.17 165.73,58.72 165.73,58.53 CU35.1
PCIE_RCOMPN: length 1.9
  TOP w0.381: v3(134.75,99.68) 134.91,99.68 135.29,99.3 RC45.1
  BOTTOM w0.254: v3(134.75,99.68) 135.09,99.34 UC1.F5
PCIE_RCOMPP: length 3
  TOP w0.381: RC45.2 135.82,99 135.82,99.68 v2(135.58,99.92) 135.25,100.25 v3(134.75,100.25)
  BOTTOM w0.254: UC1.E5 135.18,100 134.93,100.25 v3(134.75,100.25)
PCIE_WAKE#: length 426.1
  TOP w0.108: v1(161.52,43.97) 161.94,43.55 168.06,43.55 169.73,45.23 172.55,45.23 174.53,47.21 175.93,47.21 v1(176.44,46.7) ; v1(260.56,44.06) 260.74,44.06 R9573.1 R9572.2
  IN1 w0.089: v1(176.44,46.7) 176.57,46.83 176.57,48.76 176.95,49.14 176.95,51.42 175.95,52.42 175.95,56.54 174.73,57.75 174.73,62.85 173.8,63.79 v1(173.8,66.82) 174.59,67.61 174.59,68.54 170.59,72.54 170.59,79.71 170.88,80 174.56,80 175.01,80.45 175.01,83.95 175.46,84.4 175.46,91.55 174.69,92.32 171.2,92.32 168.95,94.56 168.95,95.91 170.64,97.59 170.64,101.32 169.45,102.51 169.45,104.72 168.6,105.57 168.6,117 168.34,117.26 159.45,126.15 159.45,129.02 158.16,130.3 155.27,130.3 152.42,133.15 152.42,135.55 150,137.97 145.21,137.97 144.85,138.33 144.3,138.33 144.12,138.51 142.9,138.51 142.63,138.78 139.85,138.78 139.18,139.45 139.18,140.45 134.7,144.94 133.34,144.94 132.77,145.51 125.52,145.51 124.47,146.56 115.31,146.56 114.37,145.62 105.8,145.62 103.01,142.83 103.01,142.08 103.65,141.43 v1(103.65,139.16) 102.26,139.16 101.47,139.94 100.77,139.94 99.34,141.37 84.82,141.37 84.34,141.85 71.74,141.85 71.6,141.71 69.77,141.71 66.62,138.56 66.62,129.83 63.24,126.45 63.24,125.24 v1(58.2,120.2)
  IN3 w0.089: v1(176.44,46.7) 177.23,45.91 178.8,45.91 181.61,43.1 201.96,43.1 203.99,45.13 211.62,45.13 211.86,45.37 217.77,45.37 218.69,46.29 218.69,46.96 219.98,48.26 222.65,48.26 226.61,52.22 228.99,52.22 229.91,51.3 229.91,50.65 230.55,50.01 232.65,50.01 233.97,51.33 236.38,51.33 236.82,50.89 237.27,50.89 237.84,50.32 239.35,50.32 240.83,51.8 243.39,51.8 245.08,53.49 245.9,53.49 246.49,52.89 246.49,51.91 247.08,51.32 250,51.32 250.35,51.68 251.83,51.68 253.12,50.39 253.6,50.39 253.82,50.61 261.36,50.61 v1(261.8,50.18) ; v1(58.2,120.2) 58.07,120.2 57.59,119.72 51.95,119.72 51.27,119.04 50.53,119.04 47.29,115.79 45.82,115.79 45.41,115.37 44.66,115.37 41.35,112.06 35.16,112.06 34.57,111.47 29,111.47 28.41,112.06 27.4,112.06 22.27,117.2 22.27,121.58 23.57,122.89 v1(23.57,123.19)
  IN4 w0.089: v1(261.8,50.18) 261.63,50.01 261.63,48.23 262.21,47.65 262.21,46.01 261.49,45.29 261.49,44.98 v1(260.56,44.06)
  BOTTOM w0.108: v1(161.52,43.97) 161.52,43.83 R9662.1 ; JEPC1.13 179.63,61.8 174.61,66.82 v1(173.8,66.82) ; JWWAN1.54 102.26,134.83 103.27,135.83 103.27,138.77 v1(103.65,139.16) ; v2(58.86,120.89) 58.86,120.86 v1(58.2,120.2) ; v1(23.57,123.19) 23.9,123.52 JWLAN1.55
PCIE_WAKE#_R: length 11.5
  TOP w0.108: R9572.1 260.74,45.71 260.74,44.84 v1(260.56,44.67) 260.03,44.67 R340.2 ; U37.B10 260.78,49.27 260.78,49.28 260.78,49.88 261.08,50.18 v1(261.18,50.18)
  BOTTOM w0.108: v2(259.83,44.64) 260.54,44.64 v1(260.56,44.67) 261.26,45.37 261.26,47.71 261.6,48.05 261.6,49.76 v1(261.18,50.18)
PECI_EC: length 183.8
  TOP w0.108: R375.2 v1(227.21,68.49)
  IN3 w0.089: v3(107.63,104.26) 109.69,104.26 112.2,101.74 120.48,101.74 121.52,100.7 121.52,98.95 121.04,98.46 121.04,97.4 120.58,96.94 120.58,88.76 121.35,88 121.35,87.74 121.93,87.16 127.51,87.16 127.95,86.72 127.95,82.54 132.52,77.97 132.52,74.55 134.52,72.56 135.03,72.56 135.86,71.72 135.86,70.55 136.92,69.49 138.07,69.49 140.77,66.79 140.77,65.51 142.78,63.5 142.78,62.75 145.22,60.31 148.18,60.31 148.51,59.98 148.51,59.43 149.79,58.15 154.12,58.15 156.36,55.92 157.27,55.92 161.05,52.13 166.48,52.13 168.59,50.03 170.88,50.03 172.55,48.35 174.97,48.35 175.29,48.67 175.75,48.67 176.52,47.91 176.52,47.44 176.9,47.06 178.44,47.06 181.85,43.65 201.74,43.65 203.76,45.68 210.55,45.68 210.79,45.92 217.54,45.92 218.1,46.47 v1(218.25,46.47)
  BOTTOM w0.089: v3(107.63,104.26) 107.06,103.69 UC1.A54
  BOTTOM w0.108: v1(218.25,46.47) 218.18,46.54 218.18,52.76 218.56,53.14 218.56,54.26 217.95,54.88 217.95,60.76 219.25,62.06 219.25,63.18 220.02,63.96 220.02,65.64 222.3,67.92 v2(226.16,67.92) 226.64,67.92 v1(227.21,68.49)
PECI_EC_R: length 8.1
  TOP w0.108: U38.A48 230.25,62.16 229.68,62.72 228.04,62.72 227.61,63.15 227.61,63.78 C395.2 227.77,64.53 227.77,65.76 227.46,66.08 v2(226.99,66.08) 226.99,66.76 R375.1
PEG_GTX_C_HRX_N0: length 50.8
  IN3 w0.102: v1(122.62,140.53) 122.01,139.92 122.01,139.84 121.75,139.59 121.75,138.62 122.31,138.06 123.86,138.06 124.42,137.5 124.42,133.26 125.41,132.27 125.41,127.12 128.89,123.64 128.89,111.44 127.98,110.53 127.98,102.71 129.37,101.31 129.37,99.48 129.55,99.3 129.55,98.75 129.92,98.37 v3(130.15,98.37)
  BOTTOM w0.102: UC1.H13 130.49,98.04 v3(130.15,98.37) ; JGFX1.40 122.2,140.11 v1(122.62,140.53)
PEG_GTX_C_HRX_N1: length 48.6
  IN3 w0.076: 130.27,100.29 130.5,100.06 130.5,99.42 130.69,99.23 130.69,98.82 131.05,98.46 v3(131.05,98.36)
  IN3 w0.102: 130.27,100.29 130.27,101.88 128.97,103.19 128.97,110.07 129.88,110.99 129.88,118.94 130.06,119.12 130.06,121.48 130.67,122.09 132.04,122.09 132.4,122.45 132.4,123.25 131.38,124.27 130.67,124.27 126.4,128.54 126.4,135.83 126.66,136.08 126.66,137 126.27,137.38 125.8,137.38 125.66,137.25 125.66,137.05 v1(125.82,136.89)
  BOTTOM w0.102: JGFX1.26 125.7,137.01 v1(125.82,136.89) ; v3(131.05,98.36) 131.4,98.36 131.53,98.49 UC1.G11
PEG_GTX_C_HRX_N2: length 47.7
  IN3 w0.102: v3(128.29,98.38) 128.41,98.38 128.79,98.77 128.79,99.15 129.02,99.38 129.02,100.71 127.01,102.71 127.01,108.12 125.26,109.87 125.26,113.53 123.3,115.49 123.3,116.8 122.92,117.18 122.92,120.03 121.67,121.28 121.67,121.96 119.67,123.97 119.67,125.06 118.43,126.3 118.43,129.07 123.68,134.33 123.68,136.69 v1(123.81,136.82)
  BOTTOM w0.102: UC1.H16 128.44,98.38 v3(128.29,98.38) ; JGFX1.32 124.2,137.21 v1(123.81,136.82)
PEG_GTX_C_HRX_N3: length 60.9
  IN3 w0.076: v3(129.18,98.37) 128.94,98.37 128.81,98.24 128.81,97.87 129.04,97.64 130.17,97.64 130.42,97.39 131.19,97.39 131.41,97.61 131.41,100.52 131,100.92 131,101.13
  IN3 w0.102: v1(126.66,139.7) 126.88,139.47 126.88,138.72 127.67,137.93 127.67,135.55 127.42,135.3 127.42,128.92 131.05,125.29 132.6,125.29 135.83,122.06 136.63,122.06 137.15,121.55 137.15,115.35 136.74,114.95 132.65,114.95 131.13,113.42 131.13,110.53 131.13,110.52 129.96,109.36 129.96,103.18 131,102.14 131,101.13
  BOTTOM w0.102: v1(126.66,139.7) 126.12,139.7 126.05,139.62 126.05,139.41 126.17,139.28 126.55,139.28 126.7,139.14 JGFX1.22 ; v3(129.18,98.37) 129.58,98.37 129.7,98.48 UC1.G15
PEG_GTX_C_HRX_P0: length 50.7
  IN3 w0.102: v3(130.19,99.02) 130.04,98.88 129.9,98.88 129.8,98.98 129.8,99.41 129.63,99.58 129.63,101.41 128.23,102.81 128.23,110.42 129.14,111.34 129.14,123.74 125.66,127.22 125.66,132.38 124.67,133.37 124.67,137.61 123.96,138.32 122.41,138.32 122.01,138.72 122.01,139.4 122.13,139.53 122.27,139.53 122.43,139.37 122.43,139.18 122.57,139.04 122.75,139.04 122.91,139.19 122.91,139.37 122.62,139.66 v1(122.62,139.92)
  BOTTOM w0.102: v1(122.62,139.92) 122.4,139.7 122.4,139.57 122.52,139.46 122.76,139.46 122.85,139.37 122.85,139.13 122.7,138.98 JGFX1.38 ; v3(130.19,99.02) 130.49,99.02 130.61,98.9 UC1.G13
PEG_GTX_C_HRX_P1: length 48.5
  IN3 w0.076: 130.53,100.31 130.67,100.17 130.67,99.48 131.05,99.1 v3(131.05,98.99)
  IN3 w0.102: v1(125.21,136.89) 125.41,137.1 125.41,137.35 125.69,137.63 126.38,137.63 126.91,137.1 126.91,135.98 126.66,135.72 126.66,128.64 130.77,124.52 131.48,124.52 132.65,123.36 132.65,122.34 132.14,121.83 130.77,121.83 130.31,121.37 130.31,119.01 130.14,118.83 130.14,110.88 129.22,109.97 129.22,103.29 130.53,101.99 130.53,100.31
  BOTTOM w0.102: v3(131.05,98.99) 131.18,98.99 UC1.F11 ; v1(125.21,136.89) 125.2,136.9 125.2,137.14 JGFX1.28
PEG_GTX_C_HRX_P2: length 47.7
  IN3 w0.102: v1(123.18,136.82) 123.43,136.56 123.43,134.43 118.17,129.18 118.17,126.2 119.42,124.95 119.42,123.86 121.42,121.86 121.42,121.17 122.67,119.93 122.67,117.08 123.05,116.7 123.05,115.38 125,113.42 125,109.77 126.76,108.01 126.76,102.61 128.76,100.6 128.76,99.48 128.53,99.25 128.53,99.04 128.5,99.01 v3(128.29,99.01)
  BOTTOM w0.102: v3(128.29,99.01) 128.7,99.01 128.78,98.93 UC1.G16 ; v1(123.18,136.82) 123.18,137.1 123.33,137.25 123.79,137.25 123.89,137.35 123.89,137.53 123.7,137.72 JGFX1.34
PEG_GTX_C_HRX_P3: length 60.7
  IN3 w0.076: v3(129.18,99.02) 129.18,98.88 128.65,98.35 128.65,97.8 128.98,97.47 130.1,97.47 130.35,97.22 131.25,97.22 131.57,97.54 131.57,100.58 131.24,100.91 131.24,101.12 131.25,101.13
  IN3 w0.102: v1(127.44,139.51) 127.24,139.51 127.14,139.41 127.14,138.82 127.93,138.04 127.93,135.45 127.67,135.19 127.67,129.03 131.16,125.54 132.7,125.54 135.93,122.31 136.74,122.31 137.4,121.65 137.4,115.25 136.84,114.69 132.76,114.69 131.38,113.32 131.38,110.53 131.38,110.47 131.38,110.42 130.21,109.25 130.21,103.29 131.25,102.25 131.25,101.13
  BOTTOM w0.102: UC1.F15 129.38,99.02 v3(129.18,99.02) ; v1(127.44,139.51) 127.3,139.51 127.2,139.41 JGFX1.20
PEG_HTX_C_GRX_N0: length 6.3
  TOP w0.121: v1(115.71,140.09) 115.49,140.09 115.4,140.18 115.4,140.4 115.3,140.51 115.21,140.51 114.84,140.15 114.84,139.7 114.62,139.48 114.62,139.33 114.7,139.25 114.96,139.25 115.05,139.16 115.05,139.05 114.95,138.95 CU16.1
  BOTTOM w0.121: JGFX1.64 116.2,139.23 116.17,139.27 116.17,139.44 116.21,139.48 116.42,139.48 116.48,139.54 116.48,139.98 116.12,140.33 115.94,140.33 v1(115.71,140.09)
PEG_HTX_C_GRX_N1: length 6.3
  TOP w0.121: CU18.1 112.75,138.56 112.45,138.86 112.45,139.14 113.38,140.07 113.5,140.07 113.67,139.9 113.81,139.9 v1(113.98,140.07)
  BOTTOM w0.121: v1(113.98,140.07) 114.3,139.76 114.38,139.76 114.46,139.84 114.46,140.06 114.55,140.15 114.81,140.15 114.98,139.98 114.98,139.49 114.9,139.41 114.67,139.41 114.55,139.28 114.55,139.15 114.7,138.99 JGFX1.70
