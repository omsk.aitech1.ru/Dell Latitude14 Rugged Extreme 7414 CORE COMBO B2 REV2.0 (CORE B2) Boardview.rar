# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 165.16,110.22 165.16,109.97 164.53,109.34 162.62,109.34 160.97,110.99 160.97,111.24 161.1,111.37 162.88,111.37 163,111.49 163.89,111.49
GND on TOP (solid shape): 220.64,59.04 220.64,56.4 220.28,56.05 219.57,56.05 219.52,56.1 219.52,56.81 219.87,57.16 219.87,59.02 220.03,59.17 220.51,59.17
GND on TOP (solid shape): 231.84,30.34 231.84,29.71 231.71,29.58 230.57,29.58 230.44,29.71 230.44,30.34 230.57,30.47 231.71,30.47
GND on TOP (solid shape): 242.37,69.6 242.37,69.09 242.11,68.83 240.46,68.83 240.21,69.09 240.21,69.6 240.33,69.72 242.24,69.72
GND on TOP (solid shape): 116.32,115.33 116.32,109.56 115.83,109.08 114.49,109.08 114.23,109.34 114.23,115.05 114.62,115.43 116.22,115.43
GND on TOP (solid shape): 131.2,114.08 131.2,109.51 131.02,109.34 129.47,109.34 129.32,109.49 129.32,114.95 129.55,115.18 130.11,115.18
GND on TOP (solid shape): 141.57,139.26 141.57,139.15 140.6,138.19 140.6,137.28 140.45,137.12 138.95,137.12 138.64,137.43 138.64,139.18 138.95,139.48 141.34,139.48
GND on TOP (solid shape): 151.8,55.91 151.8,53.96 151.55,53.71 149.79,53.71 148.91,54.6 148.91,56.38 149.05,56.52 151.19,56.52
GND on TOP (solid shape): 183.58,107.02 183.58,101.59 182.19,100.2 181.66,100.2 181.54,100.32 181.54,107.28 181.57,107.3 183.3,107.3
GND on TOP (solid shape): 202.25,62.42 202.25,61.61 201.95,61.32 200.92,61.32 200.8,61.44 200.8,63.22 200.82,63.25 201.42,63.25
GND on TOP (solid shape): 239.3,38.67 239.3,38.34 239.13,38.16 239.13,36.23 239.05,36.16 238.67,36.16 238.59,36.23 238.59,38.34 239.01,38.75 239.23,38.75
GND on TOP (solid shape): 56.96,96.38 56.96,94.35 56.83,94.22 55.69,94.22 55.31,93.84 54.67,93.84 54.16,94.35 54.16,95.49 55.18,96.51 56.83,96.51
GND on TOP (solid shape): 98.56,93.36 99.05,93.36 99.1,93.31 99.1,93.08 98.92,92.9 97.47,92.9 97.39,92.98 97.39,93.28 97.47,93.36 97.85,93.36 98.11,93.61 98.31,93.61
GND on TOP (solid shape): 135.44,133.85 135.44,132.2 137.09,130.54 137.09,129.4 136.98,129.29 134.29,129.29 134.28,129.3 134.28,129.76 132.4,131.64 132.4,134.1 132.9,134.61 134.68,134.61
GND on TOP (solid shape): 139.69,60.8 139.69,58.71 139.15,58.18 136.61,58.18 136.51,58.28 136.51,60.74 136.71,60.95 139.53,60.95
GND on TOP (solid shape): 154.11,31.61 154.11,31.1 153.1,30.09 151.06,30.09 151.04,30.11 151.04,30.93 151.47,31.36 151.95,31.36 152.46,31.87 153.86,31.87
GND on TOP (solid shape): 173.04,24.12 173.04,22.45 172.91,22.32 168.85,22.32 168.72,22.45 168.72,23.86 169.1,24.25 172.91,24.25
GND on TOP (solid shape): 220.53,51.93 220.53,48.68 220.18,48.32 219.47,48.32 219.39,48.4 219.39,48.88 219.9,49.39 219.9,51.37 220.05,51.52 220.05,51.96 220.15,52.06 220.41,52.06
GND on TOP (solid shape): 273.03,34.55 273.03,26.45 272.75,26.17 269.41,26.17 269.1,26.48 269.1,28.53 269.26,28.68 271.27,28.68 271.69,29.1 271.69,34.51 272.02,34.84 272.74,34.84
GND on TOP (solid shape): 42.43,95.11 42.73,95.11 42.89,94.96 42.89,94.65 42.81,94.58 42.26,94.58 41.94,94.9 40.76,94.9 40.7,94.96 40.7,95.35 40.77,95.41 42.13,95.41
GND on TOP (solid shape): 122.9,115.66 122.9,109.28 122.82,109.21 121.58,109.21 121.32,109.46 121.32,113.81 121.88,114.36 121.88,115.35 122.36,115.84 122.72,115.84
GND on TOP (solid shape): 79.79,75.43 79.79,74.71 79.61,74.54 78.6,74.54 78.27,74.21 75.37,74.21 75.04,74.54 75.04,74.99 75.27,75.22 77.94,75.22 78.32,75.6 79.61,75.6
GND on TOP (solid shape): 173.42,118.99 173.42,118.73 173.29,118.61 172.5,118.61 172.27,118.83 171.94,118.83 171.87,118.91 170.88,118.91 170.78,119.01 170.78,119.34 170.85,119.42 172.98,119.42
GND on TOP (solid shape): 186.85,133.08 186.85,129.38 186.55,129.07 185.51,129.07 185.2,129.38 183.22,129.38 182.99,129.6 182.99,131.69 182.31,132.37 182.31,132.98 182.48,133.16 183.37,133.16 183.48,133.26 186.68,133.26
GND on TOP (solid shape): 187.77,40.2 187.77,37.71 187.64,37.58 179.11,37.58 178.78,37.91 178.78,39.89 179.94,41.06 186.9,41.06
GND on TOP (solid shape): 104.35,37.48 105.17,36.67 105.17,36.26 105.04,36.13 104.74,36.13 104.23,36.64 101.41,36.64 101.23,36.82 101.23,37.78 101.81,38.37 103.39,38.37 103.62,38.6 104.35,38.6
GND on TOP (solid shape): 143.42,46.57 143.42,45.39 143.58,45.23 143.58,44.7 143.44,44.57 142.68,44.57 142.05,45.2 141.67,45.2 141.51,45.35 141.51,46.52 141.59,46.6 143.39,46.6
GND on TOP (solid shape): 267.14,48.65 267.85,48.65 267.87,48.64 267.87,48.03 267.8,47.97 267.12,47.97 266.96,48.12 266.43,48.12 266.2,48.35 266.2,48.83 266.38,49.01 266.79,49.01
GND on TOP (solid shape): 32.37,137.83 32.37,137.83 32.8,137.4 32.8,133.52 32.7,133.41 32.14,133.41 32.06,133.49 32.06,136.29 31.23,137.12 31.23,137.15 31.17,137.21 31.17,138.33 31.26,138.42 31.78,138.42
GND on TOP (solid shape): 92.88,26.79 93,26.76 93.13,26.78 93.36,26.56 93.36,25.31 93.25,25.21 92.7,25.21 92.59,25.31 92.59,26.63 92.75,26.79
GND on TOP (solid shape): 118.55,100.32 118.55,99.94 117.92,99.3 117.92,97.65 117.79,97.52 117.66,97.52 117.54,97.4 117.54,97.27 117.41,97.14 117.28,97.14 117.16,97.27 117.16,99.43 118.17,100.45 118.43,100.45
GND on TOP (solid shape): 126.02,130.87 126.02,125.37 125.9,125.24 125.31,125.24 125.16,125.39 125.16,126.1 124.27,126.99 124.27,127.37 123.51,128.13 123.51,130.09 124.37,130.95 125.94,130.95
GND on TOP (solid shape): 149.79,39.49 149.79,37.45 146.11,37.45 145.86,37.71 145.86,38.09 146.11,38.34 148.27,38.34 148.4,38.47 148.4,39.1 148.46,39.17 148.82,39.17 148.98,39.33 148.98,39.51 149.12,39.65 149.63,39.65
GND on TOP (solid shape): 190.31,65.39 190.69,65.39 190.82,65.27 190.82,64.25 190.69,64.12 190.26,64.12 189.55,64.83 188.81,64.83 188.75,64.9 188.75,65.86 188.94,66.05 189.65,66.05
GND on TOP (solid shape): 148.37,42.1 148.46,42 148.56,41.91 148.87,41.61 148.87,41.15 148.73,41.01 144.54,41.01 144.45,41.1 144.45,42.06 144.64,42.25 148.22,42.25
GND on TOP (solid shape): 220.53,30.6 220.53,29.33 219.77,28.56 218.37,28.56 215.2,25.39 212.66,25.39 212.41,25.64 212.41,28.06 212.79,28.44 214.69,28.44 215.26,29.01 215.26,29.77 216.22,30.72 220.41,30.72
GND on TOP (solid shape): 141.01,116.83 141.67,116.83 141.79,116.7 141.79,115.81 141.54,115.56 140.9,115.56 140.52,115.18 137.83,115.18 137.73,115.28 137.73,115.84 137.85,115.96 138.29,115.96 139.38,117.06 140.78,117.06
GND on TOP (solid shape): 185.14,23.75 185.14,23.21 185,23.07 184.79,23.07 184.55,23.31 183.9,23.31 183.79,23.2 183.79,22.68 183.74,22.63 183.46,22.63 183.41,22.68 183.41,23.2 183.3,23.31 182.85,23.31 182.75,23.4 182.75,24.18 182.84,24.27 184.62,24.27
GND on TOP (solid shape): 188.4,69.2 188.4,63.23 188.15,62.98 185.48,62.98 185.35,63.11 185.35,67.17 185.74,67.55 186.88,67.55 187.01,67.68 187.01,69.46 187.13,69.58 188.02,69.58
GND on TOP (solid shape): 215.33,61.84 215.33,59.68 215.2,59.55 214.69,59.55 214.56,59.42 214.56,58.71 214.39,58.54 213.68,58.54 213.6,58.61 213.6,60.21 213.83,60.44 214.54,60.44 214.56,60.47 214.56,61.84 214.69,61.96 215.2,61.96
GND on TOP (solid shape): 26.47,98.72 28.88,98.72 29.69,97.91 29.69,97.61 29.66,97.58 28.79,97.58 28.45,97.92 27.52,97.92 27.39,98.04 26.43,98.04 26.2,98.27 25.82,98.27 25.71,98.38 25.71,98.67 25.84,98.8 26.4,98.8
GND on TOP (solid shape): 37.66,91.81 37.66,87.37 37.4,87.11 34.86,87.11 34.74,87.24 34.74,89.14 34.23,89.65 34.23,90.03 34.74,90.54 34.74,91.81 34.86,91.94 37.53,91.94
GND on TOP (solid shape): 107.4,116.83 107.4,109.59 107.12,109.31 106.63,109.31 106.46,109.51 106.21,109.56 105.98,109.79 105.98,116.78 106.12,116.92 107.31,116.92
GND on TOP (solid shape): 199.88,30.37 199.88,29.1 196.61,25.83 195.38,25.83 195.12,25.56 191.56,25.56 191.27,25.86 189.08,25.86 188.01,26.93 188.01,27.28 188.01,27.28 188.01,28.57 188.03,28.59 188.25,28.82 196.29,28.82 197.45,29.97 197.45,30.43 197.62,30.61 199.64,30.61
GND on TOP (solid shape): 207.4,61.56 207.4,60.57 209.23,60.57 209.36,60.44 209.36,59.93 209.23,59.81 204.71,59.81 204.56,59.96 204.56,60.83 204.66,60.94 205.74,60.94 205.83,60.85 205.83,60.62 205.88,60.57 207.25,60.57 207.25,61.56 207.27,61.58 207.38,61.58
GND on TOP (solid shape): 139.03,125.49 139.03,124.92 139.01,124.82 139.03,124.72 139.03,123.69 138.77,123.43 136.31,123.43 136.05,123.69 136.05,125.16 134.38,125.16 134.33,125.11 134.33,123.86 134.3,123.84 134.17,123.84 134.15,123.86 134.15,125.67 134.17,125.69 138.82,125.69
GND on TOP (solid shape): 146.12,74.42 148.87,74.42 149.95,73.34 149.95,72.61 149.79,72.45 149.49,72.45 148.91,71.87 146.24,71.87 146.11,72 146.11,72.89 145.98,73.01 144.46,73.01 144.33,73.14 144.33,74.31 144.46,74.44 146.11,74.44
GND on TOP (solid shape): 172.76,33.19 174.23,33.19 174.51,32.91 174.51,32.27 174.39,32.16 173.73,32.16 173.72,32.14 173.34,32.14 172.71,31.51 168.9,31.51 168.64,31.76 168.64,33.44 168.84,33.64 172.3,33.64
GND on TOP (solid shape): 188.3,110.2 188.3,109.46 188.4,109.36 191.43,109.36 191.48,109.31 191.48,106.37 191.36,106.25 190.45,106.25 190.36,106.34 190.36,107.66 190.21,107.81 189.67,107.81 189.52,107.96 189.52,108.34 189.34,108.52 187.87,108.52 187.72,108.67 187.72,110.15 187.84,110.27 188.22,110.27
GND on TOP (solid shape): 215.33,53.84 215.33,52.13 215.45,52.01 215.45,51.6 215.33,51.47 214.87,51.47 214.64,51.25 214.64,50.71 214.34,50.41 213.68,50.41 213.57,50.51 213.57,51.07 213.59,51.08 213.59,52.32 213.7,52.44 214.51,52.44 214.56,52.49 214.56,53.84 214.69,53.96 215.2,53.96
GND on TOP (solid shape): 97.34,57.01 97.34,55.11 96.96,54.73 95.82,54.73 95.44,54.34 95.44,52.19 94.17,50.92 94.17,49.77 94.04,49.65 92.9,49.65 92.71,49.84 92.71,50.72 93.85,51.87 93.85,54.66 93.53,54.98 93.53,57.01 93.79,57.27 97.09,57.27
GND on TOP (solid shape): 23.43,128.77 21.42,128.77 21.27,128.91 20.92,129.27 20.52,128.98 20.3,128.77 18.41,128.77 18.41,132.7 23.43,132.7
GND on TOP (solid shape): 212.46,59.17 212.46,58.94 212.74,58.66 213.24,58.66 213.29,58.61 213.29,57.98 213.22,57.9 211.77,57.9 211.23,58.44 211.15,58.55 211.04,58.63 211.01,58.66 210.04,58.66 209.97,58.74 209.97,59.45 210.12,59.6 212.02,59.6
GND on TOP (solid shape): 209.48,65.11 209.48,63.54 209.41,63.46 208.75,63.46 208.72,63.49 208.72,64.68 208.56,64.85 208.43,64.85 208.34,64.76 208.34,64.38 208.32,64.35 207.88,64.35 207.88,64.81 207.78,64.91 207.53,64.91 207.45,64.83 207.45,64.38 207.43,64.35 206.97,64.35 206.97,64.99 207.4,65.42 207.4,65.75 207.53,65.88 208.72,65.88
GND on TOP (solid shape): 87.86,62.92 92.33,62.92 92.52,62.73 92.52,59.93 92.33,59.74 91.18,59.74 90.93,59.49 90.93,58.34 90.23,57.65 87.18,57.65 86.8,57.27 80.45,57.27 80.33,57.39 80.33,58.03 80.45,58.15 84.52,58.15 84.64,58.28 84.64,60.44 84.77,60.57 86.17,60.57 86.42,60.82 86.42,60.82 86.42,63.62 86.55,63.74 87.03,63.74
GND on TOP (solid shape): 66.56,138.29 66.56,137.76 67.63,136.69 67.63,135.98 67.7,135.9 69.25,135.9 70.04,136.69 70.55,136.69 70.67,136.56 70.67,134.53 70.24,134.1 70.24,133.67 70.17,133.59 69.58,133.59 68.9,134.28 68.9,134.99 68.82,135.07 67.09,135.07 66.79,135.37 66.79,136.34 66.61,136.51 65.95,136.51 65.8,136.67 65.8,138.29 65.87,138.37 66.48,138.37
GND on TOP (solid shape): 107.55,79.41 107.55,76.67 107.64,76.58 107.63,76.57 107.63,75.05 107.3,74.71 107.3,69.89 106.36,68.95 103.89,68.95 103.77,69.08 103.77,69.76 97.85,75.68 97.09,75.68 96.96,75.81 96.96,77.08 97.09,77.2 98.61,77.2 103.69,72.12 103.75,72.05 103.82,72 104.69,71.13 105.61,71.13 105.85,71.37 105.85,75.22 106.87,76.24 106.87,78.93 106.41,79.39 106.41,79.69 106.51,79.79 107.17,79.79
GND on TOP (solid shape): 185.74,58.94 185.74,57.01 185.23,56.5 185.23,54.8 185.3,54.73 187.36,54.73 187.46,54.62 187.46,52.57 187.97,52.06 191.32,52.06 191.45,51.93 191.45,51.25 190.61,50.41 190.1,50.41 190,50.31 190,49.7 189.95,49.65 187.16,49.65 187.11,49.7 187.04,49.74 185.05,51.73 185.05,52.26 184.08,53.23 184.08,56.05 184.14,56.1 184.14,56.68 183.83,56.99 183.83,58.34 183.88,58.45 183.89,58.57 183.89,58.6 184.47,59.17 185.51,59.17
GND on TOP (solid shape): 117.31,73.6 119.34,73.6 119.67,73.27 119.67,72.33 119.45,72.11 119.45,70.59 119.7,70.35 121.65,70.35 121.83,70.17 121.83,69.2 121.12,68.49 118.48,68.49 118.4,68.42 118.4,67.96 118.32,67.88 117.89,67.88 117.84,67.93 117.84,68.26 117.82,68.29 117,68.29 116.77,68.52 116.77,68.77 116.7,68.85 115.96,68.85 115.78,68.67 115.78,67.2 115.66,67.07 115.17,67.07 115.05,67.2 115.05,68.85 115.38,69.18 115.38,74.94 115.48,75.05 115.86,75.05
GND on TOP (solid shape): 122.74,130.29 122.74,129.53 122.36,129.15 122.36,127.24 122.11,126.99 120.71,126.99 120.53,126.81 120.53,122.59 119.95,122.01 119.95,120.51 119.7,120.26 116.52,120.26 116.27,120.51 116.27,123.94 116.52,124.19 118.1,124.19 118.17,124.12 119.01,124.12 119.21,124.32 119.21,124.8 118.98,125.03 118.98,126.56 118.71,126.84 115.17,126.84 114.31,125.97 111.34,125.97 111.34,124.6 111.29,124.55 111.21,124.55 111.19,124.58 111.19,125.92 111.13,125.97 108.4,125.97 108.27,126.1 108.27,127.88 108.4,128.01 115.5,128.01 116.74,129.24 118.26,129.24 119.57,130.54 122.49,130.54
GND on TOP (solid shape): 228.2,37.91 228.2,36.95 212.76,36.95 212.13,36.31 207.71,36.31 207.58,36.44 207.58,38.09 207.83,38.34 209.33,38.34 209.59,38.6 209.59,39.79 210.3,39.79 210.7,39.38 211.15,39.38 211.26,39.37 211.38,39.38 212.04,39.38 212.15,39.37 212.27,39.38 212.92,39.38 213.04,39.37 213.16,39.38 213.52,39.38 214.13,39.99 226.12,39.99
GND on TOP (solid shape): 198.59,49.14 198.59,48.53 195.92,45.86 193.66,45.86 193.43,46.09 193.43,46.98 193.35,47.06 193.35,47.07 193.01,47.38 192.62,47.14 192.62,47.13 192.37,46.88 192.04,46.88 191.96,46.88 191.88,46.88 191.3,46.88 191.17,47 191.17,47.66 191.32,47.82 193.38,47.82 193.74,48.17 193.74,49.26 193.86,49.39 198.33,49.39
GND on TOP (solid shape): 155.66,110.71 155.66,109.11 155.52,108.97 155.29,108.97 155.21,109.06 155.21,109.52 155.13,110.02 154.62,110 154.35,109.73 154.35,108.83 153.45,107.93 153.45,106.8 153.3,106.64 152.13,106.64 151.88,106.9 151.88,107.96 152.64,108.73 152.64,110.17 153.15,110.68 154.6,110.68 154.72,110.81 155.56,110.81
GND on TOP (solid shape): 68.13,108.83 68.13,108.28 67.8,107.95 67.8,106.67 67.37,106.24 67.37,104 69.28,102.1 69.28,99.37 68.8,98.9 64.56,98.9 64.2,99.26 64.2,99.93 63.56,100.56 62.42,100.56 62.13,100.27 62.13,96.18 62.37,95.94 62.37,92.98 63.03,92.98 63.06,92.95 63.06,92.85 63.03,92.83 62.37,92.83 62.37,91.86 62.29,91.78 62.29,91.3 62.16,91.17 59.5,91.17 59.37,91.3 59.37,91.56 59.62,91.81 60.18,91.81 60.44,92.06 60.44,95.7 60.42,95.71 60.42,96.22 60.15,96.5 60.15,100.7 59.5,101.35 59.5,105.4 61.78,107.68 63.33,107.68 64.5,108.85 68.11,108.85
GND on TOP (solid shape): 90.26,126.31 90.42,126.17 90.62,126.18 90.72,126.17 90.77,126.08 90.77,125.65 90.66,125.54 90.66,125.08 90.53,124.96 89.8,124.96 89.7,125.05 89.7,125.53 89.61,125.63 89.58,125.72 89.64,125.8 89.74,125.85 89.81,125.93 89.97,126.09 90,126.19 90.06,126.24 90.11,126.31
GND on TOP (solid shape): 116.01,99.18 116.01,97.65 115.76,97.4 115.76,97.27 115.25,96.76 115.25,96.51 115.5,96.25 115.89,96.25 116.01,96.13 116.01,94.98 116.14,94.86 116.77,94.86 116.9,94.98 116.9,96 117.03,96.13 117.16,96.13 117.28,96 117.28,94.98 117.41,94.86 118.04,94.86 118.17,94.98 118.17,96 118.3,96.13 118.43,96.13 118.55,96 118.55,94.6 118.3,94.35 118.3,91.05 118.04,90.79 117.79,90.79 117.41,90.41 117.41,88.76 117.29,88.64 117.27,88.63 116.53,88.63 116.52,88.64 116.39,88.76 116.39,90.41 116.14,90.67 116.01,90.67 115.63,91.05 115.63,94.35 115.5,94.48 115.12,94.48 115,94.6 115,98.74 115.12,98.87 115.12,99.18 115.25,99.3 115.89,99.3
GND on TOP (solid shape): 106.69,123.58 107.4,123.58 107.48,123.51 107.48,121.81 107.12,121.45 107.03,121.45 106.31,121.45 105.29,120.43 104.96,120.43 104.81,120.59 104.81,121.37 105.53,122.09 105.6,122.12 105.67,122.09 106.31,122.26 105.85,122.74 105.76,122.76 105.73,122.84 105.73,123.91 105.88,124.07 106.21,124.07
GND on TOP (solid shape): 188.68,101.16 188.68,99.45 188.38,99.15 186.29,99.15 186.04,98.9 186.04,86.25 186.03,86.23 186.03,86.03 185.63,85.64 185.25,85.64 185,85.38 185,84.8 184.92,84.72 184.49,84.72 184.41,84.8 184.41,85.69 184.62,85.89 185,85.89 185.23,86.12 185.23,87.29 184.24,87.29 184.21,87.31 184.21,87.44 184.24,87.47 185.2,87.47 185.23,87.49 185.23,91.45 183.98,91.45 183.78,91.25 183.22,91.25 183.09,91.38 183.09,91.68 183.22,91.81 183.86,91.81 184.01,91.66 185.2,91.66 185.23,91.68 185.23,92.9 185.18,92.95 185.18,97.4 185.15,97.42 184.01,97.42 183.86,97.27 183.55,97.27 183.45,97.37 183.45,97.6 183.57,97.72 183.81,97.72 183.91,97.63 185.15,97.63 185.18,97.65 185.18,98.77 185.2,98.79 185.2,99.91 186.65,101.36 188.48,101.36
GND on TOP (solid shape): 113.22,28.44 113.22,28.18 112.96,27.93 112.96,24.93 117.13,24.93 117.31,25.11 117.31,27.65 117.97,28.31 118.12,28.31 119.06,27.37 119.06,25.26 119.39,24.93 121.52,24.93 122.13,24.32 123.71,24.32 123.89,24.5 123.89,25.01 124.01,25.13 124.27,25.13 124.43,24.98 124.43,23.91 124.27,23.75 102.36,23.75 102.25,23.86 102.25,26.84 102.86,27.45 103.77,27.45 103.97,27.24 103.97,26.76 104.18,26.56 105.5,26.56 105.65,26.71 106.03,26.71 106.09,26.65 106.09,25.55 106.31,25.34 107.12,25.34 107.3,25.52 107.3,26.51 107.5,26.71 107.94,26.71 108.42,26.23 108.42,25.31 108.8,24.93 110.86,24.93 111.06,25.13 111.06,27.89 111.35,27.89 111.35,26.44 111.74,26.05 112.13,26.05 112.57,26.49 112.57,27.89 112.48,27.98 112.48,27.99 112.47,27.99 112.46,28.01 111.46,28.01 111.45,27.99 111.42,27.99 111.42,27.96 111.35,27.89 111.06,27.89 111.06,28.69 111.44,29.07 112.58,29.07
GND on TOP (solid shape): 15.96,114.13 15.96,113.23 15.37,112.64 13.26,112.64 11.66,111.04 11.27,111.04 11.19,111.07 11.17,111.15 11.16,111.31 11.11,111.46 11.05,111.55 10.99,111.63 10.96,111.7 11.17,112.2 10.96,112.7 10.99,112.77 11.13,112.98 11.17,113.23 11.19,113.31 11.27,113.34 11.79,113.34 12.31,113.85 12.31,114.85 12.74,115.28 14.81,115.28
GND on TOP (solid shape): 13.6,111.45 15.18,111.45 15.33,111.6 15.56,111.6 15.71,111.45 15.71,111.19 15.58,111.06 15.3,111.06 15.23,111.14 13.7,111.14 13.45,111.14 11.82,109.51 11.82,109.25 10.63,108.07 10.31,108.07 10.17,108.2 10.17,108.57 10.22,108.65 10.32,108.66 11.06,108.86 10.99,109.63 10.96,109.7 10.99,109.77 11.12,109.97 11.17,110.21 11.2,110.28 11.27,110.31 11.96,110.31 13.25,111.6 13.45,111.6
GND on TOP (solid shape): 141.21,26.94 141.21,26.94 141.58,26.79 141.88,27.05 141.89,27.09 142.05,27.09 142.17,26.96 143.57,26.96 143.57,26.96 144.04,26.96 144.28,26.72 144.52,26.72 144.84,26.62 145.16,26.72 146.21,26.72 146.68,26.25 147.41,26.25 147.76,25.9 147.76,25.29 147.67,25.2 140.87,25.2 140.75,25.07 140.75,24.21 140.29,23.75 136.83,23.75 136.35,24.22 136.35,26.69 136.42,26.76 136.74,26.76 136.98,26.51 136.98,25.23 137.15,25.06 139.41,25.06 139.54,25.19 139.54,26.4 139.28,26.65 139.28,26.96 139.38,27.06 139.41,27.05 139.54,27.04 139.68,27.08 139.74,27.11 139.8,27.17 140.98,27.17
GND on TOP (solid shape): 273.14,64.29 273.14,53.81 272.74,53.41 272.06,53.41 271.72,53.76 271.72,55.43 271.21,55.94 271.21,58.13 271.33,58.39 271.24,58.66 271.24,59.05 271.26,59.53 270.78,59.64 270.68,59.64 270.64,59.73 270.64,63.11 270.67,63.12 270.95,63.48 270.69,63.85 270.66,63.86 270.66,64.44 270.94,64.73 272.71,64.73
GND on TOP (solid shape): 16.02,116.78 16.09,116.7 16.09,116.55 16.02,116.47 12.22,116.47 11.58,115.83 11.58,114.15 11.49,114.06 11.27,114.06 11.19,114.09 11.17,114.17 11.13,114.42 10.99,114.63 10.96,114.7 11.17,115.2 10.96,115.7 11.17,116.2 10.96,116.7 10.99,116.77 11,116.78 16.02,116.78
GND on TOP (solid shape): 114.56,38.27 114.56,37.43 114.36,37.23 114.3,36.54 114.86,36.95 114.86,36.98 115.6,37.72 115.6,37.92 116.03,38.34 125.02,38.34 125.17,38.19 125.17,37.15 125.18,37.15 125.92,36.41 127.67,36.41 127.9,36.18 127.9,34.96 127.75,34.81 127.44,34.81 126.99,35.27 124.7,35.27 124.59,35.15 124.59,34.72 123.63,33.77 110.15,33.77 110.09,33.72 110.09,32.55 109.92,32.37 108.88,32.37 108.82,32.42 108.82,35.89 108.01,36.7 108.01,37.96 108.02,37.97 108.02,38.08 108.29,38.34 114.49,38.34
GND on TOP (solid shape): 85.32,130.5 85.35,130.48 85.4,130.43 85.45,130.38 85.47,130.31 85.52,130.25 85.52,129.7 85.66,129.56 85.72,129.54 85.73,129.53 85.77,129.48 85.83,129.44 85.83,129.28 85.76,129.23 85.71,129.16 85.7,129.15 85.49,128.94 85.49,128.74 85.45,128.67 85.37,128.66 85.19,128.64 85.06,128.51 85.04,128.48 84.96,128.48 84.86,128.58 84.77,128.66 84.77,128.78 84.8,128.79 84.94,129.03 84.8,129.28 84.77,129.29 84.77,129.43 84.8,129.44 84.94,129.68 84.8,129.93 84.77,129.94 84.77,130.08 84.8,130.09 84.93,130.27 84.89,130.49 84.87,130.52 84.92,130.57 85.31,130.57
GND on TOP (solid shape): 90.59,99.52 90.89,99.4 91.2,99.52 92.05,99.52 92.71,98.86 96.07,98.86 97.62,98.26 99.46,98.26 99.57,98.37 99.57,98.46 99.71,98.59 99.91,98.59 99.99,98.51 99.99,98.28 100.23,98.03 100.23,98.01 100.25,97.9 100.3,97.8 100.57,97.59 100.91,97.63 101.27,97.63 101.64,97.26 101.64,96.99 101.56,96.91 101.23,96.91 101.22,96.92 101.1,96.95 100.99,96.92 100.97,96.91 100.58,96.91 97.6,96.91 96.15,97.52 90.21,97.52 89.75,97.52 89.32,97.52 89.32,97.52 88.86,97.52 88.86,97.52 88.46,97.52 88.46,97.52 87.99,97.52 87.99,97.52 87.59,97.52 87.59,97.52 87.13,97.52 86.7,97.52 86.7,97.52 86.24,97.52 86.24,97.52 85.82,97.52 85.81,97.52 85.35,97.52 84.93,97.52 84.93,97.52 84.46,97.52 84.46,97.52 84.04,97.52 84.04,97.52 83.57,97.52 83.1,97.52 82.74,97.52 82.49,97.78 82.49,97.85 82.49,99.26 82.74,99.52
GND on TOP (solid shape): outline of 98 points within 119.19,88.13 126.17,99.43
GND on TOP (solid shape): 161.85,152.77 161.93,152.72 161.95,152.63 161.9,152.47 161.89,152.31 161.89,151.5 161.81,151.5 161.81,150.25 162,149.66 162.49,149.28 162.49,149.35 162.55,149.35 162.56,149.34 163.11,149.34 163.58,149.65 163.69,149.68 163.76,149.58 163.76,149.47 163.76,144.65 163.76,144.59 163.74,144.58 163.29,143.92 163.38,143.13 163.38,140.35 163.36,140.32 162.06,140.32 160.96,139.22 157.96,139.22 157.24,139.95 156.93,139.95 156.93,139.95 156.78,139.95 156.78,141.14 156.76,141.15 156.79,141.22 158.14,141.22 158.16,141.19 158.24,141.1 158.32,141.01 159.79,140.96 160.08,142.39 160.08,142.48 160.16,142.54 160.62,142.8 160.81,143.31 160.81,144.3 160.51,144.91 159.76,145.07 159.72,145.15 159.72,152.77
GND on TOP (solid shape): outline of 209 points within 71.46,128.76 81.27,139.28
GND on TOP (solid shape): 106,100.57 106.09,100.53 106.1,100.44 106.08,100.23 106.18,100.05 106.21,99.98 106.18,99.91 106.19,99.4 106.7,99.42 106.96,99.16 107.37,98.68 107.55,99.28 107.53,99.32 107.55,99.35 107.6,99.42 107.63,99.49 107.64,99.51 107.71,99.58 107.81,99.55 107.82,99.53 107.83,99.52 107.93,99.38 108.15,99.29 108.22,99.29 108.85,98.67 109.54,98.67 109.76,98.9 109.76,99.12 109.94,99.3 110.17,99.3 110.3,99.18 110.3,98.79 110.17,98.67 110.17,98.39 110.04,98.26 107.58,98.26 107.57,98.27 106.89,97.6 106.18,97.6 105.93,97.85 105.93,98.64 105.75,98.82 105.82,99.04 105.74,99.26 105.72,99.32 105.74,99.39 105.47,99.97 105.19,99.39 105.21,99.32 105.19,99.26 105.11,99.07 105.15,98.87 105.16,98.84 104.99,98.67 104.99,97.73 104.89,97.63 104.1,97.63 103.95,97.78 103.95,99.05 104.28,99.38 104.77,99.38 104.79,99.88 104.77,99.94 104.79,100.01 104.88,100.21 104.84,100.42 104.84,100.52 104.93,100.57
GND on TOP (solid shape): outline of 284 points within 42.38,128.93 83.48,153.09
GND on TOP (solid shape): 144.85,145.15 144.81,145.07 144.73,145.05 144.06,144.91 143.76,144.3 143.76,143.31 143.95,142.8 144.42,142.54 144.49,142.48 144.49,142.39 144.9,140.88 146.43,141.22 148.08,141.22 148.18,141.16 148.16,141.05 148.01,140.83 147.93,140.57 147.92,140.49 147.92,140.41 147.94,140.25 148,140.09 147.99,139.99 147.91,139.95 146.95,139.95 144.73,139.57 143.17,141.2 143.12,141.24 143.08,141.22 138.69,140.27 136.71,144.3 136.71,145.78 135.06,147.44 134.68,147.44 134.55,147.31 134.55,146.42 134.43,146.29 133.92,146.29 133.79,146.42 133.79,147.31 133.68,147.42 129.23,147.42 127.62,146.93 126.08,147.6 126.04,147.65 125.44,148.7 125.43,149.91 125.47,149.91 125.47,151.19 127.12,151.19 127.12,150.27 126.96,148.52 128.7,148.69 134.96,148.69 136.05,149.49 135.59,150.77 135.59,152.77 144.85,152.77
GND on TOP (solid shape): outline of 370 points within 0.64,98.33 26.99,109.86
GND on TOP (solid shape): outline of 413 points within 0.64,117.91 16.03,143.5
GND on TOP (solid shape): outline of 573 points within 89.67,143.55 113.06,152.77
GND on TOP (solid shape): outline of 608 points within 85.82,125.88 90.65,132.19
GND on TOP (solid shape): outline of 748 points within 83.48,85.84 112.84,97.02
GND on TOP (solid shape): outline of 1951 points within 6.81,0.64 277.09,153.1
GND on BOTTOM (solid shape): 188.62,110.4 184.61,110.4 184.61,118.4 188.62,118.4
GND on BOTTOM (solid shape): 115.63,115.05 115.63,108.95 114.62,108.95 114.36,109.21 114.36,115.18 115.5,115.18
GND on BOTTOM (solid shape): 200.95,31.18 200.95,28.13 200.14,27.32 199.05,27.32 199.05,31.9 200.23,31.9
GND on BOTTOM (solid shape): 108.29,124.63 108.29,124.17 108.09,123.97 106.51,123.97 106.51,124.65 106.69,124.83 108.09,124.83
GND on BOTTOM (solid shape): 183.42,109.03 183.42,108.75 183.22,108.55 180.15,108.55 180.02,108.67 180.02,109.34 183.12,109.34
GND on BOTTOM (solid shape): 28.92,138.42 28.92,137.71 28.81,137.61 24.42,137.61 24.39,137.63 24.39,138.65 24.42,138.67 28.66,138.67
GND on BOTTOM (solid shape): 44.79,125.92 44.79,121.45 44.49,121.15 42.81,121.15 42.66,121.3 42.66,125.72 42.94,126 44.71,126
GND on BOTTOM (solid shape): 70.6,135.98 70.6,134.38 70.47,134.25 67.45,134.25 67.32,134.38 67.32,135.93 67.65,136.26 70.32,136.26
GND on BOTTOM (solid shape): 90.38,131.41 90.38,130.57 90.28,130.47 89.34,130.47 89.29,130.52 89.29,131.41 89.39,131.51 90.28,131.51
GND on BOTTOM (solid shape): 94.8,90.92 94.8,90.64 94.7,90.54 94.52,90.54 93.47,91.59 93.47,91.9 93.53,91.96 93.76,91.96
GND on BOTTOM (solid shape): 99.57,136.59 99.57,135.44 99.35,135.22 97.76,135.22 97.36,135.63 97.36,136.73 97.53,136.9 99.25,136.9
GND on BOTTOM (solid shape): 121.46,148.17 121.46,147.29 121.26,147.09 119.71,147.09 119.54,147.25 119.54,148.2 119.73,148.38 121.25,148.38
GND on BOTTOM (solid shape): 150.05,133.69 150.05,131.56 149.96,131.47 148.65,131.47 148.65,133.67 148.91,133.92 149.82,133.92
GND on BOTTOM (solid shape): 153.36,74.02 153.36,73.15 153,72.78 151.55,72.78 151.32,73.01 151.32,73.85 151.6,74.13 153.25,74.13
GND on BOTTOM (solid shape): 168.65,110.93 168.65,108.86 168.51,108.72 164.61,108.72 163.72,109.6 163.72,110.61 164.27,111.16 168.42,111.16
GND on BOTTOM (solid shape): 175.93,121.68 175.93,121.15 175.63,120.84 172.02,120.84 171.92,120.94 171.92,122.29 172.27,122.64 174.97,122.64
GND on BOTTOM (solid shape): 175.96,88.51 175.96,84.57 175.83,84.44 174.81,84.44 174.74,84.52 174.74,88.56 174.81,88.63 175.83,88.63
GND on BOTTOM (solid shape): 176.34,97.55 176.34,95.37 176.21,95.24 175.32,95.24 175.19,95.37 175.19,97.5 175.35,97.65 176.24,97.65
GND on BOTTOM (solid shape): 196.17,37.34 196.17,34.53 195.97,34.33 194.93,34.33 194.78,34.48 194.78,37.28 194.96,37.45 196.06,37.45
GND on BOTTOM (solid shape): 151.09,139.13 151.09,138.32 150.66,137.88 148.07,137.88 148.02,137.94 148.02,139.31 148.14,139.43 150.79,139.43
GND on BOTTOM (solid shape): 171.13,94.22 171.13,93.33 171,93.21 169.86,93.21 169.73,93.33 169.73,94.22 169.86,94.35 171,94.35
GND on BOTTOM (solid shape): 195.26,47.38 195.26,46.29 194.8,45.84 193.48,45.84 193.36,45.96 193.36,47.28 193.53,47.46 195.18,47.46
GND on BOTTOM (solid shape): 200.11,39.38 200.11,35.83 199.81,35.52 199.3,35.52 199.1,35.73 199.1,39.49 199.2,39.59 199.91,39.59
GND on BOTTOM (solid shape): 82.72,57.25 82.72,55.57 83.2,55.1 83.2,52.54 82.48,51.83 80.25,51.83 79.42,52.66 79.42,57.54 79.96,58.08 81.9,58.08
GND on BOTTOM (solid shape): 99.3,121.12 99.3,119.83 99.12,119.65 97.09,119.65 97.04,119.7 97.04,120.69 97.6,121.25 99.17,121.25
GND on BOTTOM (solid shape): 200.82,43.12 200.82,41.05 200.71,40.93 200.19,40.93 200.01,41.11 200.01,42.3 199.83,42.48 198.03,42.48 197.93,42.58 197.93,43.09 198.16,43.32 200.62,43.32
GND on BOTTOM (solid shape): 58.53,117.79 58.53,116.92 57.7,116.09 54.82,116.09 54.66,116.26 54.66,116.84 55.15,117.34 55.18,117.34 55.56,117.72 57.57,117.72 57.69,117.84 58.48,117.84
GND on BOTTOM (solid shape): 73.59,89.14 76.26,89.14 76.39,89.02 76.39,88.51 74.23,86.35 74.23,85.36 72.27,83.4 70.06,83.4 69.91,83.55 69.91,90.18 72.55,90.18
GND on BOTTOM (solid shape): 92.52,89.65 92.52,89.22 92.58,89.15 92.58,88.11 91.68,87.21 83.37,87.21 82.23,88.35 81.8,88.35 81.52,88.63 81.52,89.75 81.67,89.9 92.26,89.9
GND on BOTTOM (solid shape): 171,107.86 171,104.74 170.9,104.64 169.76,104.64 169.61,104.79 169.61,107.76 169.91,108.07 170.8,108.07
GND on BOTTOM (solid shape): 174.56,75.43 174.56,72.23 174.18,71.84 172.35,71.84 172.22,71.97 172.22,74.87 172.27,74.92 172.27,75.43 172.4,75.55 174.43,75.55
GND on BOTTOM (solid shape): 161.38,74.77 161.38,73.55 161.22,73.39 160.84,73.39 160.18,74.05 159.5,74.05 159.45,74.11 159.45,74.77 159.5,74.82 161.33,74.82
GND on BOTTOM (solid shape): 91.94,97.4 91.94,96.66 91.89,96.62 91.54,96.62 91.32,96.84 80.43,96.84 80.3,96.97 80.3,97.55 82.03,97.55 83.27,98.79 90.54,98.79
GND on BOTTOM (solid shape): 128.08,136.51 128.08,134.48 127.9,134.3 127.42,134.3 125.84,135.88 125.26,135.88 124.9,136.23 124.9,136.39 125.03,136.51 126.05,136.51 126.3,136.77 127.82,136.77
GND on BOTTOM (solid shape): 164.92,117.73 164.92,117.08 164.84,117.01 162.49,117.01 162.29,117.21 162.29,117.38 162.38,117.52 162.39,117.69 162.52,117.82 164.83,117.82
GND on BOTTOM (solid shape): 64.1,102.48 70.04,102.48 70.29,102.22 70.29,95.14 69.63,94.48 62.09,94.48 61.91,94.63 61.27,96.53 61.27,102.79 61.62,103.15 63.43,103.15
GND on BOTTOM (solid shape): 155.05,102.55 154.49,102.55 154.42,102.48 154.42,102.17 154.49,102.1 155.05,102.1 155.05,101.49 154.04,101.49 153.17,102.35 153.17,102.93 153.35,103.11 154.42,103.11 154.47,103.16 155.05,103.16
GND on BOTTOM (solid shape): 182.92,58.99 182.92,58.29 183.27,57.94 183.27,56.88 182.99,56.88 182.99,58.07 181.77,58.07 181.77,56.88 181.49,56.88 181.49,58.07 180.27,58.07 180.27,56.93 180,56.93 180,58.79 180.35,59.14 182.76,59.14
GND on BOTTOM (solid shape): 153.73,42.41 160.46,42.41 160.59,42.28 160.59,37.2 153.48,37.2 153.35,37.07 153.35,34.28 153.22,34.15 152.54,34.15 152.31,34.38 151.63,34.38 151.32,34.7 151.32,42.91 151.45,43.04 153.1,43.04
GND on BOTTOM (solid shape): 225.79,41.31 225.79,40.12 227.62,38.29 227.62,37.35 225.33,35.07 225.33,31.89 221.73,28.28 213.8,28.28 212.79,29.3 212.79,33.59 221.45,42.25 224.85,42.25
GND on BOTTOM (solid shape): 91.35,138.27 91.35,136.26 91.84,135.76 91.84,134.05 91.67,133.87 90.23,133.87 90.21,133.9 89.04,133.9 88.73,133.59 88.07,133.59 88.07,138.47 88.56,138.95 90.66,138.95
GND on BOTTOM (solid shape): 152.97,58.38 152.97,56.81 152.02,55.86 152.02,54 151.74,53.72 150.75,53.72 150.48,53.99 150.48,57.21 151.42,58.15 152.06,58.15 152.35,58.45 152.9,58.45
GND on BOTTOM (solid shape): 51.98,132.32 51.98,131.05 51.65,130.72 51.65,128 51.98,127.67 51.98,126.25 51.83,126.1 50.25,126.1 50.15,126.2 50.15,127.24 50.89,127.98 50.89,132.3 51.01,132.42 51.88,132.42
GND on BOTTOM (solid shape): 141.03,119.62 141.03,115.18 140.84,114.99 137.92,114.99 137.76,115.15 137.76,116.02 137.83,116.09 138.57,116.09 138.82,116.35 138.82,117.03 140.14,118.35 140.14,119.62 140.27,119.75 140.9,119.75
GND on BOTTOM (solid shape): 88.73,125.18 88.73,124.24 89.9,123.08 90.54,123.08 91.02,122.59 91.02,121.02 90.38,120.38 87.95,120.38 87.31,121.02 87.31,122.57 87.32,122.58 87.32,123.47 88.1,124.24 88.1,125.16 88.17,125.24 88.68,125.24
GND on BOTTOM (solid shape): 139.04,139.43 141.32,139.43 141.48,139.27 141.48,138.86 141.17,138.55 141.16,138.55 140.52,137.91 138.47,137.91 138.11,138.27 138.11,138.37 135.49,138.37 135.04,138.82 135.04,139.18 135.11,139.26 135.11,139.65 135.62,140.16 138.31,140.16
GND on BOTTOM (solid shape): 36.34,97.22 36.34,90.41 36.46,90.29 37.53,90.29 37.66,90.16 37.66,87.37 37.4,87.11 33.85,87.11 33.47,87.49 33.47,89.32 32.5,90.29 32.5,97.25 32.58,97.32 36.23,97.32
GND on BOTTOM (solid shape): 54.72,121.53 57.82,121.53 58,121.35 58.2,121.35 58.37,121.18 58.37,120.85 58.25,120.74 56.55,120.74 56.55,119.06 56.3,118.81 56.07,118.81 55.94,118.94 55.94,119.19 56.37,119.62 56.37,120.74 54.8,120.74 54.66,120.6 53.41,120.6 53.26,120.75 53.26,121.41 53.56,121.7 54.54,121.7
GND on BOTTOM (solid shape): 169.8,75.9 169.8,74.63 169.33,74.16 169.33,73.55 169.17,73.39 167.52,73.39 167.37,73.24 167.37,72.86 167.17,72.66 166.79,72.66 166.61,72.84 166.61,73.85 166.94,74.18 168.51,74.18 168.72,74.38 168.72,75.96 168.82,76.06 169.63,76.06
GND on BOTTOM (solid shape): 174.74,32.55 174.74,31.74 175.65,30.82 175.65,28.54 174.3,27.19 174.3,28.43 172.86,28.43 172.86,26.37 173.51,26.37 173.23,26.08 171.38,26.08 170.98,26.48 170.98,31.33 170.8,31.51 170.57,31.51 170.42,31.66 170.42,31.94 170.62,32.14 172.53,32.14 172.74,32.36 172.74,32.74 172.96,32.96 174.33,32.96
GND on BOTTOM (solid shape): 186.02,58.69 186.02,58.46 185.68,58.13 185.41,58.13 185.28,58 185.28,56.93 185.23,56.88 185.02,56.88 185,56.91 185,58.08 184.97,58.1 184.8,58.1 184.77,58.08 184.77,56.93 184.49,56.93 184.49,58.03 184.34,58.18 184.11,58.18 183.91,58.38 183.91,58.74 184.03,58.87 185.84,58.87
GND on BOTTOM (solid shape): 117.48,124.58 117.6,124.52 117.72,124.5 117.74,124.5 119.92,122.31 119.92,116.29 119.57,115.94 118.81,115.94 118.55,116.19 118.55,118.23 118.04,118.73 108.9,118.73 108.65,118.99 108.65,121.65 108.9,121.91 112.56,121.91 113.47,122.82 113.47,124.19 113.85,124.58
GND on BOTTOM (solid shape): 146.08,32.38 146.08,31.26 145.45,30.62 145.22,30.62 145.15,30.66 145.13,30.74 145.14,30.79 145.15,30.83 145.15,30.88 145.13,30.96 145.45,31.27 145.45,32.38 145.98,32.38
GND on BOTTOM (solid shape): 174.53,58.51 174.53,58.28 174.28,58.03 174.28,56.76 174.48,56.55 176.72,56.55 177.02,56.86 177.02,57.82 177,57.85 177.02,57.87 177.25,57.87 177.25,56.78 177.3,56.73 177.3,55.79 176.38,54.86 174.8,54.86 173.79,55.88 173.79,56.54 173.98,56.73 173.98,58.51 174.13,58.66 174.38,58.66
GND on BOTTOM (solid shape): 62.3,112.81 62.3,111.35 62.24,111.29 62.16,111.29 62.14,111.26 62.14,110.37 62.23,110.28 62.23,109.91 62.11,109.8 61.89,109.8 61.79,109.89 61.79,110.27 61.88,110.35 61.88,111.26 61.85,111.28 61.29,111.28 61.19,111.38 61.19,112.81 61.27,112.89 62.22,112.89
GND on BOTTOM (solid shape): 140.08,32.38 140.08,31.68 139.31,30.9 139.1,30.9 139.08,30.94 139.05,30.97 139.03,31.03 139.05,31.09 139.13,31.25 139.14,31.43 139.13,31.45 139.45,31.77 139.45,32.38 139.99,32.38
GND on BOTTOM (solid shape): 174.56,102.1 174.56,101.23 174.71,101.08 175.14,101.08 175.19,101.03 175.19,100.57 173.57,100.57 173.29,100.85 173.29,101.54 173.24,101.59 172.63,101.59 172.58,101.64 172.58,101.79 172.63,101.84 173.21,101.84 173.26,101.89 173.26,102.05 173.21,102.1 172.6,102.1 172.58,102.12 172.58,102.32 172.6,102.35 174.31,102.35
GND on BOTTOM (solid shape): 176.08,128.64 176.08,126.23 175.7,125.85 164.76,125.85 164.58,125.67 164.58,122.8 166.13,121.25 168.69,121.25 168.84,121.1 168.84,119.29 168.47,118.91 165.8,118.91 164.58,120.13 163.86,120.86 163.86,121.45 163.78,121.53 163.18,121.53 163,121.7 163,128.64 163.26,128.89 175.83,128.89
GND on BOTTOM (solid shape): 25.82,102.12 25.82,99.1 25.79,99.07 24.06,99.07 22.94,97.95 22.94,97.01 23.08,96.88 23.84,96.88 23.89,96.83 23.89,95.19 23.84,95.14 22.25,95.14 22.21,95.18 22.21,96.82 22.28,96.89 22.55,96.89 22.66,97 22.66,98.61 22.79,98.75 22.79,102.07 22.97,102.25 25.69,102.25
GND on BOTTOM (solid shape): 138.26,41.38 138.33,41.41 138.4,41.38 139.83,39.95 139.83,39.48 139.2,39.48 139.2,40.08 138.36,40.92 138.36,40.95 138.34,41.13 138.24,41.29 138.23,41.33 138.24,41.36
GND on BOTTOM (solid shape): 159.51,45.36 159.51,45.18 159.48,45.04 159.51,44.9 159.51,44.58 159.68,44.41 159.68,43.9 159.44,43.65 155.9,43.65 155.55,44 155.55,45.43 155.59,45.47 156.42,45.47 156.46,45.51 156.46,45.68 156.43,45.71 155.62,45.71 155.56,45.77 155.56,45.97 155.59,46.01 158.86,46.01
GND on BOTTOM (solid shape): 54.16,100.7 53.66,100.2 53.66,99.81 53.66,99.81 53.38,99.53 53.38,96.41 53.34,96.37 52.09,96.37 52.08,96.38 52.08,97.92 52.08,97.92 51.45,98.56 51.45,99.38 51.75,99.68 52.01,99.8 52.13,100.06 52.39,100.32 52.39,100.82 54.16,100.82
GND on BOTTOM (solid shape): 122.62,131.83 122.62,127.65 122.49,127.38 122.6,127.1 122.37,126.86 122.11,126.86 121.22,125.97 108.4,125.97 108.27,126.1 108.27,127.88 108.4,128.01 118.68,128.01 118.86,128.18 118.86,129.07 119.95,130.17 119.95,131.84 120.32,132.21 122.24,132.21
GND on BOTTOM (solid shape): 87.83,32.38 87.92,32.31 87.9,32.2 87.76,32.07 87.76,31.08 88.18,30.66 88.37,30.66 88.42,30.6 88.48,30.54 88.51,30.46 88.47,30.39 88.42,30.33 88.37,30.27 88.15,30.27 87.45,30.97 87.45,32.38
GND on BOTTOM (solid shape): 48.69,117.78 48.69,116.88 47.7,115.89 46.79,115.89 46.66,116.02 46.66,116.11 46.67,116.19 46.66,116.28 46.43,116.55 46.07,116.51 46.06,116.5 46.04,116.5 45.6,116.07 44.41,116.07 44.05,116.42 44.05,117.64 44.28,117.87 48.6,117.87
GND on BOTTOM (solid shape): 154.7,133.59 154.7,132.92 154.69,132.91 154.67,132.78 154.69,132.65 154.7,132.64 154.7,131.99 152.82,130.11 151.14,130.11 150.97,130.29 150.97,130.46 151.17,130.81 150.94,131.15 150.91,131.16 150.91,133.8 151.19,134.07 154.21,134.07
GND on BOTTOM (solid shape): 87.21,127.98 87.21,126.61 86.75,126.15 86.75,124.4 86.52,124.17 81.44,124.17 81.24,124.37 81.24,125.01 81.44,125.21 82.76,125.21 82.94,125.39 82.94,125.82 83.02,125.9 83.58,125.9 84.24,125.24 85.2,125.24 85.46,125.49 85.46,126.1 85.96,126.61 85.96,126.89 86.4,126.89 86.57,127.06 86.57,127.9 86.61,128.01 86.6,128.14 86.68,128.21 86.98,128.21
GND on BOTTOM (solid shape): 85.2,148.45 84.74,147.99 84.74,147.18 84.52,146.98 84.46,146.7 83.83,146.7 83.83,148.59 83.89,148.67 83.99,148.67 84.45,148.55 84.88,148.76 85.2,148.76
GND on BOTTOM (solid shape): 145.32,134.71 145.32,134.47 145.28,134.46 144.97,134.09 145.28,133.71 145.32,133.7 145.32,131.43 144.54,130.65 144.23,130.65 144.08,130.8 144.08,133.21 144.07,133.23 144.05,133.34 144.07,133.44 144.08,133.46 144.08,135.01 144.28,135.22 144.82,135.22
GND on BOTTOM (solid shape): 181.42,81.27 181.42,79.36 181.93,78.86 181.93,77.84 181.8,77.71 178.8,77.71 177.2,79.31 177.2,79.87 178.24,79.87 178.29,79.92 178.29,80.07 178.27,80.1 177.2,80.1 177.2,80.38 178.27,80.38 178.32,80.43 178.32,80.56 178.29,80.58 177.23,80.58 177.23,80.86 178.24,80.86 178.29,80.91 178.29,81.06 178.27,81.09 177.2,81.09 177.19,81.1 177.19,81.31 177.27,81.39 178.16,81.39 178.16,81.4 181.29,81.4
GND on BOTTOM (solid shape): 83.58,140.98 83.58,139.67 81.32,137.42 80.48,136.57 80.48,133.67 80.58,133.44 80.43,133.23 80.32,133.19 80.32,132.62 80.43,132.51 80.43,131.79 80.27,131.64 80.05,131.64 79.93,131.76 79.93,137.51 80.42,138 80.66,138 82.41,139.75 82.41,140.93 82.64,141.16 83.4,141.16
GND on BOTTOM (solid shape): 170.62,79.74 170.62,79.36 170.5,79.24 170.04,79.24 169.99,79.19 169.99,79.03 170.04,78.98 170.65,78.98 170.7,78.93 170.7,78.78 170.65,78.73 170.06,78.73 170.01,78.68 170.01,78.52 170.06,78.47 170.67,78.47 170.7,78.45 170.7,78.25 170.67,78.22 169.86,78.22 169.23,77.59 168.84,77.59 168.72,77.71 168.72,78.47 168.59,78.6 167.96,78.6 167.83,78.73 167.83,79.11 167.96,79.24 168.59,79.24 168.72,79.36 168.72,79.74 168.84,79.87 170.5,79.87
GND on BOTTOM (solid shape): 60.83,100.64 60.01,100.64 60.01,100.7 59.75,100.95 57.99,100.95 57.86,101.08 57.86,101.82 60.73,101.82 60.73,105.43 59.13,105.43 59.13,101.82 57.86,101.82 57.86,102.53 32.7,102.53 32.7,100.64 29.73,100.64 29.73,101.82 31.43,101.82 31.43,104.72 58.04,104.72 58.04,106.43 55.32,106.43 55.32,104.72 46.64,104.72 46.64,106.43 43.92,106.43 43.92,104.72 35.24,104.72 35.24,106.43 32.52,106.43 32.52,104.72 31.43,104.72 31.43,105.43 29.83,105.43 29.83,101.82 29.73,101.82 29.73,108.3 60.83,108.3
GND on BOTTOM (solid shape): 133.06,125.22 138.69,125.22 138.9,125.01 138.9,123.38 138.36,122.85 134.05,122.85 133.8,123.67 133.16,123.09 132.99,122.92 131.62,122.92 131.51,123.03 131.51,124.97 131.76,125.22 133.06,125.22
GND on BOTTOM (solid shape): 193.6,61.81 193.69,61.76 193.7,61.67 193.73,61.29 194.07,61.13 194.12,61.08 195.16,61.08 195.46,60.77 195.46,57.06 195.27,56.87 193.11,56.87 193,56.99 193,59.42 192.82,59.6 192.82,61.14 192.86,61.15 193.08,61.37 193.06,61.69 193.04,61.72 193.13,61.81
GND on BOTTOM (solid shape): 86.47,130.7 86.47,128.48 86.44,128.4 86.35,128.38 86.26,128.38 86.16,128.36 86.16,128.36 85.77,128.36 85.7,128.38 85.64,128.39 85.58,128.38 85.51,128.36 85.45,128.36 85.3,128.21 85.3,127.95 85.23,127.88 84.77,127.88 84.64,127.75 84.64,127.14 83.3,127.14 83.04,127.39 83.04,128.97 83.09,129.02 83.93,129.02 84.24,129.32 84.97,129.32 85.76,130.11 85.76,130.32 85.89,130.32 86.12,130.54 86.12,130.77 86.17,130.82 86.35,130.82
GND on BOTTOM (solid shape): 134.41,82.72 134.59,82.54 134.84,82.53 134.88,82.49 134.88,81.72 134.78,81.62 134.52,81.62 134.45,81.7 134.45,82.08 134.42,82.11 134.41,82.13 134.15,82.36 133.82,82.23 133.82,82.22 133.72,82.12 133.44,82.12 133.28,82.28 133.28,82.51 133.4,82.63 133.55,82.63 133.86,82.51 134.14,82.72
GND on BOTTOM (solid shape): 152.52,63.28 152.71,63.23 152.9,63.28 152.91,63.28 153.04,63.28 153.22,63.1 153.49,63.06 153.51,63.07 153.78,62.8 153.78,61.21 153.66,61.09 153.21,61.09 153.08,61.22 153.08,61.62 153.1,61.72 153.09,61.82 153.09,62.3 153.02,62.63 152.72,62.78 152.66,62.77 152.58,62.75 152.51,62.75 152.41,62.85 152.41,63.18 152.51,63.28
GND on BOTTOM (solid shape): 125.16,130.54 125.16,126.73 125.03,126.61 123.76,126.61 123.51,126.86 123.51,126.91 123.52,126.96 123.55,127 123.61,126.99 123.67,126.99 123.7,126.99 124.01,127.37 123.7,127.75 123.67,127.75 123.61,127.75 123.55,127.74 123.52,127.78 123.51,127.83 123.51,130.21 123.65,130.42 123.63,130.67 123.76,130.8 124.9,130.8
GND on BOTTOM (solid shape): 110.88,87.08 111.05,87.07 111.08,87.04 111.11,87.01 111.51,86.61 111.98,86.61 112.04,86.67 112.08,86.71 112.12,86.75 112.45,87.08 112.92,87.08 113.41,86.6 113.41,86.35 113.14,86.09 113.02,86.01 112.95,85.89 112.62,85.89 112.44,86.08 112.18,86.07 111.56,86.07 111.34,86.1 111.16,85.98 111.11,85.93 110.88,85.93 110.74,86.07 110.74,86.16 110.76,86.2 110.79,86.24 110.83,86.28 110.83,86.79 110.8,86.82 110.78,86.88 110.78,86.95
GND on BOTTOM (solid shape): 123.43,140.96 123.43,140.63 123.35,140.55 123,140.55 122.99,140.59 122.6,140.91 122.24,140.57 122.24,140.55 122.02,140.34 122.02,139.58 121.83,139.38 121.35,139.38 121.14,139.59 121.14,139.79 121.25,139.89 121.27,139.89 121.37,139.88 121.5,139.89 121.52,139.91 121.64,139.99 121.72,140.11 121.73,140.13 121.75,140.26 121.73,140.39 121.73,140.4 121.73,140.73 121.73,140.74 121.75,140.83 121.75,140.93 121.75,140.95 121.88,141.09 123.3,141.09
GND on BOTTOM (solid shape): 103.38,97.88 103.38,97.6 103.25,97.47 102.94,97.47 102.77,97.3 102.76,97.3 102.67,97.24 102.61,97.15 102.6,97.14 102.41,96.94 97.24,96.94 97.09,97.09 97.09,97.35 97.24,97.5 98.56,97.5 98.65,97.59 99.15,97.59 99.31,97.62 99.44,97.73 99.45,97.75 99.5,97.77 99.52,97.76 99.7,97.74 99.87,97.8 99.89,97.82 100.01,97.82 100.02,97.81 100.18,97.77 100.35,97.81 100.36,97.82 100.69,97.64 101.02,97.82 101.04,97.81 101.17,97.77 101.31,97.79 101.34,97.8 102.07,97.8 102.11,97.79 102.34,97.8 102.51,97.96 103.3,97.96
GND on BOTTOM (solid shape): 81.36,151.02 81.43,150.98 81.46,150.9 81.45,150.83 81.45,150.63 81.46,150.53 81.49,150.43 81.5,150.4 80.65,149.55 80.65,147.04 80.07,147.04 80.07,147.61 79.19,148.5 79.19,148.63 79.25,148.72 79.35,148.71 80.38,148.87 80.06,149.86 80,149.96 80.06,150.05 80.33,150.28 80.44,150.63 80.44,150.83 80.43,150.9 80.46,150.98 80.53,151.02
GND on BOTTOM (solid shape): 86.04,135.14 86.04,133.48 85.95,133.24 86.06,133.01 86.1,132.96 86.09,132.89 86.08,132.87 86.04,132.83 85.96,132.79 85.88,132.83 85.46,132.89 85.33,132.48 85.34,132.47 85.34,132.43 85.01,132.16 85.03,131.74 85.03,131.24 84.67,130.87 84.19,130.87 83.88,131.18 83.09,131.18 83.07,131.2 83.07,131.92 83.27,132.12 83.58,132.12 83.58,132.12 83.77,132.11 83.94,132.2 83.97,132.23 84.06,132.42 84.04,132.63 84.02,132.66 84.15,132.79 84.15,135.51 84.4,135.76 85.42,135.76
GND on BOTTOM (solid shape): 83.65,151.02 83.72,150.98 83.75,150.9 83.74,150.83 83.74,150.63 83.75,150.53 83.78,150.43 83.79,150.4 83.47,150.08 83.47,147.26 83.25,147.04 81.21,147.04 81.02,147.23 81.02,149.4 81.46,149.85 81.69,149.85 81.73,149.81 82.14,148.55 82.35,149.86 82.29,149.96 82.35,150.05 82.62,150.28 82.73,150.63 82.73,150.83 82.72,150.9 82.75,150.98 82.82,151.02
GND on BOTTOM (solid shape): 132.51,83.51 132.52,83.47 132.53,83.41 132.55,83.34 132.59,83.34 132.62,83.3 132.65,83.27 132.68,83.2 132.65,83.12 132.55,82.81 132.75,82.54 132.81,82.46 132.75,82.36 132.67,82.3 132.61,82.22 131.95,82.22 131.64,82.36 131.36,82.15 131.35,82.12 131.04,82.12 131.04,82.21 131.02,82.23 131.02,82.26 130.85,82.43 130.85,82.46 130.94,82.56 130.95,82.56 131.07,82.54 131.18,82.55 131.19,82.56 131.23,82.56 131.32,82.64 131.43,82.76 131.43,82.77 131.46,82.84 131.53,82.87 131.67,82.9 131.78,82.99 131.81,83.01 131.92,83.12 131.94,83.11 132.24,83.18 132.4,83.45 132.4,83.47 132.45,83.52
GND on BOTTOM (solid shape): 161.95,152.77 162.03,152.72 162.04,152.63 161.99,152.47 161.98,152.31 161.98,151.5 161.9,151.5 161.9,150.25 162.06,149.73 162.49,149.38 162.49,149.39 162.51,149.43 162.55,149.44 162.56,149.43 162.9,149.39 163.22,149.47 163.42,149.61 163.57,149.79 163.69,149.83 163.76,149.73 163.76,149.6 163.76,145.78 163.29,145.78 163.29,143.93 163.29,143.92 163.27,143.52 163.38,143.13 163.38,140.25 163.38,138.61 160.77,138.61 160.46,139.22 160.16,138.61 157.63,138.61 156.64,139.6 156.64,139.95 156.56,139.95 156.56,141.22 158.14,141.22 159.71,140.9 160.04,142.47 160.03,142.56 160.11,142.62 160.55,142.85 160.72,143.31 160.72,144.3 160.45,144.84 159.76,144.97 159.72,145.05 159.72,147.43 160.91,147.43 160.91,150.27 159.72,150.27 159.72,152.77
GND on BOTTOM (solid shape): outline of 104 points within 107.37,99.8 112.9,101.91
GND on BOTTOM (solid shape): 113.54,32.01 113.57,32.05 113.62,32.04 113.7,31.97 113.69,31.94 113.71,31.79 113.78,31.65 113.81,31.58 113.69,31.26 113.81,30.94 113.78,30.88 113.69,30.61 113.8,30.36 113.83,30.28 113.8,30.21 114.07,29.55 114.29,30.23 114.27,30.27 114.29,30.31 114.33,30.35 114.67,30.35 115.28,30.95 115.28,31.05 115.31,31.1 115.36,31.09 115.7,30.75 116.14,30.75 116.14,30.7 116.17,30.59 116.23,30.5 116.26,30.43 116.23,30.36 116.16,29.99 116.44,29.74 116.51,29.7 116.52,29.63 116.52,29.54 116.23,29.54 115.48,28.8 115.48,28.4 115.49,28.22 115.42,28.13 115.31,28.16 114.86,28.26 114.64,27.86 114.64,27.84 114.05,27.25 113.95,27.22 113.88,27.29 113.85,27.37 113.8,27.44 113.78,27.5 113.8,27.57 113.63,28.19 113.14,27.77 113.14,27.75 112.26,26.87 112.22,26.89 112.05,26.95 111.87,26.92 111.77,26.93 111.73,27.02 111.73,27.08 110.95,27.85 110.96,27.88 110.89,28.14 110.68,28.3 110.6,28.37 110.63,28.47 111.35,29.19 112.55,29.19 113.24,29.4 112.55,29.61 111.85,29.61 111.76,29.68 111.79,29.79 111.8,29.81 111.81,29.81 113.54,31.53
GND on BOTTOM (solid shape): 144.85,150.27 143.66,150.27 143.66,147.43 144.85,147.43 144.85,145.05 144.81,144.97 144.12,144.84 143.85,144.3 143.85,143.31 144.02,142.85 144.46,142.62 144.54,142.57 144.53,142.47 144.86,140.9 146.43,141.22 148.21,141.22 148.31,141.15 148.28,141.04 148.02,140.6 148.1,140.1 148.09,140 148.01,139.95 146.95,139.95 145.06,139.48 143.45,140.57 142.38,140.57 139.57,139.97 137.2,141.6 136.66,143.14 136.84,144.77 136.84,145.15 136.59,145.4 131.89,145.4 131.38,145.91 131.38,147.3 131.25,147.42 129.23,147.42 126.44,147.32 125.43,149.91 125.47,149.91 125.47,151.19 127.12,151.19 127.12,150.27 126.96,148.52 128.7,148.69 133.45,148.69 133.53,148.65 133.55,148.56 133.53,148.48 133.52,148.39 133.52,146.56 134.18,145.9 134.85,146.56 134.85,148.39 134.84,148.48 134.82,148.56 134.84,148.65 134.92,148.69 134.96,148.69 136.05,149.49 135.59,150.77 135.59,152.77 144.85,152.77
GND on BOTTOM (solid shape): outline of 175 points within 108.82,80.84 120.32,83.3
GND on BOTTOM (solid shape): outline of 221 points within 121.05,80.25 130.18,86.12
GND on BOTTOM (solid shape): outline of 629 points within 130.68,83.98 137.76,88.18
GND on BOTTOM (solid shape): outline of 321 points within 113.38,83.55 124.37,87.59
GND on BOTTOM (solid shape): outline of 874 points within 85.1,140.96 113.06,152.77
GND on BOTTOM (solid shape): outline of 905 points within 42.38,129.15 83.65,153.1
GND on BOTTOM (solid shape): outline of 1101 points within 124.9,87.87 130.74,96.64
GND on BOTTOM (solid shape): outline of 1253 points within 98.07,80.94 108,90.34
GND on BOTTOM (solid shape): outline of 4225 points within 0.64,0.64 277.09,153.1
GND on BOTTOM (solid shape): outline of 8491 points within 78.54,23.58 150.18,61.84
GND on GND1 (solid shape): outline of 2877 points within 0.64,0.64 277.09,152.77
GND on IN1 (solid shape): 266.74,39.03 261.88,39.03 261.88,44.23 266.74,44.23
GND on IN1 (solid shape): 205.54,33.04 190.93,33.04 190.83,33.14 190.83,43.9 205.54,43.9
GND on IN1 (solid shape): 195.76,27.82 195.76,27.1 195.19,26.53 189.58,26.53 189.42,26.69 189.42,27.75 189.75,28.08 195.5,28.08
GND on IN1 (solid shape): 81.21,137.41 81.21,136.92 81.37,136.77 81.9,136.77 82.04,136.91 82.04,137.29 82.08,137.33 82.54,137.33 82.8,137.06 82.8,135.67 80.14,133.01 75.78,133.01 75.78,136.86 76.64,137.73 80.89,137.73
GND on IN1 (solid shape): 225.93,55.53 225.93,50.9 225.85,50.72 225.67,50.65 223.47,50.65 223.25,50.86 223.25,55.08 223.96,55.79 225.66,55.79
GND on IN1 (solid shape): 147.23,125.28 147.41,125.21 147.48,125.02 147.48,120.82 147.41,120.64 147.23,120.57 143.73,120.57 143.61,120.59 143.52,120.67 143.17,121.03 143.17,122.31 143.7,122.85 143.7,124.57 143.72,124.6 143.72,125.26 143.75,125.28
GND on IN1 (solid shape): 72.78,102.02 72.78,99.51 72.78,91.43 72.48,91.13 70.38,91.13 70.33,91.14 70.29,91.17 70.36,91.72 69.82,91.77 69.75,91.75 69.68,91.78 69.35,91.89 69.06,91.69 69,91.63 68.96,91.56 68.95,91.53 64.21,91.53 64.01,91.73 64.01,91.76 64.02,91.84 64.01,91.94 64.01,101.91 64.96,102.86 71.94,102.86
GND on IN1 (solid shape): outline of 81 points within 123.27,115.16 129.08,125.51
GND on IN1 (solid shape): outline of 83 points within 108.27,118.89 119.52,127.99
