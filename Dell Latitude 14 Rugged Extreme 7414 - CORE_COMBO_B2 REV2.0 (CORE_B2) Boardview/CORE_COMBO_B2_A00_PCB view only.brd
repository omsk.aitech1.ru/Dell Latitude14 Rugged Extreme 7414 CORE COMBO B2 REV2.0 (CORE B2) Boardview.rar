# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_N1_C: length 5.5
  TOP w0.102: C158.1 88.61,137.44 88.61,137.11 88.02,136.52 88.02,134.88 88.24,134.66 88.24,133.4 U6.F2
CPU_DP2_N2: length 54.6
  TOP w0.102: C160.2 90.97,139.13 90.97,139.54 91.58,140.15 92.73,140.15 v6(92.75,140.16) 92.76,140.15 95.73,140.15 98.35,137.52 98.35,130.62 97.57,129.84 97.57,120.46 97.93,120.1 v1(97.93,119.24)
  BOTTOM w0.102: v1(97.93,119.24) 98.39,118.78 106.39,118.78 108.34,116.84 108.34,108.19 109.66,106.87 109.66,104.09 109.54,103.97 UC1.A50
CPU_DP2_N2_C: length 6.9
  TOP w0.102: 89.92,136.89 v6(89.92,136.91) ; 89.92,136.89 90.71,136.89 90.99,137.17 90.99,137.43 C160.1 ; 89.92,136.89 89.44,136.89 89.06,136.51 89.06,135.7 88.73,135.37 88.73,133.96 88.89,133.81 88.89,133.44 U6.E2
CPU_DP2_N3: length 50
  TOP w0.102: 96.42,124.42 v6(96.41,124.42) ; 96.42,124.42 96.42,118.9 97.2,118.12 97.74,118.12 98.13,117.73 98.13,116.92 v1(97.94,116.73) ; 96.42,124.42 96.42,125.9 95.96,126.36 95.96,136.65 95.64,136.97 95.31,136.97 C162.2
  BOTTOM w0.102: v1(97.94,116.73) 98.13,116.92 98.13,117.55 98.68,118.1 106.06,118.1 107.66,116.51 107.66,107.84 108.95,106.55 108.95,102.22 109.28,101.87 109.28,101.65 UC1.D51
CPU_DP2_N3_C: length 6.8
  TOP w0.102: U6.D2 90.19,133.45 90.19,134.09 90.58,134.47 90.58,135.1 91.28,135.8 v6(91.3,135.8) 91.3,135.82 91.53,136.05 91.53,136.05 92.42,136.94 93.71,136.94 C162.1
CPU_DP2_P0: length 62.3
  TOP w0.102: 89.34,141.55 96.29,141.55 99.52,138.32 99.52,127.49 98.99,126.96 98.99,120.78 99.73,120.05 99.73,119.64 v1(99.48,119.39) ; 89.34,141.55 87.72,141.55 87.56,141.39 87.56,141.16 C155.2 ; 89.34,141.55 v6(89.34,141.54)
  BOTTOM w0.076: UC1.D50 109.88,101.38 109.88,101.67 109.97,101.93 109.97,102.18 109.94,102.3 109.94,102.49 109.99,102.62 109.99,103.32 110.13,103.46 110.18,103.46 110.19,103.47
  BOTTOM w0.102: 110.19,103.47 110.37,103.66 110.37,107.18 109.03,108.52 109.03,117.13 106.46,119.7 101.85,119.7 101.39,120.16 99.88,120.16 99.66,119.93 99.66,119.57 v1(99.48,119.39)
CPU_DP2_P0_C: length 6.8
  TOP w0.102: C155.1 87.56,139.45 87.56,139.13 87.34,138.91 87.34,138.3 v6(87.35,138.29) 87.34,138.28 87.34,137.37 87.54,137.17 87.54,136.77 87.54,134.79 87.79,134.53 87.79,134.28 87.79,134.28 87.79,133.7 U6.G1
CPU_DP2_P1: length 58.6
  TOP w0.102: v1(99.57,117.29) 99.86,117.57 99.86,117.86 98.64,119.08 98.64,119.51 98.41,119.74 98.41,120.33 98.16,120.59 98.16,127.5 98.84,128.18 98.84,134.61 ; C157.2 88.76,139.19 88.76,139.5 89.91,140.65 95.95,140.65 98.84,137.76 98.84,134.61 ; 98.84,134.61 v6(98.82,134.61)
  BOTTOM w0.076: 108.11,103.34 108.14,103.32 108.14,103.09 107.98,102.94 107.98,102.58 108.02,102.49 108.02,102.3 107.98,102.18 107.98,101.93 108.07,101.67 108.07,101.18 108.15,101.11 108.5,101.11 108.58,101.03 108.58,100.92 UC1.D52
  BOTTOM w0.102: v1(99.57,117.29) 99.88,116.97 99.88,116.74 100.16,116.47 100.32,116.47 106.41,116.47 106.77,116.12 106.77,107.25 108.11,105.91 108.11,103.34
CPU_DP2_P1_C: length 4.8
  TOP w0.102: C157.1 88.81,137.44 88.81,137.02 88.23,136.44 88.23,134.96 88.44,134.74 88.44,133.7 88.49,133.65 U6.F1
CPU_DP2_P2: length 55.4
  TOP w0.102: 94.71,139.94 95.65,139.94 98.15,137.44 98.15,130.7 97.37,129.92 97.37,120.38 97.72,120.02 97.72,119.67 v1(97.27,119.22) ; 94.71,139.94 91.66,139.94 91.17,139.45 91.17,139.15 C159.2 ; 94.71,139.94 v6(94.71,139.93)
  BOTTOM w0.102: v1(97.27,119.22) 97.65,118.83 97.93,118.83 98.18,118.58 106.31,118.58 108.14,116.75 108.14,108.11 109.46,106.79 109.46,104.18 109.34,104.06 109.34,102.99 109.24,102.89 109.24,102.55 109.54,102.24 UC1.B50
CPU_DP2_P2_C: length 6.2
  TOP w0.102: C159.1 91.19,137.45 91.19,137.08 90.8,136.69 89.52,136.69 89.26,136.43 89.26,135.61 88.94,135.29 88.94,134.05 89.11,133.87 89.11,133.68 U6.E1
CPU_DP2_P3: length 50.2
  TOP w0.102: v1(98.7,116.73) 98.43,116.73 98.33,116.83 98.33,117.82 97.83,118.33 97.29,118.33 96.63,118.99 96.63,122.7 v6(96.64,122.71) 96.63,122.72 96.63,125.99 96.17,126.45 96.17,136.73 95.73,137.17 95.38,137.17 C161.2
  BOTTOM w0.076: UC1.C51 108.98,101.52 108.9,101.44 108.79,101.44 108.56,101.68 108.56,101.78 108.74,101.96
  BOTTOM w0.102: v1(98.7,116.73) 98.41,116.73 98.35,116.8 98.35,116.82 98.33,116.83 98.33,117.46 98.77,117.89 105.98,117.89 107.45,116.42 107.45,107.75 108.74,106.46 108.74,101.96
CPU_DP2_P3_C: length 6.5
  TOP w0.102: C161.1 93.58,137.15 92.88,137.15 v6(92.87,137.16) 92.86,137.15 92.34,137.15 91.44,136.25 91.44,136.25 90.37,135.18 90.37,134.56 89.99,134.17 89.99,133.71 U6.D1
CPU_DPB_AUX: length 17.7
  TOP w0.102: 106.23,104.97 v6(106.23,104.94) ; 106.23,104.97 107.5,104.97 108.16,104.3 108.16,101.66 109.28,100.54 109.28,100.29 109.18,100.19 108.88,100.19 108.72,100.04 108.72,99.84 108.85,99.71 v3(109.13,99.71) ; 106.23,104.97 105.75,104.97 102.45,108.27 102.45,110.33 101.84,110.94 101.84,111.35 RC153.1
  BOTTOM w0.089: v3(109.13,99.71) 109.25,99.59 109.33,99.59 UC1.F50
CPU_DPB_AUX#: length 17.8
  TOP w0.102: 104.82,106.19 105.84,105.17 107.58,105.17 108.37,104.38 108.37,101.74 109.56,100.55 109.56,99.48 v3(109.13,99.05) ; 104.82,106.19 v6(104.85,106.19) ; 104.82,106.19 102.65,108.35 102.65,110.24 102.65,110.41 102.04,111.02 102.04,111.36 RC147.1
  BOTTOM w0.089: v3(109.13,99.05) 109.22,99.05 UC1.G50
CPU_DPC_AUX: length 63.9
  TOP w0.102: C19.2 85.51,141.55 85.51,142.08 85.69,142.25 96.86,142.25 100.21,138.91 100.21,127.14 100.7,126.65 100.7,125.03 101.41,124.32 101.41,120.35 102.7,119.06 102.7,117.06 RC155.1 102.76,116.08 102.76,114.06 103.08,113.74 103.08,112.41 103.29,112.21 103.29,112.12 103.29,112.12 103.29,108.5 104.81,106.97 106.91,106.97 107.22,106.66 ; 107.22,106.66 v6(107.22,106.6) ; 107.22,106.66 108.82,105.06 108.82,102.04 110.53,100.34 110.53,99.59 110.42,99.49 110.24,99.49 v3(110.04,99.68)
  BOTTOM w0.102: UC1.F48 110.5,99.58 110.39,99.68 v3(110.04,99.68)
CPU_DPC_AUX#: length 63.2
  TOP w0.102: 108.71,105.46 v6(108.75,105.46) ; 108.71,105.46 107,107.18 104.9,107.18 103.49,108.58 103.49,112.04 103.49,112.04 103.49,112.29 103.29,112.49 103.29,113.82 102.97,114.14 102.97,116.15 RC149.1 102.91,117.11 102.91,119.14 101.61,120.43 101.61,124.41 100.9,125.12 100.9,126.73 100.41,127.22 100.41,138.99 96.95,142.46 85.6,142.46 85.3,142.16 85.3,141.55 C20.2 ; 108.71,105.46 109.03,105.14 109.03,102.12 v3(110.96,100.19)
  BOTTOM w0.102: UC1.E48 110.7,100.19 v3(110.96,100.19)
CPU_DPC_AUX#_C: length 8.3
  TOP w0.102: 85.89,137.02 v6(85.89,136.99) ; 85.89,137.02 85.33,137.57 85.33,139.83 C20.1 ; 85.89,137.02 86.6,136.3 86.6,134.72 86.93,134.39 86.93,133.44 U6.H2
CPU_DPC_AUX_C: length 7.6
  TOP w0.102: C19.1 85.53,139.88 85.53,138.85 ; 85.53,138.85 85.53,137.66 86.8,136.39 86.8,134.81 87.13,134.48 87.13,133.71 87.16,133.68 U6.H1 ; 85.53,138.85 v6(85.55,138.85)
CPU_SBIOS_TX: length 137
  TOP w0.108: v1(223.84,66.54) 223.84,67.36 224.08,67.6 R9577.2
  IN2 w0.089: v1(220.31,55.56) 218.83,57.04 212.77,57.04 212.65,57.16 208.73,57.16 206.75,55.18 195.06,55.18 194.22,56.02 190.83,56.02 189.43,57.42 188.55,57.42 185.32,60.66 184.16,60.66 179.05,65.77 179.05,82.81 178.63,83.22 178.25,83.22 176.59,84.88 176.59,92.2 172.47,96.32 169.09,96.32 168.03,95.26 162.49,95.26 162.26,95.49 160.19,95.49 159.77,95.91 158.21,95.91 157.73,95.42 155.47,95.42 154.32,96.58 152.59,96.58 151.67,95.67 148.83,95.67 147.19,97.31 143.99,97.31 143.57,96.89 143.57,93.78 142.66,92.88 139.56,92.88 v3(138.24,91.56)
  BOTTOM w0.076: v3(138.24,91.56) 138.21,91.53 137.48,91.53 UC1.AB2
  BOTTOM w0.108: v1(220.31,55.56) 219.87,56 219.87,59.89 222.19,62.21 222.19,63.86 223.84,65.51 v2(223.84,65.76) v1(223.84,66.54)
CPU_XDP_PRDY#: length 76.1
  IN3 w0.089: v1(105.97,105.93) 102.78,105.93 101.9,106.82 98.2,106.82 98.12,106.9 96.68,106.9 95.98,106.19 92.57,106.19 92.24,106.52 85.58,106.52 83.8,108.3 83.13,108.3 82.27,109.16 61.02,109.16 59.73,110.45 v1(59.73,110.73)
  BOTTOM w0.076: UC1.D56 105.94,100.96 106.2,101.22 arc(106.24,101.28) 106.25,101.36 106.25,101.46 arc(106.24,101.54) 106.2,101.6 106.18,101.61 106.18,101.87 106.4,102.08 106.4,104.58 105.97,105 105.97,105.64
  BOTTOM w0.108: JXDP1.5 69.8,121.75 69.25,121.2 69.25,121.03 68.65,120.43 63.56,120.43 61.63,118.5 61.63,118.02 v2(61.28,117.67) 60.8,117.67 58.19,115.06 58.19,113.68 57.88,113.37 57.88,111.89 58.1,111.67 58.3,111.67 58.69,111.28 59.17,111.28 v1(59.73,110.73) ; 105.97,105.64 v1(105.97,105.93)
CPU_XDP_PREQ#: length 76.2
  TOP w0.108: v1(99.74,106.39) v5(99.74,105.58)
  IN3 w0.089: v1(59.09,110.78) 59.09,110.61 60.88,108.82 69.12,108.82 69.86,108.08 83.71,108.08 85.49,106.31 92.15,106.31 92.48,105.98 95.32,105.98 96.15,105.14 97.67,105.14 98.69,106.16 99.51,106.16 v1(99.74,106.39)
  BOTTOM w0.076: 102.73,103.62 102.95,103.62 103.19,103.38 103.19,103.1 103.08,102.99 arc(103.04,102.92) 103.02,102.85 103.02,102.56 103.06,102.47 103.06,102.29 103.02,102.16 103.02,101.95 103.11,101.69 103.11,101.39 103.13,101.36 103.13,101.08 UC1.D61
  BOTTOM w0.108: v1(59.09,110.78) 58.84,110.78 58.18,111.44 58,111.44 57.65,111.79 57.65,113.47 57.96,113.78 57.96,115.15 63.46,120.66 68.3,120.66 69.3,121.66 JXDP1.3 ; RC362.2 98.49,109.08 98.49,107.64 v1(99.74,106.39) 99.74,106.28 101.96,104.06 102.17,104.06 102.6,103.62 102.73,103.62
CPU_XDP_TCLK: length 36.7
  IN4 w0.089: v1(88.12,117.36) 88.56,116.93 89.06,116.93 89.4,117.27 92.08,117.27 92.42,116.93 93.3,116.93 93.46,116.77 95.93,116.77 96.81,115.89 v1(96.81,115.89)
  BOTTOM w0.076: UC1.B61 103.65,102.06 103.78,102.19 103.78,104.55 103.35,104.98 102.59,104.98 101.41,106.16
  BOTTOM w0.108: JXDP1.57 82.8,121.83 83.08,121.55 84.88,121.55 87.46,118.97 87.46,118.02 v1(88.12,117.36) ; 101.41,106.16 100.63,106.94 100.63,107.66 100.62,107.67 100.62,108.47 101.08,108.93 101.08,109.77 RC359.2 100.62,110.88 100.19,111.32 RC402.1 99.73,112.33 99.73,112.51 99.72,112.52 99.72,113.54 v2(98.92,114.34) 98.49,114.77 97.46,114.77 96.81,115.42 v1(96.81,115.89)
CPU_XDP_TDI: length 52.8
  TOP w0.108: v5(101.56,107.79) 101.31,108.04 v1(101.31,108.55)
  IN3 w0.089: v1(101.31,108.55) 100.44,107.68 95.82,107.68 94.93,106.8 94.17,106.8 93.34,107.63 89.02,107.63 86.38,110.26 79.89,110.26 79.23,109.6 63.57,109.6 63.21,109.96 v1(63.21,110.53)
  BOTTOM w0.076: 101.9,106.16 102.74,105.32 103.24,105.32 103.94,104.62 103.94,102.12 103.69,101.87 103.69,101.63 103.71,101.61 arc(103.74,101.57) 103.76,101.53 arc(103.77,101.49) 103.78,101.45 103.78,101.33 UC1.D60
  BOTTOM w0.108: RC363.2 101.54,108.78 v1(101.31,108.55) 101.31,106.95 101.9,106.36 101.9,106.16 ; v1(63.21,110.53) 62.92,110.81 62.92,111.03 UC6.6
CPU_XDP_TDO: length 50.8
  TOP w0.108: v5(98.79,107.46) 98.79,107.73 v1(99.3,108.24)
  IN3 w0.089: v1(64.19,111.83) 64.19,111.63 66,109.82 79.06,109.82 79.81,110.56 86.43,110.56 89.05,107.94 94.53,107.94 96.13,109.54 98.01,109.54 v1(99.3,108.24)
  BOTTOM w0.108: v1(64.19,111.83) 63.79,112.23 63.45,112.23 63.1,112.58 UC6.3 ; RC361.2 99.78,109.01 99.3,108.53 v1(99.3,108.24) 99.3,108.11 99.63,107.79 99.81,107.79 100.14,107.46 100.14,106.67 102.04,104.76 103.31,104.76 103.57,104.5 103.57,102.99 103.46,102.88 UC1.A61
CPU_XDP_TMS: length 57.4
  TOP w0.108: v5(101.53,109.56) 101.94,109.15 v1(101.94,108.55)
  IN3 w0.089: v1(60.78,110.49) 60.78,110.69 63.15,113.07 64.66,113.07 65.24,112.48 66.48,112.48 67.9,111.07 67.95,111.12 78.26,111.12 79.42,112.28 82.87,112.28 82.95,112.2 85.28,112.2 89.2,108.28 94.38,108.28 95.98,109.88 100.61,109.88 v1(101.94,108.55)
  BOTTOM w0.076: 104.11,104.72 104.11,102.05 104.02,101.97 UC1.C60
  BOTTOM w0.108: v1(60.78,110.49) 60.78,110.6 60.9,110.73 UC6.8 ; RC364.2 102.38,108.98 v1(101.94,108.55) 101.94,106.83 103.25,105.53 103.3,105.53 104.11,104.72
CPU_XDP_TRST#: length 62.1
  TOP w0.108: v3(102.75,103.99) v5(101.83,104.92) 100.65,106.1 100.65,106.16 v1(99.58,107.23)
  IN3 w0.089: v3(102.75,103.99) 104.58,103.99 v3(104.84,103.73) ; v1(59.77,112.61) 60.22,112.17 60.22,110.49 61.32,109.38 79.32,109.38 79.6,109.66 86.35,109.66 89.27,106.74 92.33,106.74 92.49,106.58 96.06,106.58 96.71,107.23 v1(99.58,107.23)
  BOTTOM w0.076: v3(102.75,103.99) 102.93,103.99 103.36,103.56 103.36,103.04 103.25,102.92 arc(103.2,102.85) 103.19,102.77 103.19,102.59 103.22,102.5 103.22,102.26 103.19,102.14 103.19,101.98 103.27,101.72 103.27,101.59 UC1.C61
  BOTTOM w0.089: v3(104.84,103.73) 104.28,103.18 104.28,102.53 104.59,102.22 UC1.B59
  BOTTOM w0.108: UC6.11 60.18,112.08 59.77,112.49 v1(59.77,112.61) ; RC360.2 99.3,109.13 98.79,108.62 98.79,108.02 v1(99.58,107.23)
CRT_ID2: length 8.5
  BOTTOM w0.108: D66.3 83.58,144.71 83.87,145 84.54,145 84.92,145.38 C16.1 v2(84.92,146.75) 84.92,147.92 85.38,148.37 85.38,149.44 JCRT1.4
CS_CTR: length 3.4
  TOP w0.076: T7150.1 138.39,86.02 138.86,85.55 v3(138.86,85.33)
  BOTTOM w0.076: v3(138.86,85.33) 138.48,84.95 137.53,84.95 UC1.AP2
CSI2_RCOMP: length 13.9
  TOP w0.381: v3(131.05,100.32) 131.25,100.52 v2(131.25,101.66) 130.44,102.48 130.44,104.14 130.91,104.61 133.69,104.61 134.72,105.64 134.72,106.63 134.91,106.82 134.91,108.37 134.71,108.57 134.71,108.95 RC20.1
  BOTTOM w0.254: UC1.E13 130.94,100.32 v3(131.05,100.32)
CTS1#: length 165.4
  TOP w0.108: v1(257.34,41.21) RP4804.1 ; v1(263.22,28.94) U6202.39
  IN1 w0.089: v1(263.22,28.94) 262.93,28.65 260.62,28.65 259.6,29.68 259.6,30.79 258.27,32.12 258.27,36.16 257.46,36.96 256.33,36.96 256.16,36.79 252.82,36.79 252.75,36.86 249.37,36.86 249.34,36.84 233.29,36.84 231.29,38.84 231.29,39.43 225.91,44.81 190.22,44.81 189.16,43.75 184.52,43.75 178.66,49.62 178.66,52.06 177.6,53.11 177.6,93.48 178.36,94.24 178.67,94.24 v1(179.16,94.73)
  BOTTOM w0.108: v1(179.16,94.73) 179.67,95.24 179.67,95.94 179.28,96.33 178.36,96.33 178.26,96.23 JIOR1.23 ; v1(257.34,41.21) 259.1,39.45 259.1,36.43 260.15,35.38 262.49,35.38 263.22,34.66 v2(263.22,31.29) v1(263.22,28.94)
CTS2: length 11.9
  TOP w0.108: RP4806.2 263.96,23.2 264.33,22.84 265.68,22.84 v1(266.03,22.49) ; U6202.49 268.48,28.88 268.84,28.51 268.84,27.6 v1(268.67,27.42)
  BOTTOM w0.108: v1(266.03,22.49) v2(267,23.47) 267.42,23.89 267.42,26.66 267.8,27.04 268.29,27.04 v1(268.67,27.42)
CTS3: length 232.4
  TOP w0.108: v1(124.65,139.56) 124.65,139.3 124.2,138.85 U6203.18 ; U6202.24 258.89,32.88 v1(258.89,32.88) ; v1(257.68,34.95) 256.96,35.67 256.96,36.69 256.66,36.99 255.43,36.99 255.05,37.37 255.05,37.71 254.6,38.16 RP4804.6
  IN3 w0.089: v1(257.68,34.95) 257.31,35.31 255.26,35.31 255.08,35.49 250.67,35.49 v1(250.52,35.64)
  IN4 w0.089: v1(250.52,35.64) 248.45,37.71 246.18,37.71 245.17,38.72 245.17,40.37 242.89,42.66 242.89,50.64 242.17,51.36 239.42,51.36 239.35,51.42 230,51.42 229.29,52.13 224.22,52.13 223.89,52.46 220.6,52.46 217.11,55.95 213.22,55.95 211.9,54.63 211.9,53.71 211.39,53.2 211.39,52.07 210.43,51.11 203.35,51.11 199.42,55.04 189.34,55.04 186.16,58.22 186.16,59.11 178.41,66.87 178.41,71.66 182.71,75.96 182.71,79.61 184.09,81 184.09,102.27 182.36,104 179.83,104 178.12,105.71 178.12,107.08 176.66,108.55 174.76,108.55 163.18,120.13 162.52,120.13 159.75,122.91 159.75,123.5 152.54,130.7 152.54,131.59 149.6,134.53 147.37,134.53 146.73,135.17 143.78,135.17 142.92,134.32 138.8,134.32 136.2,136.92 134.73,136.92 132.01,139.63 132.01,139.76 130.47,141.31 127.7,141.31 127.04,140.65 127.04,140.48 126.68,140.12 125.2,140.12 v1(124.65,139.56) ; v1(258.89,32.88) 258.51,33.26 258.51,33.97 257.86,34.62 257.86,34.76 257.68,34.94 v1(257.68,34.95)
  BOTTOM w0.108: v2(257.67,33.31) 258.46,33.31 v1(258.89,32.88)
CTS3_T: length 14
  TOP w0.108: U6203.5 128.1,145.94 v2(127.85,146.19) 127.62,146.42 127.01,146.42 124.97,148.46 v1(124.97,148.77)
  IN2 w0.089: JSER1.8 118.92,149.52 122.42,149.52 123.17,148.77 v1(124.97,148.77)
CV2_ON: length 99.5
  TOP w0.108: v1(241.13,43.52) 240.7,43.96 240.7,44.77 240.7,44.78 240.7,45.12 240.7,45.12 240.7,45.23 241.11,45.63 R9583.2 240.63,46.14 239.28,47.49 238.57,47.49 237.68,48.37 236.92,48.37 235.92,49.38 235.23,49.38 234.25,50.36 U38.A9
  IN2 w0.089: v1(240.7,39.61) 240.48,39.38 231.58,39.38 231.13,39.84 228.53,39.84 227.72,39.03 226.76,39.03 226.45,39.33 223.13,39.33 222.22,38.42 205.68,38.42 204.34,39.76 190.29,39.76 189.99,40.07 175.74,40.07 172.7,43.11 167.81,43.11 v1(166.79,44.13)
  BOTTOM w0.108: JSEC1.3 165.69,41.41 165.97,41.69 166.76,41.69 167.57,42.51 v2(167.57,42.84) 167.57,43.35 v1(166.79,44.13) ; v1(240.7,39.61) 241.13,40.04 v1(241.13,43.52)
D_CLKRUN#: length 5.2
  TOP w0.108: U37.A19 266.61,50.83 267.17,51.39 267.17,51.63 267.48,51.94 RP4807.5 268.36,51.94 268.54,51.75 268.54,50.97 v2(267.96,50.38)
D_DLDRQ1#: length 5.6
  TOP w0.108: U37.B24 264.31,52.58 264.31,52.58 v1(264.27,52.58) ; RP4807.1 v1(267.09,53.04)
  IN3 w0.089: v1(267.09,53.04) 266.7,52.64 264.33,52.64 v1(264.27,52.58)
  BOTTOM w0.108: v1(267.09,53.04) 267.71,53.04 v2(267.97,53.29)
D_SERIRQ: length 3.4
  TOP w0.108: RP4807.3 267.32,52.43 v2(267.04,52.16) 266.96,52.08 266.96,51.48 266.6,51.12 266.23,51.12 266.01,51.33 U37.A20
DAT_DDC2_CRT: length 36.4
  TOP w0.089: 83.63,131.86 83.85,131.63 U6.M4
  TOP w0.108: 83.63,131.86 v1(83.05,132.44)
  IN3 w0.089: v1(92.64,145.95) 92.52,146.08 90.52,146.08 88.2,148.4 82.92,148.4 JCRT1.12
  IN4 w0.089: v1(82.48,137.78) 82.76,137.51 82.76,137.18 83.53,136.41 83.53,132.92 v1(83.05,132.44)
  BOTTOM w0.108: v1(92.64,145.95) 92.91,145.69 92.91,143.01 92.51,142.61 88.61,142.61 88.18,142.18 D4.6 88.18,141.04 87.84,140.7 R2747.2 85.71,140.07 84.37,140.07 v2(84.3,140) 82.48,138.18 v1(82.48,137.78)
DAT_KBD: length 10.4
  TOP w0.108: U38.B41 235,61.09 235.14,60.95 235.14,60.52 v1(235.55,60.11) ; v1(237.3,66.13) 237.3,66.61 R355.2
  IN4 w0.089: v1(237.3,66.13) 237.7,65.73 237.7,64.32 237.08,63.7 237.08,62.49 236.84,62.25 236.51,62.25 235.15,60.89 235.15,60.51 v1(235.55,60.11)
  BOTTOM w0.108: v1(237.3,66.13) 237.3,66.38 v2(236.92,66.76)
DAT_MSE: length 7.5
  TOP w0.108: v1(234.73,60.72) 234.5,60.96 U38.B42 ; v1(235.39,65.41) 235.56,65.41 v2(235.95,65.8) 235.95,66.16 R357.2
  IN4 w0.089: v1(234.73,60.72) 235.28,61.27 235.28,65.3 v1(235.39,65.41)
DAT_TP_SIO: length 180.3
  TOP w0.108: v1(152.72,61.1) 152.14,61.1 R441.1 ; U38.B40 235.5,60.78 v1(235.55,60.72)
  IN1 w0.089: v1(167.64,32.78) 167.02,32.16 164.4,32.16 163.93,32.63 163.93,34.75 163.18,35.5 158.91,35.5 151.73,42.67 151.73,49.49 150.73,50.48 150.73,51.02 150.28,51.47 150.28,60.88 150.96,61.56 152.26,61.56 v1(152.72,61.1)
  IN4 w0.089: v1(247.91,34.81) 247.84,34.74 247.84,30.42 240.81,23.39 224.21,23.39 220.77,26.83 204,26.83 202.89,27.95 202.89,30.59 201.64,31.84 179.39,31.84 178.38,32.85 169.3,32.85 168.83,32.38 168.04,32.38 v1(167.64,32.78)
  BOTTOM w0.108: v1(235.55,60.72) 235.31,60.96 235.31,61.58 234.88,62.01 234.88,63.11 236.2,64.42 236.39,64.42 239.2,64.42 239.39,64.23 241.38,64.23 243.77,61.84 243.77,60.83 244.8,59.8 244.8,54.77 245.62,53.95 245.9,53.95 247.22,52.63 247.22,47.1 247.38,46.94 247.38,44.16 247.59,43.94 247.59,42.14 v2(247.94,41.8) 247.94,41.17 248.08,41.03 248.08,38.8 248.22,38.66 248.22,35.12 v1(247.91,34.81)
DCD1#: length 152.2
  TOP w0.108: RP4806.8 264.6,27.04 264.72,27.15 U6202.42 264.72,28.75 v1(265.52,29.55)
  IN1 w0.089: v1(178.55,94.73) 178.53,94.73 177.39,93.59 177.39,53.02 178.44,51.97 178.44,49.53 184.43,43.54 189.25,43.54 190.22,44.5 206.07,44.5 206.77,43.8 223.18,43.8 223.71,43.27 227.15,43.27 228.74,41.68 228.74,38.8 230.15,37.39 232.33,37.39 233.1,36.62 249.43,36.62 249.46,36.65 252.61,36.65 252.94,36.31 253.35,36.31 257.87,31.79 257.87,28.65 258.14,28.38 264.34,28.38 v1(265.52,29.55)
  BOTTOM w0.108: JIOR1.26 v1(178.55,94.73) ; v2(264.69,29.93) 265.07,29.55 v1(265.52,29.55)
DCD2: length 3.1
  TOP w0.108: RP4806.7 265.24,26.92 265.2,26.96 v1(265.2,27.31) 265.72,27.83 U6202.44
  BOTTOM w0.108: v1(265.2,27.31) 265.2,26.39 v2(265.14,26.33)
DCD3: length 227.3
  TOP w0.108: U6202.19 259.24,35.38 256.97,37.65 256.64,37.65 255.97,38.32 RP4804.8 v1(255.97,39.44) ; U6203.15 122.25,138.89 123.05,139.69 v1(123.19,139.69)
  IN3 w0.089: v1(255.97,39.44) 255.57,39.84 250.93,39.84 v1(249.92,38.83)
  IN4 w0.089: v1(123.19,139.69) 123.83,140.33 126.59,140.33 126.83,140.57 126.83,140.74 127.61,141.52 130.56,141.52 132.23,139.85 132.23,139.72 134.69,137.26 136.16,137.26 138.89,134.53 142.83,134.53 143.69,135.39 146.81,135.39 147.46,134.74 149.92,134.74 152.82,131.84 152.82,130.73 159.96,123.59 159.96,123 162.61,120.35 163.26,120.35 174.85,108.76 176.75,108.76 178.34,107.17 178.34,105.8 179.92,104.22 182.45,104.22 184.31,102.36 184.31,80.91 182.92,79.52 182.92,75.87 178.62,71.57 178.62,66.95 186.38,59.2 186.38,58.31 189.43,55.26 199.51,55.26 203.44,51.33 210.34,51.33 211.17,52.16 211.17,53.34 211.64,53.81 211.64,54.68 213.13,56.17 217.2,56.17 220.69,52.67 223.99,52.67 224.32,52.35 229.4,52.35 230.11,51.64 239.47,51.64 239.53,51.58 242.26,51.58 243.1,50.73 243.1,43.05 246.92,39.23 247.46,39.23 247.86,38.83 v1(249.92,38.83)
  BOTTOM w0.108: v2(255.22,38.69) v1(255.97,39.44)
DCD3_T: length 8.1
  TOP w0.108: U6203.8 126.15,145.14 123.84,147.46 123.56,147.46 123.45,147.56 v2(123.45,147.61) 123.45,149.42 124.67,150.63 JSER1.1
DDI3_AUX: length 2.4
  TOP w0.076: v3(110.93,99.63) 111.35,100.05 111.35,100.53 T6204.1
  BOTTOM w0.076: UC1.F46 111.11,99.63 110.93,99.63 v3(110.93,99.63)
DDI3_AUX#: length 5.4
  TOP w0.076: v3(110.93,99.05) 111.52,99.63 111.52,101.26 110.32,102.45 T6203.1
  BOTTOM w0.076: v3(110.93,99.05) 111.05,99.05 UC1.G46
DDR4_DRAMRST#: length 19.7
  TOP w0.108: v1(107.52,27.17) 107.2,26.85 CD34.1 ; v1(107.51,40.5) 107.06,40.05 CD3.1 107.06,38.53 107.03,38.51 RC189.1 v2(107.03,36.74) v1(107.03,35.24)
  IN4 w0.089: v1(107.03,35.24) 106.23,34.44 106.23,30.09 107.52,28.81 v1(107.52,27.17)
  BOTTOM w0.108: JDIMM1.108 108.01,40 v1(107.51,40.5) ; JDIMM2.108 108.02,26.67 v1(107.52,27.17)
DDR4_DRAMRST#_CPU: length 99.1
  TOP w0.108: v2(105.07,37.35) 104.96,37.45 RD3.2 105.81,38.29 RC189.2 v1(106.15,37.07)
  IN4 w0.089: v3(130.15,83.53) 130.62,83.06 130.62,82.83 132.94,80.51 133.79,80.51 139.3,74.99 139.3,73.24 140.26,72.29 140.26,69.52 138.67,67.93 137.91,67.93 137.03,67.05 137.03,65.26 139.71,62.57 139.71,58.54 141.49,56.76 142.84,56.76 145.42,54.17 145.81,54.17 145.82,54.17 145.86,54.17 146.16,53.86 146.16,44.64 144.87,43.35 144.87,40.03 143.46,38.62 107.69,38.62 v1(106.15,37.07)
  BOTTOM w0.076: UC1.AT13 130.29,83.53 v3(130.15,83.53)
DDR_A_ACT#: length 50.3
  IN4 w0.14: v1(104.3,75.4) 104.3,74.61 103.29,73.6 103.29,72.78 101.76,71.25 101.76,49.55 102.68,48.62 102.68,47.82 103.12,47.39 103.12,45.92 107.12,41.92 108.71,41.92 109.03,41.61 v1(109.03,40.37)
  BOTTOM w0.076: v1(104.3,75.4) 104.68,75.4 105.42,76.14 106.67,76.14 106.85,76.32 106.85,79 106.71,79.14 106.48,79.14 106.28,79.35 106.28,79.64 106.37,79.73 106.37,80.12 arc(106.36,80.22) 106.32,80.31 arc(106.3,80.4) 106.32,80.49 arc(106.37,80.63) 106.39,80.77 arc(106.45,80.94) UC1.BA55
  BOTTOM w0.171: JDIMM1.114 109.51,39.89 v1(109.03,40.37)
DDR_A_ALERT#: length 51.8
  IN4 w0.076: 109.47,74.79 109.47,75.04 109.39,75.12 109.39,79.74 108.18,80.94 v3(108.18,82.71)
  IN4 w0.14: 109.47,74.79 109.47,67.14 108.75,66.42 108.75,56.74 113.69,51.79 113.69,46.89 114.16,46.43 114.16,44.08 v1(114.74,43.5)
  BOTTOM w0.076: UC1.AW50 108.86,82.03 v3(108.18,82.71)
  BOTTOM w0.171: JDIMM1.116 110.01,39.94 112.94,42.86 114.11,42.86 v1(114.74,43.5)
DDR_A_BA0: length 50.1
  IN4 w0.076: 110.32,74.79 110.32,75.78 109.89,76.21 109.89,80.53 109.1,81.31 v7(109.1,82.87)
  IN4 w0.14: v1(120.01,40.56) 119.25,40.56 118.11,41.7 118.11,50.93 111.28,57.77 111.28,68.35 110.32,69.31 110.32,74.79
  BOTTOM w0.076: UC1.AU52 109,82.87 v7(109.1,82.87)
  BOTTOM w0.171: JDIMM1.150 120.51,40.06 v1(120.01,40.56)
DDR_A_BA1: length 51.7
  IN4 w0.076: v3(110.04,83.5) 110.17,83.63 110.37,83.63 110.54,83.47 110.54,82.62 110.77,82.39 110.77,80.88 112.03,79.62 112.03,74.82 112,74.79
  IN4 w0.14: v7(119.82,43.47) 119.82,44.06 120.05,44.29 120.05,44.46 119.95,44.57 119.87,44.57 119.82,44.62 119.82,44.79 119.95,44.92 120.15,44.92 120.22,44.99 120.22,45.5 119.79,45.93 119.79,51.63 113.63,57.79 113.63,58.03 113.47,58.18 113.24,58.18 112.96,58.46 112.96,69.05 112,70 112,74.79
  BOTTOM w0.076: UC1.AT48 110.15,83.5 v3(110.04,83.5)
  BOTTOM w0.171: JDIMM1.145 119.26,44.95 119.42,44.79 119.77,44.79 119.9,44.67 119.9,44.34 119.8,44.23 118.81,44.23 118.65,44.08 118.65,43.68 118.86,43.47 v7(119.82,43.47)
DDR_A_BG0: length 51.1
  IN4 w0.14: v1(105.31,75.38) 104.74,74.8 104.74,74.54 103.67,73.47 103.67,72.58 102.18,71.09 102.18,49.72 103.53,48.36 103.53,46.1 107.24,42.39 107.49,42.39 107.71,42.61 107.71,42.84 v1(106.76,43.79)
  BOTTOM w0.076: v1(105.31,75.38) 105.89,75.96 106.79,75.96 107.01,76.18 107.01,79.67 106.82,79.86 106.82,80.23 106.84,80.26 106.86,80.31 106.86,80.49 106.82,80.61 106.82,80.87 106.86,80.97 106.86,81.17 106.78,81.31 106.49,81.61 UC1.AY55
  BOTTOM w0.171: v1(106.76,43.79) 107.96,43.79 109.76,45.59 JDIMM1.115
DDR_A_BG1: length 50.6
  IN4 w0.14: v1(105.32,74.74) 104.05,73.47 104.05,72.61 103.79,72.35 103.79,72.21 102.59,71.01 102.59,49.9 103.95,48.54 103.95,47.65 104.48,47.12 104.48,46.88 104.01,46.41 104.01,46.21 104.25,45.97 104.42,45.97 104.94,46.49 105.12,46.49 105.24,46.37 105.24,46.19 104.72,45.68 104.72,45.5 104.84,45.38 105.02,45.38 105.53,45.89 105.7,45.89 105.82,45.77 105.82,45.59 105.31,45.08 105.31,44.91 105.48,44.75 105.57,44.75 105.77,44.95 106.03,44.95 106.19,44.79 106.19,44.59 106.03,44.44 106.03,44.19 106.17,44.06 106.38,44.06 v1(106.76,44.44)
  BOTTOM w0.076: UC1.AY54 107.05,81.28 107.05,81.03 106.99,80.84 106.99,80.65 107.03,80.48 107.03,80.29 106.99,80.19 106.99,79.93 107.18,79.74 107.18,75.91 106.92,75.65 v6(106.43,75.65) 105.98,75.65 105.88,75.55 105.88,75.3 105.78,75.19
  BOTTOM w0.171: v1(106.76,44.44) 108.01,44.44 109.26,45.69 JDIMM1.113 ; 105.78,75.19 v1(105.32,74.74)
DDR_A_CKE0: length 51.3
  IN4 w0.076: 105.82,74.79 105.82,75.35 106.91,76.43 106.91,77.47 106.74,77.63 v3(106.48,77.63)
  IN4 w0.14: v1(110.04,44.57) 109.62,44.99 109.62,45.54 108.19,46.97 108.19,48.1 107.49,48.8 107.1,48.8 106.84,48.54 106.7,48.54 106.47,48.78 106.47,49.7 106.08,50.09 106.08,50.33 106.28,50.53 106.49,50.53 106.67,50.71 106.67,50.97 106.41,51.22 105.93,51.22 105.46,50.75 105.3,50.75 105.11,50.94 105.11,67.93 105.82,68.65 105.82,74.79
  BOTTOM w0.076: UC1.BA56 105.73,80.39 105.71,80.29 105.67,80.21 105.63,79.97 105.63,79.31 105.76,79.18 105.76,78.86 105.94,78.68 105.94,78.17 v3(106.48,77.63)
  BOTTOM w0.171: JDIMM1.109 108.26,45.45 107.76,44.95 106.65,44.95 106.32,44.62 106.32,43.6 106.58,43.35 108.82,43.35 v1(110.04,44.57)
DDR_A_CKE1: length 50.5
  IN4 w0.14: v3(106.49,78.2) 106.71,78.42 107.02,78.42 107.2,78.25 107.2,76.34 106.24,75.38 106.24,68.47 105.53,67.76 105.53,51.82 105.7,51.65 107.38,51.65 107.65,51.38 107.65,50.14 107.1,49.59 107.1,49.39 107.27,49.22 107.66,49.22 108.61,48.28 108.61,47.24 110.47,45.38 110.47,44.12 v7(112.01,42.58)
  BOTTOM w0.076: v3(106.49,78.2) 106.11,78.58 106.11,78.75 105.93,78.93 105.93,79.24 105.79,79.38 105.79,79.95 UC1.BB56
  BOTTOM w0.171: JDIMM1.110 108.51,40.98 108.75,41.21 110.65,41.21 v7(112.01,42.58)
DDR_A_CKE2: length 4.3
  TOP w0.076: T6208.1 105.88,78.78 v3(106.47,78.78)
  BOTTOM w0.076: UC1.AW56 105.93,81.83 106.22,81.54 106.22,80.93 arc(106.23,80.85) 106.23,80.78 arc(106.21,80.67) 106.17,80.57 arc(106.13,80.4) 106.17,80.24 arc(106.2,80.18) 106.2,80.12 106.2,79.8 106.11,79.71 106.11,79.14 v3(106.47,78.78)
DDR_A_CKE3: length 5.6
  TOP w0.076: v3(106.49,77.08) T6207.1
  BOTTOM w0.076: UC1.AY56 105.93,81.21 105.56,80.85 105.56,80.39 105.53,80.33 105.49,80.25 105.45,80.08 105.45,79.25 105.6,79.11 105.6,77.97 v3(106.49,77.08)
DDR_A_CS#0: length 55.7
  IN4 w0.076: 113.26,74.79 113.26,74.86 112.53,75.59 112.53,79.83 111.31,81.04 111.31,82.43 111.53,82.65 111.53,82.75 111.64,82.87 v3(111.86,82.87)
  IN4 w0.14: v1(121.49,43.92) 121.55,43.86 121.55,43.19 121.42,43.07 121.22,43.07 121.09,43.19 121.09,43.68 120.97,43.8 120.79,43.8 120.67,43.68 120.67,42.75 120.89,42.53 122.2,42.53 122.34,42.67 122.34,43.32 122.18,43.48 122.18,44.03 122.34,44.19 122.34,44.45 122.23,44.57 122.01,44.57 121.91,44.66 121.91,48.27 121.64,48.54 121.29,48.54 121.14,48.7 121.14,52.06 114.93,58.27 114.93,58.8 114.22,59.52 114.22,59.81 114.35,59.94 114.36,59.94 114.83,60.42 114.83,61.44 114.64,61.63 114.39,61.63 114.22,61.81 114.22,69.57 113.26,70.53 113.26,74.79
  BOTTOM w0.076: UC1.AU45 112.19,83.2 v3(111.86,82.87)
  BOTTOM w0.171: v1(121.49,43.92) 120.61,43.92 120.48,44.05 120.48,45 120.26,45.22 JDIMM1.149
DDR_A_CS#1: length 58.2
  IN4 w0.14: v3(112.78,82.87) 113.12,82.87 113.67,82.31 113.67,82.17 113.31,81.81 113.17,81.81 112.36,82.61 112.15,82.61 112.02,82.48 111.76,82.48 111.62,82.33 111.62,82.18 111.72,82.08 112.08,82.08 112.18,81.98 112.18,81.77 112.1,81.7 111.69,81.7 111.59,81.6 111.59,81.44 111.71,81.31 112.88,81.31 112.95,81.24 112.95,81.05 112.85,80.95 112.15,80.95 112.08,80.87 112.08,80.67 112.22,80.53 112.65,80.53 112.79,80.39 112.79,78.75 112.94,78.6 113.17,78.6 113.29,78.47 113.29,78.22 113.19,78.12 112.89,78.12 112.79,78.02 112.79,77.71 112.93,77.57 113.21,77.57 113.35,77.43 113.35,77.09 113.21,76.96 112.95,76.96 112.81,76.82 112.81,76.54 112.95,76.4 113.21,76.4 113.35,76.26 113.35,76.09 113.22,75.96 112.91,75.96 112.85,75.89 112.85,75.65 112.97,75.53 113.5,75.53 113.68,75.35 113.68,70.7 114.63,69.74 114.63,62.23 115.25,61.62 115.25,60.24 114.92,59.91 114.92,59.4 115.35,58.97 115.35,58.44 121.56,52.23 121.56,49.03 121.62,48.96 121.82,48.96 122.33,48.45 122.33,48.1 122.33,47.99 122.48,47.84 122.94,47.84 123.08,47.7 123.08,47.42 122.94,47.28 122.43,47.28 122.33,47.18 122.33,46.68 122.43,46.58 122.94,46.58 123.08,46.44 123.08,46.16 122.94,46.02 122.48,46.02 122.34,45.88 122.34,45.07 v1(122.77,44.64)
  BOTTOM w0.076: UC1.AU43 113.11,83.2 v3(112.78,82.87)
  BOTTOM w0.171: v1(122.77,44.64) 122.44,44.31 122.29,44.31 122.2,44.4 122.2,45.6 122.26,45.66 JDIMM1.157
DDR_A_CS#2: length 3.9
  TOP w0.171: v1(124.01,41.26) 124.27,41.52 T6213.1
  BOTTOM w0.171: v1(124.01,41.26) 123.51,40.76 JDIMM1.162
DDR_A_CS#3: length 3.8
  TOP w0.171: T6212.1 124.34,45.15 v1(124.84,44.65)
  BOTTOM w0.171: v1(124.84,44.65) 124.26,45.23 JDIMM1.165
DDR_A_D0: length 61.9
  IN4 w0.089: v1(82.67,44.1) 83.04,44.1 83.19,44.25 83.19,46.56 83.1,46.64 82.7,46.64 82.61,46.73 82.61,46.91 82.7,47 83.1,47 83.19,47.09 83.19,47.27 83.1,47.36 82.7,47.36 82.61,47.44 82.61,47.62 82.7,47.71 83.1,47.71 83.19,47.8 83.19,48.56 82.55,49.19 82.55,53.75 82.66,53.85 82.81,53.85 82.92,53.96 82.92,54.1 82.81,54.21 82.66,54.21 82.55,54.31 82.55,54.46 82.66,54.56 82.81,54.56 82.92,54.67 82.92,54.81 82.81,54.92 82.66,54.92 82.55,55.02 82.55,62.36 85.68,65.49 87.56,65.49 87.86,65.8 87.86,84.3 88.51,84.95 91.81,88.25 92.32,88.25 93.52,88.25 v3(95.13,86.64)
  BOTTOM w0.076: v3(95.13,86.64) 95.33,86.85 96.95,86.85 97.01,86.91 UC1.AL71
  BOTTOM w0.108: v1(82.67,44.1) 82.44,44.1 81.76,44.78 JDIMM1.3
DDR_A_D1: length 62.4
  IN4 w0.089: v3(95.9,86.01) 95.9,86.38 94.66,87.62 94.58,87.62 93.64,88.56 92.45,88.56 92.45,88.56 91.69,88.56 88.39,85.26 87.56,84.43 87.56,65.93 87.43,65.8 85.56,65.8 82.14,62.38 82.14,53.17 82.05,53.08 81.48,53.08 81.39,52.99 81.39,52.81 81.48,52.73 82.05,52.73 82.14,52.64 82.14,49.7 82.03,49.59 81.39,49.59 81.32,49.52 81.32,49.16 81.42,49.06 81.82,49.06 82.14,48.75 82.14,47.98 82.26,47.85 82.26,45.43 82.31,45.37 v1(82.67,45.37)
  BOTTOM w0.076: UC1.AL68 99.17,86.13 99.06,86.02 98.4,86.02 98.3,85.98 98.1,85.98 98,86.01 97.75,86.01 97.62,85.98 97.44,85.98 97.36,86.01 96.8,86.01 96.58,85.79 96.12,85.79 v3(95.9,86.01)
  BOTTOM w0.108: JDIMM1.7 82.76,45.46 v1(82.67,45.37)
DDR_A_D2: length 63.2
  IN4 w0.089: v1(92.77,85.33) 92.49,85.33 90.3,83.15 90.3,63.11 87.87,60.68 87.87,57.82 87.48,57.43 87.48,57.13 87.56,57.04 87.91,57.04 88,56.95 88,56.77 87.91,56.68 87.56,56.68 87.48,56.59 87.48,56.41 87.56,56.33 87.91,56.33 88,56.24 88,56.06 87.91,55.97 87.56,55.97 87.48,55.88 87.48,55.7 87.56,55.61 87.91,55.61 88,55.53 88,55.35 87.91,55.26 87.6,55.26 87.51,55.17 87.51,53.66 87.77,53.4 87.77,52.44 87.48,52.15 87.48,49.78 86.98,49.29 86.86,49.29 86.65,49.5 86.53,49.5 86.4,49.37 86.4,49.25 86.61,49.04 86.61,48.92 86.17,48.48 86.17,46.81 85.96,46.59 85.96,43.61 86.17,43.4 86.57,43.4 86.65,43.32 86.65,43.14 86.55,43.04 86.27,43.04 86.19,42.96 86.19,42.79 86.29,42.69 86.9,42.69 87.08,42.86 87.08,43.75 86.78,44.06 v1(86.36,44.06)
  BOTTOM w0.076: 93.66,84.49 95.15,84.49 95.77,85.11 96.83,85.11 96.87,85.15 97.86,85.15 98.09,85.38 98.38,85.38 98.4,85.36 98.66,85.36 98.98,85.68 UC1.AN68
  BOTTOM w0.108: v1(92.77,85.33) 92.77,85.08 93.36,84.49 93.66,84.49 ; v1(86.36,44.06) 86.04,44.06 85.26,44.83 JDIMM1.17
DDR_A_D3: length 62.6
  IN4 w0.089: v3(94.68,85.33) 93.79,86.22 92.51,86.22 89.69,83.4 89.69,63.36 87.26,60.93 87.26,58.18 86.7,57.62 86.7,55.89 86.37,55.56 86.37,52.94 85.56,52.13 85.56,51.82 85.67,51.71 86.19,51.71 86.29,51.61 86.29,51.46 86.19,51.36 85.67,51.36 85.56,51.25 85.56,51.1 85.67,51 86.19,51 86.29,50.9 86.29,50.75 86.19,50.64 85.67,50.64 85.56,50.54 85.56,47.19 85.35,46.97 85.35,43.55 85.24,43.45 84.7,43.45 84.59,43.34 84.59,43.19 84.7,43.09 85.24,43.09 85.35,42.99 85.35,42.84 85.24,42.73 84.7,42.73 84.59,42.63 84.59,42.48 84.7,42.38 85.24,42.38 85.35,42.27 85.35,41.78 85.51,41.62 v1(85.51,41.01)
  BOTTOM w0.076: v3(94.68,85.33) 95.05,85.33 95.32,85.6 96.62,85.6 96.86,85.85 97.32,85.85 97.4,85.81 97.65,85.81 97.78,85.85 97.97,85.85 98.16,85.78 98.41,85.78 UC1.AN69
  BOTTOM w0.108: v1(85.51,41.01) 85.01,40.52 JDIMM1.16
DDR_A_D4: length 62.6
  IN4 w0.089: v3(94.52,86.65) 93.21,87.95 91.94,87.95 88.64,84.65 88.64,84.65 88.17,84.17 88.17,65.67 87.68,65.19 85.81,65.19 82.87,62.24 82.87,55.41 83.42,54.85 83.42,51.73 83.02,51.33 83.02,49.16 83.49,48.69 83.49,41.73 v1(84.14,41.09)
  BOTTOM w0.076: UC1.AL70 97.72,86.91 97.54,87.08 97.42,87.14 97.3,87.17 97.02,87.17 96.86,87.01 94.88,87.01 v3(94.52,86.65)
  BOTTOM w0.108: JDIMM1.8 83.01,40.19 83.91,41.09 v1(84.14,41.09)
DDR_A_D5: length 63.6
  IN4 w0.089: v1(84.14,41.75) 83.8,42.08 83.8,49.94 83.98,50.12 83.98,54.88 83.25,55.61 83.25,62.19 85.94,64.89 87.81,64.89 88.47,65.55 88.47,84.05 88.77,84.34 92.07,87.64 93.05,87.64 93.81,86.89 v3(93.81,86.65)
  BOTTOM w0.076: 94.16,87 94.34,87.18 96.79,87.18 96.95,87.34 97.32,87.34 97.47,87.29 97.52,87.27 97.6,87.25 98.17,87.25 UC1.AL69
  BOTTOM w0.108: v1(84.14,41.75) 83.09,41.75 81.72,40.37 81.72,39.82 82.01,39.52 JDIMM1.4 ; 94.16,87 v3(93.81,86.65)
DDR_A_D6: length 61.5
  IN4 w0.089: v1(86.36,45.33) 86.48,45.45 86.48,48.36 87.78,49.66 87.78,51.83 88.1,52.15 88.1,54.78 88.3,54.98 88.3,60.68 90.61,62.98 90.61,83.02 90.8,83.22 90.95,83.22 91.26,82.91 91.41,82.91 91.52,83.01 91.52,83.16 91.2,83.47 91.2,83.62 91.31,83.72 91.45,83.72 91.77,83.41 91.91,83.41 92.02,83.51 92.02,83.66 91.71,83.97 91.71,84.12 91.81,84.22 91.96,84.22 92.27,83.91 92.42,83.91 92.55,84.05 92.55,84.23 92.34,84.44 92.34,84.65 92.49,84.8 93.05,84.8 93.29,84.56 97.48,84.56 97.6,84.67 97.6,84.9 97.53,84.97 93.59,84.97 93.41,85.15 v1(93.41,85.33)
  BOTTOM w0.076: 93.66,85.08 93.79,85.08 94.17,84.7 95.05,84.7 95.63,85.27 96.76,85.27 96.8,85.31 97.6,85.31 UC1.AN70
  BOTTOM w0.108: 93.66,85.08 v1(93.41,85.33) ; JDIMM1.21 86.26,45.42 v1(86.36,45.33)
DDR_A_D7: length 60.4
  IN4 w0.089: v3(94.04,85.33) 93.53,85.84 92.56,85.84 90,83.27 90,63.23 87.56,60.8 87.56,58 87.17,57.61 87.17,55.7 87.07,55.6 86.86,55.6 86.75,55.5 86.75,55.35 86.86,55.25 87.07,55.25 87.17,55.14 87.17,54.99 87.07,54.89 86.86,54.89 86.75,54.79 86.75,54.64 86.86,54.53 87.07,54.53 87.17,54.43 87.17,54.28 87.07,54.18 86.86,54.18 86.75,54.07 86.75,53.93 86.86,53.82 87.07,53.82 87.17,53.72 87.17,53.57 87.07,53.47 86.86,53.47 86.75,53.36 86.75,52.92 87.17,52.5 87.17,52.31 87.07,52.21 86.73,52.21 86.62,52.1 86.62,51.96 86.73,51.85 87.07,51.85 87.17,51.75 87.17,51.6 87.07,51.5 86.73,51.5 86.62,51.39 86.62,51.24 86.73,51.14 87.07,51.14 87.17,51.04 87.17,50.85 87.01,50.69 87.01,50.19 86.9,50.09 86.41,50.09 85.87,49.55 85.87,47.01 85.65,46.79 85.65,41.91 85.91,41.65 85.91,40.52 85.76,40.37 v1(85.51,40.37)
  BOTTOM w0.076: UC1.AN71 96.83,85.58 96.69,85.44 95.51,85.44 94.98,84.91 94.47,84.91 v3(94.04,85.33)
  BOTTOM w0.108: v1(85.51,40.37) 86.01,39.87 JDIMM1.20
DDR_A_D8: length 53.5
  IN4 w0.089: v3(94.17,83.68) 93.32,83.68 91.41,81.77 91.41,62.65 89.1,60.34 89.1,54.92 89.27,54.75 89.27,51.91 88.58,51.22 88.58,49.33 88.2,48.95 88.2,48.77 88.47,48.5 88.47,48.3 88.37,48.2 87.69,48.2 87.59,48.09 87.59,47.94 87.69,47.84 88.37,47.84 88.47,47.74 88.47,47.59 88.37,47.48 87.8,47.48 87.69,47.38 87.69,47.23 87.8,47.13 88.37,47.13 88.47,47.03 88.47,46.88 88.37,46.77 87.8,46.77 87.69,46.67 87.69,46.52 87.8,46.42 88.37,46.42 88.47,46.31 88.47,46.05 88.17,45.75 88.17,44.82 88.04,44.69 v1(87.75,44.69)
  BOTTOM w0.076: UC1.AR70 97.6,84.82 97,84.82 96.96,84.78 96.07,84.78 94.98,83.68
  BOTTOM w0.108: JDIMM1.29 88.26,44.88 88.07,44.69 v1(87.75,44.69) ; 94.98,83.68 v3(94.17,83.68)
DDR_A_D9: length 54.4
  IN4 w0.089: v1(87.75,44.06) 87.34,44.48 87.34,44.5 87.25,44.59 87.07,44.59 86.98,44.68 86.98,44.86 87.07,44.95 87.25,44.95 87.34,45.04 87.34,45.21 87.25,45.3 87.07,45.3 86.98,45.39 86.98,45.57 87.07,45.66 87.25,45.66 87.34,45.75 87.34,45.93 87.25,46.01 87.07,46.01 86.98,46.1 86.98,46.28 87.07,46.37 87.25,46.37 87.34,46.46 87.34,46.72 87.23,46.83 87.15,46.83 87.05,46.93 87.05,47.08 87.15,47.18 87.28,47.18 87.39,47.29 87.39,47.43 87.28,47.54 87.15,47.54 87.05,47.64 87.05,48.23 88.28,49.45 88.28,51.35 88.96,52.03 88.96,54.62 88.8,54.79 88.8,60.47 91.1,62.77 91.1,81.89 93.27,84.06 v3(94.68,84.06)
  BOTTOM w0.076: v3(94.68,84.06) 94.93,84.31 95.31,84.31 95.94,84.94 96.89,84.94 96.94,84.98 97.86,84.98 98.09,84.75 98.37,84.75 arc(98.4,84.75) 98.42,84.77 98.65,84.77 98.97,84.45 UC1.AR68
  BOTTOM w0.108: v1(87.75,44.06) 87.56,44.06 87.26,44.36 JDIMM1.25
DDR_A_D10: length 51.5
  IN4 w0.089: v3(95.12,81.78) 93.54,80.19 93.54,61.76 92.58,60.8 92.58,58.23 91.65,57.3 91.65,51.22 91.39,50.97 91.39,47.95 90.61,47.17 90.61,42.54 91.28,41.87 92.59,41.87 92.74,41.73 92.74,40.87 92.64,40.78 92.24,40.78 v1(92.01,41.01)
  BOTTOM w0.076: v3(95.12,81.78) 95.12,81.97 95.47,82.32 96.15,82.32 96.95,83.12 97.11,83.12 UC1.AU71
  BOTTOM w0.108: JDIMM1.38 90.51,39.92 91.6,41.01 v1(92.01,41.01)
DDR_A_D11: length 53.3
  IN4 w0.089: v1(92.01,40.37) 91.55,40.83 91.55,41.16 90.3,42.42 90.3,48.19 91.09,48.98 91.09,51.09 91.34,51.35 91.34,55.73 90.95,56.12 90.95,59.6 93.23,61.89 93.23,80.32 94.55,81.64 v3(94.55,82)
  BOTTOM w0.076: UC1.AU68 99.17,83.95 arc(99.16,83.98) 99.15,84.02 99.14,84.05 arc(99.1,84.11) 99.04,84.15 99.02,84.16 arc(99.01,84.17) 99,84.17 arc(98.94,84.21) 98.88,84.23 98.77,84.23 arc(98.75,84.21) 98.73,84.2 arc(98.7,84.17) 98.66,84.15 98.66,84.15 arc(98.59,84.11) 98.5,84.09 arc(98.43,84.09) 98.37,84.13 98.35,84.15 98.1,84.15 97.97,84.11 97.74,84.11 97.73,84.12 97.73,84.12 97.73,84.12 97.64,84.15 97.44,84.15 97.35,84.12 96.99,84.12 96.87,84.25 96.3,84.25 96.12,84.06 95.96,83.91 94.91,82.85 94.91,82.64 94.55,82.28 v3(94.55,82)
  BOTTOM w0.108: JDIMM1.42 91.51,39.88 v1(92.01,40.37)
DDR_A_D12: length 51.9
  IN4 w0.089: v3(93.79,83.17) 93.79,83.02 92.01,81.24 92.01,62.39 89.73,60.11 89.73,55.19 89.88,55.04 89.88,51.65 89.19,50.97 89.19,48.8 89.08,48.7 89.08,45.8 88.78,45.49 88.78,41.15 88,40.37 v1(87.56,40.37)
  BOTTOM w0.076: 94.3,83.17 94.76,83.17 96.2,84.61 96.97,84.61 97.03,84.55 UC1.AR71
  BOTTOM w0.108: 94.3,83.17 v3(93.79,83.17) ; v1(87.56,40.37) 88.01,39.93 JDIMM1.28
DDR_A_D13: length 53.5
  IN4 w0.089: v1(93.21,83.01) 93.2,83.01 91.71,81.52 91.71,62.52 89.41,60.22 89.41,55.04 89.57,54.87 89.57,51.78 88.89,51.09 88.89,48.93 88.78,48.82 88.78,45.92 88.47,45.62 88.47,41.92 v1(87.56,41.01)
  BOTTOM w0.076: 94.72,82.9 96.23,84.41 96.93,84.41 97.06,84.28 97.32,84.28 97.41,84.32 97.67,84.32 97.76,84.28 97.97,84.28 98.05,84.31 98.15,84.35 98.41,84.35 UC1.AR69
  BOTTOM w0.108: 94.72,82.9 94.56,82.74 v6(94.04,82.74) 93.48,82.74 v1(93.21,83.01) ; v1(87.56,41.01) 87.01,40.46 JDIMM1.24
DDR_A_D14: length 52
  IN4 w0.089: v3(95.69,81.78) 93.84,79.93 93.84,61.64 92.88,60.68 92.88,58.11 91.95,57.18 91.95,51.09 91.7,50.84 91.7,47.83 90.91,47.04 90.91,46.76 91.01,46.66 91.27,46.66 91.37,46.55 91.37,46.41 91.27,46.3 91.01,46.3 90.91,46.2 90.91,42.87 91.35,42.43 92.54,42.43 92.67,42.56 92.67,42.83 92.61,42.89 91.65,42.89 91.31,43.23 v1(91.31,44.06)
  BOTTOM w0.076: UC1.AU70 97.59,82.95 97.01,82.95 96.22,82.15 96.07,82.15 v3(95.69,81.78)
  BOTTOM w0.108: JDIMM1.37 90.26,45.1 v1(91.31,44.06)
DDR_A_D15: length 52.5
  IN4 w0.089: v3(96.37,81.82) 95.89,81.34 95.63,81.34 94.15,79.86 94.15,79.61 94.24,79.53 95.3,79.53 95.39,79.44 95.39,79.26 95.3,79.17 94.24,79.17 94.15,79.08 94.15,78.9 94.24,78.81 95.3,78.81 95.39,78.73 95.39,78.55 95.3,78.46 94.24,78.46 94.15,78.37 94.15,78.19 94.24,78.1 95.3,78.1 95.39,78.01 95.39,77.84 95.3,77.75 94.24,77.75 94.15,77.66 94.15,77.48 94.24,77.39 95.07,77.39 95.18,77.28 95.18,77.15 95.07,77.04 94.24,77.04 94.15,76.95 94.15,61.51 93.19,60.55 93.19,57.98 92.26,57.05 92.26,50.97 92,50.71 92,47.42 91.9,47.31 91.63,47.31 91.53,47.21 91.53,47.06 91.63,46.96 91.9,46.96 92,46.85 92,46.26 91.78,46.04 91.43,46.04 91.31,45.92 v1(91.31,45.33)
  BOTTOM w0.076: UC1.AU69 98.31,83.22 97.93,82.84 97.73,82.84 97.65,82.76 97.06,82.76 96.37,82.07 v3(96.37,81.82)
  BOTTOM w0.108: JDIMM1.41 91.26,45.37 v1(91.31,45.33)
DDR_A_D16: length 46.8
  IN4 w0.089: v3(99.63,77.64) 99.2,77.64 97.45,75.89 96.31,75.89 95.56,75.14 95.56,60.92 94.6,59.96 94.6,54.01 93.67,53.08 93.67,48.38 93.54,48.25 93.54,42.12 v1(94.01,41.64)
  BOTTOM w0.076: v3(99.63,77.64) 100.26,78.27 100.26,78.98 100.7,79.42 100.7,79.79 100.85,79.93 100.85,79.96 UC1.BB65
  BOTTOM w0.108: v1(94.01,41.64) 93.43,41.64 92.72,40.93 92.72,39.79 92.51,39.58 JDIMM1.46
DDR_A_D17: length 48.8
  IN4 w0.089: v3(101.29,78.86) 100.96,79.19 99.32,79.19 99.02,78.88 99.02,78.47 96.97,76.42 95.6,76.42 94.64,75.47 94.64,61.3 93.68,60.34 93.68,57.78 92.75,56.85 92.75,50.76 92.5,50.51 92.5,45.99 92.1,45.59 92.1,44.4 92.44,44.06 v1(92.83,44.06)
  BOTTOM w0.076: UC1.AW65 101.58,82.03 arc(101.68,82.02) 101.75,81.96 101.76,81.95 arc(101.85,81.83) 101.87,81.67 arc(101.87,81.61) 101.86,81.55 arc(101.85,81.4) 101.88,81.27 arc(101.91,81.08) 101.88,80.89 arc(101.85,80.75) 101.87,80.6 101.9,80.52 arc(101.91,80.48) 101.92,80.45 arc(101.92,80.4) 101.91,80.35 101.88,80.24 arc(101.86,80) 101.93,79.78 arc(101.99,79.64) 102.01,79.49 102.01,79.37 101.49,78.86 v3(101.29,78.86)
  BOTTOM w0.108: v1(92.83,44.06) 93.26,44.49 JDIMM1.49
DDR_A_D18: length 49.5
  IN4 w0.076: v3(102.49,78.58) 102.14,78.58 101.69,78.12 101.69,76.85 101.48,76.65 100.98,76.65 99.62,75.29 99.4,75.29 98.96,74.84
  IN4 w0.089: v1(96.01,41.01) 95.79,41.23 95.79,41.54 96.3,42.05 96.3,42.2 96.2,42.3 95.9,42.3 95.79,42.41 95.79,42.76 95.88,42.85 96.39,42.85 96.48,42.94 96.48,43.12 96.39,43.21 95.88,43.21 95.79,43.3 95.79,49.17 96.36,49.74 96.36,52.46 96.12,52.7 96.12,59.33 97.08,60.29 97.08,72.97 98.96,74.84
  BOTTOM w0.076: v3(102.49,78.58) 102.73,78.81 102.73,80.6 arc(102.7,80.74) 102.63,80.86 102.54,80.97 arc(102.49,81.06) 102.48,81.17 arc(102.48,81.21) 102.49,81.25 arc(102.48,81.69) UC1.AW63
  BOTTOM w0.108: JDIMM1.58 95.51,40.51 v1(96.01,41.01)
DDR_A_D19: length 48.3
  IN4 w0.076: v3(101.3,77.08) 100.69,77.08 100.49,76.87 100.49,76.42 99.6,75.53 99.38,75.53 98.69,74.84 98.21,74.84
  IN4 w0.089: 98.21,74.84 96.78,73.41 96.78,60.42 95.82,59.46 95.82,52.57 96.06,52.33 96.06,49.86 95.49,49.29 95.49,43.36 95.4,43.27 94.94,43.27 94.85,43.18 94.85,43 94.94,42.91 95.4,42.91 95.49,42.82 95.49,40.9 v1(96.01,40.37)
  BOTTOM w0.076: v3(101.3,77.08) 101.43,77.08 101.78,77.43 101.78,78.87 102.17,79.26 102.17,79.49 arc(102.15,79.68) 102.07,79.86 arc(102.02,80.02) 102.04,80.19 102.07,80.3 arc(102.09,80.39) 102.08,80.48 arc(102.07,80.53) 102.06,80.57 102.03,80.65 arc(102.01,80.74) 102.03,80.83 arc(102.12,81.11) UC1.AY63
  BOTTOM w0.108: v1(96.01,40.37) 96.51,39.87 JDIMM1.62
DDR_A_D20: length 47.7
  IN4 w0.089: v3(99.63,78.19) 99.45,78.19 97.32,76.07 96.18,76.07 95.25,75.14 95.25,61.05 94.29,60.09 94.29,54.13 93.36,53.2 93.36,48.51 93.23,48.38 93.23,40.95 93.43,40.76 93.76,40.76 v1(94.01,41.01)
  BOTTOM w0.076: v3(99.63,78.19) 99.76,78.19 100.01,78.45 100.01,78.98 100.54,79.51 100.54,79.85 100.69,80.01 100.69,80.08 arc(100.72,80.22) 100.81,80.35 arc(100.85,80.41) 100.86,80.48 arc(100.89,80.62) UC1.BA65
  BOTTOM w0.108: JDIMM1.50 93.51,39.8 93.46,39.85 93.46,40.7 93.76,41.01 v1(94.01,41.01)
DDR_A_D21: length 47.7
  IN4 w0.089: v1(92.83,44.69) 92.61,44.46 92.49,44.46 92.42,44.54 92.42,45.47 92.8,45.86 92.8,48.8 92.89,48.89 92.97,48.89 93.06,48.97 93.06,49.15 92.97,49.24 92.89,49.24 92.8,49.33 92.8,49.51 92.89,49.6 92.97,49.6 93.06,49.69 93.06,49.86 92.97,49.95 92.89,49.95 92.8,50.04 92.8,50.38 93.06,50.64 93.06,53.75 93.15,53.84 93.56,53.84 93.97,54.24 93.97,54.5 93.91,54.55 93.76,54.55 93.41,54.19 93.15,54.19 93.06,54.28 93.06,54.46 93.15,54.55 93.28,54.55 93.37,54.64 93.37,54.81 93.28,54.9 93.15,54.9 93.06,54.99 93.06,55.17 93.15,55.26 93.28,55.26 93.37,55.35 93.37,55.53 93.28,55.62 93.15,55.62 93.06,55.7 93.06,55.88 93.15,55.97 93.28,55.97 93.37,56.06 93.37,56.24 93.28,56.33 93.15,56.33 93.06,56.42 93.06,56.72 93.99,57.65 93.99,60.22 94.95,61.18 94.95,75.32 95.88,76.25 97.15,76.25 99.63,78.73 v3(99.63,78.75)
  BOTTOM w0.076: v3(99.63,78.75) 99.63,79.02 100.37,79.77 100.37,79.92 100.53,80.08 arc(100.55,80.23) 100.62,80.37 arc(100.65,80.45) 100.64,80.54 arc(100.68,81.01) UC1.AY65
  BOTTOM w0.108: JDIMM1.45 92.26,45.26 v1(92.83,44.69)
DDR_A_D22: length 47.9
  IN4 w0.076: 99.39,74.84 99.67,75.12 99.89,75.12 101.25,76.48 101.55,76.48 101.85,76.78 101.85,77.71 102.11,77.97 v3(102.49,77.97)
  IN4 w0.089: 99.39,74.84 97.39,72.84 97.39,60.17 96.43,59.21 96.43,54.59 96.53,54.48 97.24,54.48 97.34,54.38 97.34,54.23 97.24,54.13 96.53,54.13 96.43,54.02 96.43,53.88 96.53,53.77 97.24,53.77 97.34,53.67 97.34,53.52 97.24,53.42 96.53,53.42 96.43,53.31 96.43,52.95 96.51,52.87 96.61,52.87 96.81,53.07 96.95,53.07 97.04,52.99 97.04,52.81 96.67,52.43 96.67,49.61 96.1,49.04 96.1,44.72 v1(96.76,44.06)
  BOTTOM w0.076: v3(102.49,77.97) 102.11,78.35 102.11,78.73 102.56,79.19 102.56,80.47 UC1.BA63
  BOTTOM w0.108: JDIMM1.59 95.76,45.06 v1(96.76,44.06)
DDR_A_D23: length 47
  IN4 w0.076: 99.82,74.84 99.84,74.84 101.32,76.32 101.62,76.32 102.02,76.71 102.02,77.08 102.3,77.36 v3(102.49,77.36)
  IN4 w0.089: v1(96.74,45.43) 96.4,45.77 96.4,48.92 96.97,49.48 96.97,52.31 97.69,53.03 97.69,56.13 97.57,56.26 96.84,56.26 96.73,56.36 96.73,56.51 96.84,56.61 97.57,56.61 97.67,56.72 97.67,56.86 97.57,56.97 96.84,56.97 96.73,57.07 96.73,57.22 96.84,57.32 97.57,57.32 97.67,57.43 97.67,57.58 97.57,57.68 96.84,57.68 96.73,57.78 96.73,57.93 96.84,58.03 97.57,58.03 97.67,58.14 97.67,58.29 97.57,58.39 96.84,58.39 96.73,58.49 96.73,58.64 96.84,58.75 97.57,58.75 97.67,58.85 97.67,59 97.57,59.1 97.12,59.1 97.02,59.21 97.02,59.35 97.15,59.48 97.57,59.48 97.69,59.61 97.69,72.72 99.82,74.84
  BOTTOM w0.076: UC1.BB63 102.3,79.79 102.37,79.72 102.37,79.23 101.95,78.8 101.95,77.9 v3(102.49,77.36)
  BOTTOM w0.108: JDIMM1.63 96.76,45.45 v1(96.74,45.43)
DDR_A_D24: length 46.8
  IN4 w0.089: v3(103.61,77.55) 103.24,77.18 103.24,76.87 102.02,75.65 101.64,75.65 100.39,74.41 100.39,73.75 98.8,72.15 98.8,52.14 98.67,52.01 98.24,52.01 98.11,51.88 98.11,51.7 98.24,51.57 98.67,51.57 98.8,51.44 98.8,51.25 98.67,51.12 98.24,51.12 98.11,50.99 98.11,50.81 98.24,50.68 98.67,50.68 98.8,50.55 98.8,50.43 98.7,50.33 98.23,50.33 98.17,50.27 98.17,50.08 98.26,49.99 98.7,49.99 98.77,49.92 98.77,49.72 97.51,48.46 97.51,47.39 97.64,47.26 98.1,47.26 98.24,47.12 98.24,46.94 98.11,46.81 97.6,46.81 97.51,46.72 97.51,46.51 97.6,46.42 98.33,46.42 98.69,46.06 98.69,45.28 v1(98.23,44.82)
  BOTTOM w0.076: UC1.BA61 103.33,80.51 103.06,80.24 103.06,78.1 v3(103.61,77.55)
  BOTTOM w0.108: v1(98.23,44.82) 98.64,44.82 98.76,44.95 JDIMM1.71
DDR_A_D25: length 48
  IN4 w0.076: 101.84,75.48 102.1,75.48 v3(103.61,77)
  IN4 w0.089: v7(98.23,44.06) 98.23,42.81 98.61,42.43 98.84,42.43 99,42.59 99,47.07 98.37,47.7 98.22,47.7 97.86,48.05 97.86,48.38 99.1,49.62 99.1,72 100.72,73.62 100.72,74.36 101.84,75.48
  BOTTOM w0.076: v3(103.61,77) 102.97,77.64 102.9,77.71 102.9,80.44 arc(102.94,80.7) 103.06,80.93 arc(103.1,80.99) 103.12,81.06 arc(103.14,81.14) 103.12,81.23 arc(103.1,81.36) 103.11,81.49 arc(103.22,81.79) UC1.AW61
  BOTTOM w0.108: JDIMM1.67 97.76,44.53 v7(98.23,44.06)
DDR_A_D26: length 46.3
  IN4 w0.089: v1(101.38,44.74) 101.66,44.47 101.87,44.47 101.97,44.57 101.97,46.09 101.92,46.14 101.74,46.14 101.51,45.91 100.75,45.91 100.63,46.04 100.63,46.27 100.76,46.4 101.42,46.4 101.56,46.54 101.56,46.72 101.43,46.85 100.76,46.85 100.63,46.97 100.63,47.15 100.76,47.28 101.33,47.28 101.47,47.42 101.47,47.6 101.34,47.73 100.76,47.73 100.63,47.86 100.63,48.25 100.87,48.5 100.87,48.71 100.63,48.95 100.63,71.21 102.25,72.83 102.25,73.98 103.44,75.17 103.44,75.59 104.69,76.84 v3(104.69,77)
  BOTTOM w0.076: v3(104.69,77) 105.1,77 105.2,77.1 105.2,77.24 105.1,77.34 105.1,78.9 104.76,79.24 104.76,79.63 104.65,79.74 UC1.BB59
  BOTTOM w0.108: v1(101.38,44.74) 102.16,44.74 102.28,44.87 102.28,45.16 101.76,45.68 JDIMM1.83
DDR_A_D27: length 48.8
  IN4 w0.076: v3(104.6,77.55) 104.43,77.55 104.33,77.45 104.33,76.72 103.19,75.58
  IN4 w0.089: v1(101.38,44.11) 100.9,43.63 100.9,42.43 100.77,42.3 100.37,42.3 100.26,42.41 100.26,44.03 100.34,44.11 100.49,44.11 100.64,44.26 100.64,45.49 100.32,45.81 100.32,71.34 101.94,72.95 101.94,74.11 103.19,75.35 103.19,75.58
  BOTTOM w0.076: v3(104.6,77.55) 104.16,77.55 104.04,77.67 v6(104.04,77.98) 104.04,78.79 103.59,79.25 103.59,79.38 arc(103.61,79.48) 103.64,79.58 103.69,79.7 arc(103.73,79.85) 103.76,80 arc(103.76,80.14) 103.74,80.27 arc(103.72,80.33) 103.72,80.4 arc(103.73,80.49) 103.75,80.59 arc(103.77,80.76) 103.74,80.92 arc(103.7,81.1) 103.74,81.28 arc(103.78,81.45) 103.78,81.62 arc(103.77,81.68) 103.77,81.73 arc(103.82,81.91) 103.97,82.02 104.09,82.03 UC1.AW59
  BOTTOM w0.108: JDIMM1.79 100.76,45.28 100.9,45.14 100.9,44.59 v1(101.38,44.11)
DDR_A_D28: length 45.9
  IN4 w0.089: v1(97.04,40.37) 97.8,41.13 97.8,41.73 97.93,41.85 98.03,41.85 98.16,41.98 98.16,42.17 98.03,42.3 97.88,42.3 97.75,42.43 97.75,45.66 97.47,45.94 97.47,46.11 97.2,46.38 97.2,48.58 97.8,49.18 97.8,52.01 98.49,52.7 98.49,72.38 100.21,74.11 100.21,74.48 101.56,75.83 101.94,75.83 103.06,76.95 103.06,77.6 v3(103.61,78.15)
  BOTTOM w0.076: UC1.BB61 103.33,79.87 103.25,79.79 103.25,78.51 v3(103.61,78.15)
  BOTTOM w0.108: v1(97.04,40.37) 97.09,40.37 97.51,39.95 JDIMM1.66
