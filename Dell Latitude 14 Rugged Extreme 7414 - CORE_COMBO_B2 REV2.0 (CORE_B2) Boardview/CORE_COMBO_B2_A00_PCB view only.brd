# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ME_RESET#: length 3.9
  BOTTOM w0.108: RC227.2 138.69,113.15 RC228.1 138.82,113.7 138.52,114.01 v2(137.91,114.01) 137.88,114.01 137.14,114.75 UC8.2
ME_SUS_PWR_ACK: length 135.5
  TOP w0.076: 132.52,74.79 132.52,74.99 RC82.1 132.52,76.01 132.52,76.53 133.01,77.01 133.01,77.8 133.98,78.76 133.98,79.84 133.05,80.76 131.38,80.76 130.53,81.61 130.53,83.8 v3(130.15,84.17)
  TOP w0.108: v1(139.65,70.31) 138.95,69.61 134.88,69.61 134.76,69.73 132.73,69.73 RC70.1 131.68,70.78 131.68,72.05 132.14,72.5 132.14,73.39 132.52,73.77 132.52,74.79 ; v1(233.74,50.53) 233.75,50.54 U38.A8
  IN2 w0.089: v1(139.65,70.31) 139.93,70.02 144.34,70.02 144.61,70.3 149.34,70.3 150.83,68.8 157.31,68.8 157.4,68.71 157.4,68.71 159.15,66.97 166.18,66.97 166.79,66.35 168.17,66.35 168.93,65.6 170.97,65.6 175.95,60.62 177.56,60.62 182.52,55.66 183.55,55.66 184.85,54.36 188.21,54.36 189.64,52.94 192.96,52.94 193.81,52.09 204.64,52.09 207.17,49.55 217.74,49.55 217.91,49.72 224.42,49.72 226.52,51.82 228.63,51.82 230.26,53.46 230.87,53.46 231.02,53.6 233.15,53.6 233.4,53.36 233.4,50.88 v1(233.74,50.53)
  BOTTOM w0.076: v3(130.15,84.17) 130.29,84.17 UC1.AR13
  BOTTOM w0.108: v2(140.45,70.31) v1(139.65,70.31)
MEC_XTAL1: length 6.8
  TOP w0.108: U38.A61 228.17,54.38 228.11,54.44 227.06,54.44 226.76,54.14 226.76,54.03 C364.1 225.57,54.2 Y4.1 222.9,54.2 v2(222.68,54.42)
MEC_XTAL2: length 5.4
  TOP w0.108: R378.1 227.01,52.38 C365.1 225.57,51.7 Y4.2 223.82,51.7 222.88,52.64 v2(222.56,52.64)
MEC_XTAL2_R: length 2.1
  TOP w0.108: R378.2 227.41,53.18 227.41,53.2 227.49,53.28 v2(227.49,53.91) 228.14,53.91 228.16,53.88 U38.A62
MEM_SMBCLK: length 24.1
  TOP w0.108: v1(145.65,95.95) 145.65,95.77 145.78,95.64 147.66,95.64 147.95,95.93 150.66,95.93 150.94,96.2 v2(150.94,96.86) 151.04,96.97 152,96.97 152.2,97.16 QC1.6
  IN3 w0.089: v1(145.65,95.95) 145.24,95.54 143.55,95.54 v1(142.88,94.88) 141.55,93.55 134.22,93.55 v3(133.49,94.28)
  BOTTOM w0.108: RC28.1 143.04,95.03 v1(142.88,94.88) ; v3(133.49,94.28) 133.49,94.28 133.49,94.93 133.64,95.09 134.11,95.09 UC1.R7
MEM_SMBDATA: length 25
  TOP w0.108: QC1.3 153.5,95.6 153.35,95.75 153.35,96.31 153.04,96.61 151.58,96.61 151.25,96.29 151.25,96.07 150.79,95.62 148.35,95.62 v2(148.12,95.39) 148.06,95.33 145.61,95.33 v1(144.99,95.96)
  IN3 w0.089: v3(134.11,94.28) 134.55,93.84 141.43,93.84 142.27,94.68 v1(142.27,94.88) 142.76,95.37 142.95,95.37 143.42,95.83 144.86,95.83 v1(144.99,95.96)
  BOTTOM w0.108: v1(142.27,94.88) 142.78,95.39 143.04,95.39 RC30.1 ; v3(134.11,94.28) 133.82,94.58 UC1.R8
MIC1_L: length 4.8
  TOP w0.191: 41.39,126.79 41.52,126.65 U17.19
  TOP w0.305: 41.39,126.79 41.39,129.05 v2(41.34,129.1) 41.34,129.74 C9515.2
MIC1_R: length 5.6
  TOP w0.191: 40.55,127.01 41.12,126.45 U17.20
  TOP w0.305: C9516.2 40.37,129.36 40.37,128.91 40.52,128.76 40.52,128.76 40.57,128.71 40.57,127.42 v2(40.55,127.39) 40.55,127.01
MIC1_REF: length 34.5
  TOP w0.221: U17.30 37.2,122.87 36.81,122.48 36.21,122.48 35.6,123.1 35.6,124.57 33.97,126.2 v2(33.92,126.2) 33.84,126.28 33.84,127.73 34.39,128.28 v1(34.4,128.28)
  TOP w0.305: D2700.3 22.64,138.95 v1(23.02,138.57)
  IN4 w0.305: v1(34.4,128.28) 34.76,128.64 34.76,129.99 34.25,130.49 34.25,138.27 32.19,140.32 23.98,140.32 23.02,139.37 v1(23.02,138.57)
MODC_EN: length 75.7
  TOP w0.108: v1(259.09,49.59) 259.28,49.4 U37.B7
  IN2 w0.089: v1(258.29,41.45) 257.6,40.76 253.82,40.76 253.05,41.54 253.05,42.08 252.7,42.43 250.43,42.43 249.7,41.69 241.67,41.69 239.87,39.89 233.24,39.89 232.35,40.78 228.31,40.78 228.03,40.51 223.27,40.51 219.94,43.83 203.2,43.83 v1(200.65,46.39)
  IN4 w0.089: v1(259.09,49.59) 259.09,49.17 258.78,48.86 258.78,46.56 258.43,46.21 258.43,41.59 v1(258.29,41.45)
  BOTTOM w0.108: v1(200.65,46.39) 200.65,45.48 v2(200.59,45.43) 200.21,45.05 199.76,45.05 R2677.1 199.53,44.84 198.94,44.26 U32.3
MPHYP_PWR_EN: length 79.4
  TOP w0.076: 136.24,78.24 136.06,78.24 133.03,81.27 132.36,81.27 131.76,81.87 131.76,82.28 131.46,82.58 131.46,85.59 v3(131.99,86.12)
  TOP w0.102: 140.75,78.24 136.24,78.24
  TOP w0.108: 140.75,78.24 140.99,77.99 142.35,77.99 142.96,77.38 148.37,77.38 149.11,78.12 152.53,78.12 152.99,77.66 154.7,77.66 155.41,76.95 RC169.2 155.69,76.95 156.02,76.62 156.02,76.54 RC407.2 157.42,75.14 166.33,75.14 v1(166.83,75.64) ; v1(190.43,87.24) 190.05,87.62 R9569.1
  IN2 w0.089: v1(173.72,70.83) 172.93,70.83 170.01,73.75 169.95,73.75 168.72,73.75 v1(166.83,75.64)
  BOTTOM w0.076: v3(131.99,86.12) 132.11,86.12 UC1.AM10
  BOTTOM w0.108: v1(173.72,70.83) 174.38,70.83 175.83,72.28 175.83,74.36 178.9,77.43 182.03,77.43 182.15,77.56 182.15,79.08 183.7,80.63 184.26,80.63 v2(189.98,86.35) 190.43,86.81 v1(190.43,87.24)
MSCLK: length 104.3
  TOP w0.108: v1(152.18,77.08) 152.18,77.03 152.64,76.57 JDEG1.6 ; R395.1 234.85,66.39 234.85,64.36 234.66,64.17 v1(234.66,63.5) ; v1(234.73,60.11) 234,60.85 U38.B43
  IN3 w0.089: v1(234.66,63.5) 234.38,63.78 233.42,63.78 233.31,63.67 231.92,63.67 230.81,62.56 226.62,62.56 225.93,61.88 219.88,61.88 217.08,59.07 206.89,59.07 204.88,57.07 191.74,57.07 189.86,58.95 189.86,59.07 187.22,61.7 185.95,61.7 182.64,65.01 181.93,65.01 173.51,73.43 166.9,73.43 165.59,74.74 157.78,74.74 157.37,75.15 154.11,75.15 v1(152.18,77.08)
  IN4 w0.089: v1(234.73,60.11) 234.33,60.51 234.33,63.17 v1(234.66,63.5)
  BOTTOM w0.108: v2(234.66,64.19) v1(234.66,63.5)
MSDATA: length 103.5
  TOP w0.108: v1(152.18,77.71) 152.59,77.3 152.59,77.08 153.14,76.53 JDEG1.7 ; U38.A40 234.25,63.7 R366.2 234.54,64.49 234.54,65.93 v1(234.44,66.03) 234.11,66.36 234,66.36 R398.1
  IN3 w0.089: v1(234.44,66.03) 234.44,65.35 233.06,63.96 231.8,63.96 230.69,62.85 226.5,62.85 225.81,62.17 219.76,62.17 216.96,59.37 206.77,59.37 204.76,57.36 191.86,57.36 190.15,59.07 190.15,59.19 187.34,61.99 186.07,61.99 182.76,65.3 182.05,65.3 173.63,73.72 167.02,73.72 165.71,75.03 157.9,75.03 157.49,75.44 154.25,75.44 152.59,77.1 152.59,77.31 v1(152.18,77.71)
  BOTTOM w0.108: v2(235.14,66.72) v1(234.44,66.03)
MSM#: length 2.4
  TOP w0.108: v3(105.47,84.82) 104.99,84.34 104.99,83.86 T7122.1
  BOTTOM w0.076: v3(105.47,84.82) 105.6,84.82 UC1.AP56
NB_DCIN_GC: length 111.4
  TOP w0.108: U38.A23 239.85,55.88 240.21,56.24 v1(240.43,56.24)
  TOP w0.254: v1(254,35.09) 254,35.8 253.88,35.93 253.68,35.93 253.38,36.23 PR5220.1 ; PQ5209.1 197.26,22.21 v2(196.4,22.21) 196.11,22.51 v1(196.11,22.92)
  IN1 w0.089: v1(252.29,55.82) 251.87,56.24 240.44,56.24 v1(240.43,56.24)
  IN3 w0.254: v1(196.11,22.92) 196.96,22.07 253.82,22.07 254.57,22.82 v1(254.57,24.17)
  IN4 w0.254: v1(254,35.09) 254,32.52 253.17,31.69 253.17,27.5 254.57,26.1 v1(254.57,24.17)
  BOTTOM w0.108: v1(254,35.09) 253.16,35.94 253.16,42.36 252.79,42.73 252.79,54.39 252.78,54.41 252.78,54.66 252.29,55.14 v1(252.29,55.82)
NB_DCIN_GC_R: length 19.1
  TOP w0.108: PQ5210.5 257.36,26.15 257.24,26.28 256.47,26.28 256.22,26.53 256.22,27.17 255.51,27.88 254.38,27.88 254.25,28 254.25,29.52 254.38,29.65 PQ5215.1 256.46,29.65 256.6,29.78 256.6,32.75 255.74,33.61 PQ5216.3 255.74,35.01 255.03,35.73 PR5218.1 PR5220.2 253.73,37.07 252.64,37.07 v2(252.41,36.84)
NB_PSID: length 273.9
  TOP w0.108: v1(243.93,42.79) 243.71,42.57 PL5103.1
  IN2 w0.089: v1(26.9,99.15) 35.36,90.69 51.81,90.69 53.28,92.16 55.5,92.16 56.67,93.33 64.15,93.33 66.91,90.56 66.91,89.96 71.51,85.36 72.06,85.36 73.82,83.6 73.82,81.09 78.34,76.57 88.15,76.57 106.17,58.54 132.65,58.54 136.28,54.91 146.08,54.91 148.42,52.57 148.42,49.82 157.64,40.6 170.97,40.6 173.9,37.67 177.28,37.67 179.35,35.61 202.94,35.61 204.16,34.38 219.3,34.38 221.38,32.31 230.4,32.31 232.01,30.7 233.03,30.7 234.88,32.55 239.91,32.55 241.28,33.92 242.5,33.92 244.25,35.68 v1(246.57,35.68)
  BOTTOM w0.108: v1(246.57,35.68) 246.58,35.68 v2(247.11,36.21) 247.36,36.45 247.36,39.36 v1(243.93,42.79) ; JDCIN1.1 PC5104.1 v1(26.9,99.15)
NB_PSID_TS5A63157: length 5.7
  TOP w0.108: PR5106.2 248.6,42.08 249.97,42.08 PR5105.2 251.2,42.53 v2(251.79,41.95) 251.89,41.85 PU1.3
Net_2110: length 0.3
  BOTTOM w0.203: 131.84,102.71 132.17,102.71
Net_2125: length 0.3
  BOTTOM w0.203: 137.84,101.1 137.53,101.1
Net_2126: length 0.3
  BOTTOM w0.203: 137.84,81.2 137.59,81
Net_2131: length 0.3
  BOTTOM w0.203: 97.22,100.95 96.92,101.02
Net_2133: length 0.3
  BOTTOM w0.203: 98.33,102.71 98.33,103.03
Net_2135: length 0.3
  BOTTOM w0.203: 136.23,102.71 136.23,102.39
Net_2136: length 0.3
  BOTTOM w0.203: 136.08,80.08 135.85,80.29
Net_2139: length 0.3
  BOTTOM w0.203: 137.84,100.44 137.6,100.26
Net_2141: length 0.3
  BOTTOM w0.203: 136.88,102.71 136.88,103.04
Net_2156: length 0.3
  BOTTOM w0.203: 97.22,101.6 96.9,101.6
Net_2201: length 0.3
  BOTTOM w0.203: 120.8,102.71 121.13,102.71
Net_2202: length 0.3
  BOTTOM w0.203: 118.33,102.71 118.66,102.71
Net_2203: length 0.3
  BOTTOM w0.203: 119.45,102.71 119.78,102.71
Net_2206: length 0.3
  BOTTOM w0.203: 115.85,102.71 116.18,102.71
Net_2209: length 0.3
  BOTTOM w0.203: 121.93,102.71 122.24,102.58
Net_2211: length 0.3
  BOTTOM w0.203: 116.98,102.71 117.31,102.71
Net_2212: length 0.3
  BOTTOM w0.203: 122.61,102.39 122.82,102.13
Net_2264: length 0.3
  BOTTOM w0.203: 134.32,102.71 134.53,102.46
NRB_BIT: length 23.7
  TOP w0.076: 141.16,85.84 140.96,85.64 140.96,83.48 140.7,83.22 137.55,83.22 v2(137.25,83.53) 136.94,83.22 134.59,83.22 134.33,83.48 134.33,83.65 v3(133.81,84.17)
  TOP w0.108: R9562.2 151.09,86.86 150.2,87.75 148.14,87.75 147.65,88.23 142.92,88.23 141.49,86.8 141.49,86.17 141.16,85.84
  BOTTOM w0.076: UC1.AR7 133.94,84.17 v3(133.81,84.17)
ODD_DA#: length 129.7
  IN2 w0.089: v1(202.3,46.42) 202.3,46.87 201.94,47.23 197.37,47.23 194.15,44.01 188.77,44.01 188.04,44.74 182.85,44.74 177.65,49.93 175.64,49.93 175.11,50.46 173.17,50.46 170.66,52.97 169.76,52.97 167.11,55.62 167.11,56.57 166.88,56.8 165.63,56.8 165.14,57.29 162.24,57.29 161.92,57.61 161.12,57.61 v1(160.69,57.19)
  IN4 w0.076: v3(131.15,91) 131.68,91.52 135.73,91.52 136.21,91.04 137.86,91.04 138.31,90.59 141.16,90.59
  IN4 w0.089: 141.16,90.59 147.86,90.59 v1(148.02,90.44) 148.02,91.23 148.87,92.08 150.72,92.08 151.21,91.6 151.21,90.04 151.77,89.47 151.77,88.56 153.22,87.11 153.47,87.11 155.59,84.99 156.04,84.99 157.15,83.88 157.15,81.58 156.55,80.99 156.55,79.05 157.37,78.23 157.37,75.45 157.28,75.36 157.28,67.16 156.33,66.21 156.33,60.17 157.07,59.43 157.47,59.43 159.71,57.19 v1(160.69,57.19)
  BOTTOM w0.076: v3(131.15,91) 131.2,91.04 131.2,91.52 UC1.AB12
  BOTTOM w0.108: JODD1.15 199,34.45 199.05,34.4 199.62,34.4 202.3,37.08 v2(202.3,42.76) v1(202.3,46.42) ; v1(148.02,90.44) 148.47,89.98 149.16,89.98 RC137.1
OPC_RCOMP: length 4.8
  TOP w0.254: v3(100.71,98.69) 100.71,98.86 100.38,99.19 98.81,99.19 RC91.1 97.69,98.7 v2(97.34,99.05)
  BOTTOM w0.254: UC1.H65 101.2,98.2 v3(100.71,98.69)
OPCE_RCOMP: length 2.5
  TOP w0.254: RC90.1 99.3,98.84 100.01,98.84 100.26,98.6 100.26,98.46 v7(100.69,98.03)
  BOTTOM w0.305: UC1.H66 100.62,98.1 v7(100.69,98.03)
ORIENTATION_DET#: length 191.9
  TOP w0.108: U37.B16 263.78,49.51 v1(263.89,49.61) ; R9403.2 v1(263.97,46.72)
  IN1 w0.089: v1(177.53,122.54) 177.93,122.94 178.48,122.94 179.33,122.09 181.37,122.09 182.48,120.97 184,120.97 185.35,119.62 185.35,118.99 186.07,118.27 186.07,107.97 185.35,107.25 185.35,81.26 181.42,77.33 181.42,66.26 187.65,60.03 187.65,58.06 190.91,54.8 190.91,51.86 190.07,51.02 190.07,49.85 191.6,48.32 194.28,48.32 194.72,47.87 205.68,47.87 206.31,48.5 217.96,48.5 219.39,49.94 219.39,56.05 220.42,57.08 226.74,57.08 228,55.82 242.13,55.82 242.61,55.34 252.38,55.34 252.74,55.7 252.74,56.12 252.89,56.27 254.63,56.27 256.42,54.47 v1(263.71,54.47)
  IN4 w0.089: v1(263.97,46.72) 263.97,47.01 262.6,48.38 262.6,50.68 262.84,50.92 262.84,53.6 v1(263.71,54.47)
  BOTTOM w0.108: v2(263.97,46.01) v1(263.97,46.72) 263.67,47.02 263.67,49.04 263.89,49.25 v1(263.89,49.61) ; v1(177.53,122.54) 176.74,123.33 176.74,128.95 177.05,129.25 JCSW2.1
ORIENTATION_SW#: length 177.3
  TOP w0.108: U37.B17 264.28,48.61 264.65,48.25 v1(264.65,47.97) 265.05,47.58 265.05,46.84 R9400.1
  IN1 w0.089: v1(178.19,122.54) 178.83,121.91 181.29,121.91 182.41,120.79 183.92,120.79 185.17,119.54 185.17,119.4 185.17,118.92 185.89,118.2 185.89,108.04 185.17,107.32 185.17,81.33 181.25,77.41 181.25,66.19 187.48,59.96 187.48,57.98 190.73,54.73 190.73,51.93 189.89,51.09 189.89,49.77 191.53,48.14 194.17,48.14 194.62,47.7 205.79,47.7 205.83,47.73 227.53,47.73 234.55,40.7 239.64,40.7 240.43,41.5 245.34,41.5 248.12,44.28 248.12,45.02 249.74,46.65 249.74,47.21 251.12,48.58 262.04,48.58 262.65,47.97 v1(264.65,47.97)
  BOTTOM w0.108: JCSW2.3 177.24,126.75 177.02,126.54 177.02,123.71 v1(178.19,122.54) ; v2(264.16,48.46) v1(264.65,47.97)
P_SENSOR_CTRL: length 5
  BOTTOM w0.108: v2(88.1,111.3) 88.16,111.25 R9445.2 88.79,110.38 R9446.2 C9541.2 C9544.1 90.71,111.22 90.75,111.26 90.74,111.27 JPSEN1.3
P_SENSOR_OUT: length 9.5
  BOTTOM w0.108: C9543.1 C9540.2 R9454.2 91.54,110.64 JPSEN1.2 91.54,112.98 91.22,113.3 90.46,113.3 89.47,114.29 89.47,114.72 89.16,115.02 89.16,116.22 89.05,116.34 Q1701.1
P_SENSOR_OUT#: length 135.5
  IN1 w0.076: v3(138.82,79.39) 137.27,80.94 137.27,82.49 136.83,82.93 136.83,88.33 139.09,90.59 140.09,90.59 141.16,91.66
  IN1 w0.089: 141.16,91.66 141.82,92.32 141.82,96.2 143.88,98.26 147.9,98.26 151.15,101.51 153.89,101.51 154.7,102.32 154.7,107.61 155.83,108.74 155.83,112.56 154.37,114.02 v1(147.61,114.02) ; v1(91.91,114.06) 91.91,113.66 92.67,112.9 101.09,112.9 102.17,113.98 102.17,117.11 103.4,118.34 103.4,121.95 v1(103.19,122.16)
  IN2 w0.089: v1(121.04,120.74) 121.47,120.74 122.26,119.95 125.87,119.95 129.96,115.86 136.36,115.86 137.3,114.92 141.84,114.92 142.81,115.89 145.73,115.89 146.75,114.87 146.76,114.87 v1(147.61,114.02)
  IN4 w0.089: v1(121.04,120.74) 120.81,120.51 120.81,119.92 119.27,118.38 108.21,118.38 104.43,122.16 v1(103.19,122.16)
  BOTTOM w0.076: UC1.AY7 134.08,81.2 133.84,80.96 133.84,79.91 134.27,79.48 134.67,79.48 135.37,78.77 137.93,78.77 138.39,79.24 138.67,79.24 v3(138.82,79.39)
  BOTTOM w0.108: v1(91.91,114.06) 90.94,114.06 R9686.2
P_SENSOR_OUT_C: length 23.9
  IN1 w0.089: v1(98.21,115.22) 99.67,115.22 101.46,117.01 101.46,121.73 102.42,122.7 103.39,122.7 104.13,123.43 104.96,123.43 v7(105.22,123.69)
  BOTTOM w0.108: v1(98.21,115.22) 98.36,115.37 R9444.1 97.88,116.32 97.17,116.32 96.2,117.29 Q3607.3 ; JWWAN1.25 105.71,127.58 104.78,126.65 104.78,126.4 104.48,126.1 104.48,124.42 v7(105.22,123.69)
PANEL_BKEN_EC: length 280.5
  TOP w0.108: U37.B38 262.78,57.86 262.75,57.82 262.75,57.4 v1(263.16,56.99)
  IN2 w0.089: v1(48.23,91.86) 48.52,91.58 51.45,91.58 54.75,94.88 58.91,94.88 59.39,94.4 64.59,94.4 67.8,91.19 67.8,90.49 68.96,89.33 69.78,89.33 73.05,86.07 73.76,86.07 74.71,85.11 74.71,81.45 78.56,77.61 88.36,77.61 106.47,59.5 132.98,59.5 135.57,56.91 144.69,56.91 145.49,56.11 145.49,56.11 145.97,55.63 147.02,55.63 149.01,53.63 149.01,52.59 150.25,51.35 150.25,50.33 152.59,47.99 152.59,46.41 157.79,41.21 171.78,41.21 174.69,38.3 177.66,38.3 179.58,36.38 203.26,36.38 204.57,35.07 226.79,35.07 228.83,37.12 241.42,37.12 242.31,38 242.31,38.89 242.57,39.15 248.68,39.15 249.43,38.4 260.06,38.4 260.41,38.74 267.5,38.74 v1(267.78,38.47)
  BOTTOM w0.108: v1(48.23,91.86) 48.42,91.67 D21.2 ; v1(263.16,56.99) 264.1,56.05 264.63,56.05 265.14,55.54 265.14,49.04 265.54,48.64 265.54,47.41 267.68,45.28 267.68,44.09 267.62,44.03 267.62,43.53 269.34,41.81 v2(269.34,39.38) 269.34,38.93 268.88,38.47 v1(267.78,38.47)
PANEL_BKLEN: length 209.9
  IN2 w0.089: v1(163.13,57.9) 162.2,58.83 158.48,58.83 157.6,57.96 145.83,57.96 145.53,58.26 135.99,58.26 132.38,61.87 119.47,61.87 118.84,61.25 106.4,61.25 83.09,84.55 83.09,85.13 80.97,87.25 73.58,87.25 70.29,90.54 69.82,90.54 68.98,91.37 68.98,92.88 65.18,96.68 57.97,96.68 57.68,96.39 54.03,96.39 52.53,94.9 50.01,94.9 49.33,94.22 47.89,94.22 v1(47.56,93.89)
  IN4 w0.076: 137.86,94.98 136.08,94.98 135.91,94.82 131.49,94.82 v3(130.95,94.28)
  IN4 w0.102: v1(163.13,57.9) 162.65,58.38 162.65,58.54 161.43,59.75 160.19,59.75 159.26,60.69 159.26,65.72 158.54,66.44 158.54,74.84 159.3,75.6 159.3,77.6 160.15,78.45 160.15,79.77 159.63,80.29 159.63,80.93 158.94,81.62 158.94,81.77 158.94,84.39 158.46,84.87 158.46,87.48 157.75,88.18 157.75,88.36 154.28,91.83 153.38,91.83 151.62,93.6 151.62,94.72 150.97,95.37 148.32,95.37 147.42,94.47 142.1,94.47 141.97,94.6 141.04,94.6 140.8,94.36 138.95,94.36 138.33,94.98 137.86,94.98
  BOTTOM w0.076: v3(130.95,94.28) 130.95,94.27 131.21,94.53 UC1.R12
  BOTTOM w0.108: v2(163.89,57.47) 163.46,57.9 v1(163.13,57.9) ; v1(47.56,93.89) 47.56,94.1 47.31,94.35 45.83,94.35 45.15,93.66 45.15,93.46 44.97,93.28 R9697.2 42.94,93.28 42.67,93.02 Q4216.2
PANEL_BKLEN_HS#: length 352.1
  TOP w0.108: U37.A62 254.71,50.83 254.23,50.35 254.23,50.21 254.28,50.16 v1(254.28,50.11)
  IN1 w0.089: v1(267.56,34.97) 267.81,34.97 268.66,35.81 268.66,38.75 267.67,39.74 267.67,43.09 267.53,43.24 267.53,44.03 267.93,44.43 267.93,44.8 269.23,46.11 269.23,47.65 268.8,48.08 268.35,48.08 267.13,49.3 265.88,49.3 265.13,48.55 262.7,48.55 262.31,48.94 256.32,48.94 255.15,50.11 v1(254.28,50.11)
  IN2 w0.089: v1(176.74,30.04) 195.93,30.04 200.36,25.6 224.99,25.6 225.74,24.85 228.5,24.85 232.34,28.69 240.62,28.69 241.38,27.94 245.66,27.94 248.12,30.39 252.97,30.39 253.93,29.44 253.93,28.76 254.33,28.37 267.54,28.37 268.2,29.03 268.2,34.33 v1(267.56,34.97)
  IN4 w0.089: v1(81.91,79.95) 81.4,79.44 76.82,79.44 74.36,81.9 74.36,83 63.53,93.83 58.89,93.83 57.14,92.09 52.92,92.09 52.13,91.3 43.88,91.3 40.45,94.73 v1(38.67,94.73) ; v1(78.53,26.1) 80.45,26.1 80.77,25.78 116.74,25.78 117.23,26.27 119.52,26.27 120.19,25.61 147.18,25.61 147.63,26.05 147.63,27.07 148.85,28.3 150.28,28.3 151.44,29.45 155.64,29.45 158.42,26.67 163.96,26.67 164.79,27.51 170.33,27.51 172.78,29.96 174.38,29.96 174.85,30.44 176.34,30.44 v1(176.74,30.04)
  BOTTOM w0.108: Q4216.1 41.14,94.92 40.96,94.73 v1(38.67,94.73) ; v1(78.53,26.1) 78.36,26.27 78.36,33.05 80.01,34.7 80.01,40.99 78.92,42.09 78.92,57.73 80.21,59.02 80.21,77.19 81.91,78.88 v1(81.91,79.95)
PBAT_PRES#: length 307.5
  TOP w0.108: v1(59.09,108.69) 59.09,109.03 v2(59.52,109.46) 60.16,110.1 60.16,111.04 59.78,111.42 59.12,111.42 58.58,111.95 UC12.1 ; U38.A49 227.94,60.38 v1(227.93,60.36) ; PR5246.2 240.96,38.11 v1(240.96,38.72) 240.96,38.77 240.22,39.5 240.22,39.92 239.89,40.25 234.67,40.25 PU5202.1
  IN1 w0.089: v1(165.97,34.13) 165.97,35.19 163.59,37.58 160.85,37.58 152.99,45.44 152.99,49.43 151.35,51.07 151.24,51.07 150.69,51.61 150.69,58.51 152.44,60.26 v1(152.72,60.26) ; v1(240.96,38.72) 241.11,38.72 242.26,39.87 245.47,39.87 246.94,41.33 247.78,41.33 250.52,44.07 251.28,44.07 251.55,44.34 251.55,44.71 v1(252.15,45.31)
  IN2 w0.089: v1(152.72,60.26) 151.78,61.2 149.08,61.2 148.15,60.27 147.21,60.27 146.59,59.65 142.5,59.65 142,59.15 136.36,59.15 132.75,62.76 118.81,62.76 118.19,62.14 106.77,62.14 83.98,84.92 83.98,85.5 81.3,88.18 74.14,88.18 71.22,91.1 71.22,92.2 63.95,99.47 63.95,103.22 59.09,108.07 v1(59.09,108.69) ; v1(227.93,60.36) 228.68,61.12 237.88,61.12 237.91,61.09 237.97,61.09 238.21,60.86 238.21,60.8 240.42,58.59 240.93,58.59 241.2,58.31 242.66,58.31 243.01,58.66 246.21,58.66 v1(246.72,58.15)
  IN3 w0.089: v1(165.97,34.13) 167.23,35.39 192.68,35.39 193.67,34.39 222.93,34.39 229.34,40.8 232.77,40.8 234.03,39.54 240.14,39.54 v1(240.96,38.72)
  IN4 w0.089: v1(252.15,45.31) 251.63,45.83 251.63,52.48 251.68,52.53 251.68,54.01 250.96,54.73 250.91,54.73 247.48,58.15 v1(246.72,58.15)
  BOTTOM w0.108: v1(165.97,34.13) PR5104.1 PR5102.1 166.76,33.47 166.99,33.23 166.99,31.8 166.28,31.09 JHS1.4
PBAT_PRES#_C: length 6.9
  BOTTOM w0.108: PR5104.2 PD5103.1 163.3,34.15 162.19,34.15 161.04,33 JBAT1.7
PBAT_PRES#_D: length 8.6
  TOP w0.108: JBAT_PK2.5 v5(210.43,110.4)
  BOTTOM w0.108: JBAT_PK1.7 JBAT_PK2.5
PBAT_SMBCLK: length 152.6
  TOP w0.108: R339.2 226.4,58.6 v1(226.6,58.4) 227.39,57.61 227.39,57.32 227.73,56.98 228.13,56.98 228.23,56.88 U38.A56
  IN4 w0.089: v1(226.6,58.4) 226.99,58.78 228.15,58.78 229.35,57.58 230.96,57.58 231.71,58.33 231.71,58.4 232.29,58.99 237.93,58.99 239.73,57.19 242.05,57.19 242.14,57.28 246.48,57.28 249.86,53.91 249.86,44.37 250.4,43.83 252.4,43.83 252.75,43.47 252.75,43.03 253.37,42.41 253.37,37.3 252.97,36.9 252.97,34.6 250.09,31.72 250.09,28.59 246.86,25.37 243.35,25.37 240.98,22.99 223.86,22.99 220.42,26.43 203.45,26.43 200.8,29.09 200.8,30.53 199.99,31.34 178.99,31.34 178.39,31.94 173.44,31.94 172.85,31.34 167.17,31.34 165.94,32.57 v1(165.94,32.79)
  BOTTOM w0.108: PR5101.1 165.8,32.66 v1(165.94,32.79)
PBAT_SMBCLK_C: length 7.9
  BOTTOM w0.108: JBAT1.5 160.3,30 161.83,31.53 161.83,32.41 162.15,32.73 163.32,32.73 PD5101.1 PR5101.2
PBAT_SMBCLK_D: length 9.1
  TOP w0.108: JBAT_PK2.7 v5(210.43,106.4)
  BOTTOM w0.108: JBAT_PK1.5 213.13,107.4 JBAT_PK2.7
PBAT_SMBDAT: length 153.6
  TOP w0.108: R345.2 226.12,59.02 v1(226.6,59.02) ; v1(231.09,58.27) 231.09,57.78 230.43,57.13 U38.B59
  IN4 w0.089: v1(165.3,32.79) 167.05,31.05 172.97,31.05 173.51,31.59 178.32,31.59 178.86,31.05 199.74,31.05 200.44,30.35 200.44,28.98 203.28,26.14 220.3,26.14 223.74,22.7 241.1,22.7 243.48,25.08 246.98,25.08 250.38,28.47 250.38,31.6 253.26,34.48 253.26,36.78 253.66,37.18 253.66,42.53 253.05,43.15 253.05,43.59 252.52,44.12 252.16,44.12 250.91,45.37 250.91,49.01 250.15,49.77 250.15,54.03 246.6,57.58 242.02,57.58 241.93,57.48 239.85,57.48 238.05,59.28 232.09,59.28 v1(231.09,58.27) 230.69,57.87 229.48,57.87 228.27,59.07 226.66,59.07 v1(226.6,59.02)
  BOTTOM w0.108: PR5103.1 165.55,33.14 165.55,33.04 v1(165.3,32.79) ; v2(231.09,57.61) v1(231.09,58.27)
PBAT_SMBDAT_C: length 7.5
  BOTTOM w0.108: JBAT1.6 161.36,31.5 161.52,31.66 161.52,32.54 162.02,33.04 163.46,33.04 PD5102.1 PR5103.2
PBAT_SMBDAT_D: length 8.8
  TOP w0.108: JBAT_PK2.6 v5(210.43,108.4)
  BOTTOM w0.108: JBAT_PK1.6 211.7,108.9 212.2,108.4 JBAT_PK2.6
PBATT+_C:
  vias: v2(152.72,25.26) v2(154.75,25.26) v4(151.42,27.93) v4(151.42,27.04) v4(152.18,28.44) v4(152.21,27.55) v4(152.21,26.64) v4(152.97,27.98) v4(152.97,27.09) v4(152.97,26.18)
PC_BEEP: length 2.5
  TOP w0.127: R353.1 48.98,127.37 v2(48.7,127.37) 48.26,127.37 C143.2
PC_SPKR: length 2
  TOP w0.127: R9387.1 48.7,125.59 48.7,125.59 v2(48.68,125.59) 48.68,125.59 C133.2
PCH_ALW_ON: length 101.5
  TOP w0.108: R9580.1 191.5,96.97 191.5,93.46 v2(191.3,93.26) 191.17,93.26 v1(190.74,93.69) ; U38.A34 237.25,63.31 237.42,63.49 R368.2 237.86,64.38 237.86,65.19 238.16,65.49 v1(238.19,65.49)
  IN1 w0.089: v1(238.19,65.49) 237.7,65.98 237.7,66.3 237.44,66.56 231.94,66.56 231.1,65.71 231.1,65.42 230.54,64.86 227.98,64.86 226.6,63.49 213.91,63.49 207.9,57.47 207.26,57.47 206.4,58.33 206.4,58.59 205.33,59.66 195.01,59.66 194.4,60.27 189.6,60.27 185.07,64.79 185.07,67.34 188.29,70.57 188.29,90.3 190.74,92.75 v1(190.74,93.69)
PCH_AZ_BITCLK: length 34.9
  TOP w0.108: RC26.2 132.55,66.1 132.8,65.85 135.65,65.85 136.26,65.24 v1(136.26,64.02)
  BOTTOM w0.076: 126.43,74.97 126.75,75.29 126.75,78.4 125.87,79.28 125.87,79.41 125.42,79.86 125.42,80.19 125.43,80.21 125.43,80.61 125.42,80.65 125.42,80.82 125.52,81.13 arc(125.59,81.27) UC1.AY22
  BOTTOM w0.108: 126.43,74.97 126.1,74.97 124.35,73.22 124.35,67.44 127.16,64.63 v2(132.45,64.63) 135.65,64.63 v1(136.26,64.02)
PCH_AZ_CODEC_BITCLK: length 157.1
  TOP w0.108: v1(129.78,67.06) 130.03,67.31 CC5.2 131.24,66.97 RC26.1 ; v1(49.67,92.16) 50.07,92.57 50.07,96.43 51.35,97.71 52.78,97.71 53.79,98.71 53.79,103.5 56.31,106.03 56.31,110.51 55.42,111.41 54.54,111.41 54.21,111.73 54.21,113.02 53.76,113.47 53.76,114.92 52.82,115.86 51.32,115.86 50.53,116.65 50.53,118.4 v2(50.94,118.81) 51.43,119.3 51.79,119.3 53.27,120.79 53.27,122.77 52.71,123.33 49.44,123.33 R149.2 48.55,122.44 48.55,122.06 47.92,121.43 47.36,121.43 46.98,121.04 46.11,121.04 45.91,121.24 45.91,121.91 45.35,122.47 U17.6
  IN3 w0.089: v1(129.78,67.06) 127.22,64.49 120.98,64.49 119.62,65.85 115.38,65.85 112.36,68.87 106.36,68.87 105.3,67.81 103.47,67.81 97.7,73.58 97.7,80.3 97.04,80.96 97.04,82.13 96.12,83.05 94.58,83.05 94.14,82.61 91.83,82.61 90.75,83.68 86.77,83.68 85.1,85.35 74.02,96.43 63.49,96.43 63.16,96.76 59.51,96.76 58.34,95.59 53.48,95.59 52.76,94.88 51.29,94.88 50.49,94.08 50.49,93.19 50.79,92.9 50.79,92.11 50.44,91.76 50.07,91.76 v1(49.67,92.16)
PCH_AZ_CODEC_RST#: length 166.8
  TOP w0.108: v1(51.45,93.46) 50.97,93.94 50.97,96.33 51.6,96.96 53.04,96.96 54.49,98.42 54.49,103.21 57.08,105.8 57.08,110.75 55.76,112.07 55.76,112.47 54.6,113.63 54.6,115.84 54.39,116.04 v2(54.39,117.29) 54.39,117.95 53.35,118.98 53.35,119.52 54.01,120.18 54.01,123.18 53.02,124.17 52.69,124.17 52.08,124.78 47.36,124.78 v1(47.18,124.6) 45.61,124.6 45.48,124.47 U17.11 ; v1(135.55,65.16) 135.44,65.27 RC25.1 131.53,65.27 131.42,65.15 CC287.2 ; v1(36.97,130.26) 36.69,129.99 35.42,129.99 R153.1
  IN3 w0.089: v1(135.55,65.16) 135.24,65.16 133.73,63.65 105.63,63.65 95.19,74.09 95.19,76.6 88.88,82.92 86.27,82.92 73.41,95.78 63.2,95.78 63.08,95.89 59.72,95.89 58.77,94.95 53.75,94.95 53.03,94.23 51.71,94.23 51.45,93.97 v1(51.45,93.46) ; v1(47.18,124.6) 47.18,125.62 42.53,130.26 v1(36.97,130.26)
PCH_AZ_CODEC_SDIN0: length 159.7
  TOP w0.108: R136.1 50.07,124.19 51.5,124.19 C2750.2 52.43,123.76 52.5,123.7 52.68,123.7 53.54,122.84 53.54,120.55 51.8,118.81 v2(51.8,117.08) 51.8,116.78 52.33,116.24 52.79,116.24 53.99,115.04 53.99,113.57 54.52,113.04 54.52,111.88 54.75,111.64 55.52,111.64 55.54,111.62 55.55,111.62 56.61,110.56 56.61,105.99 54.02,103.4 54.02,98.61 52.88,97.47 51.44,97.47 50.43,96.46 50.43,92.32 v1(50.28,92.16)
  IN3 w0.089: v1(129.58,67.89) 129.58,67.64 126.67,64.73 121.04,64.73 119.62,66.16 119.6,66.16 117.51,68.24 116.31,68.24 115.43,69.13 105.7,69.13 104.86,68.28 103.66,68.28 98.18,73.76 98.18,80.35 97.27,81.26 97.27,82.45 95.3,84.42 94.16,84.42 93.91,84.18 86.72,84.18 85.33,85.56 74.38,96.51 74.25,96.64 63.58,96.64 63.25,96.97 59.42,96.97 58.25,95.81 53.39,95.81 52.67,95.09 51.2,95.09 50.28,94.17 v1(50.28,92.16)
  BOTTOM w0.076: 127.44,77.71 127.44,78.41 126.36,79.49 126.36,80.31 126.25,80.42 UC1.BA21
  BOTTOM w0.108: v1(129.58,67.89) 129.21,67.89 127.26,69.84 127.26,74.74 127.44,74.92 127.44,77.71
PCH_AZ_CODEC_SDOUT: length 153.2
  TOP w0.108: v1(136.03,66.61) 136.28,66.61 RC23.1 ; U17.5 45.37,122.07 45.65,121.78 45.65,121.1 46.01,120.74 47.05,120.74 47.41,121.1 48.47,121.1 R148.2 49.36,121.07 49.77,121.07 50.18,120.66 v2(50.18,120.38) 50.18,116.42 50.81,115.79 50.81,114.42 51.29,113.93 52.97,113.93 53.98,112.92 53.98,111.64 54.44,111.17 55.33,111.17 56.08,110.42 56.08,106.12 53.55,103.6 53.55,98.81 52.69,97.94 51.25,97.94 49.74,96.44 49.74,92.85 v1(49.06,92.16)
  IN3 w0.089: v1(49.06,92.16) 49.67,91.55 50.53,91.55 51,92.02 51,92.99 50.71,93.28 50.71,93.99 51.38,94.66 52.85,94.66 53.57,95.38 58.43,95.38 59.6,96.54 63.07,96.54 63.4,96.21 73.84,96.21 84.82,85.23 86.63,83.43 89.7,83.43 96.14,76.99 96.14,74.48 104.28,66.33 106.13,66.33 108.19,68.39 111.64,68.39 115.76,64.28 132.2,64.28 134.9,66.99 135.48,66.99 135.65,66.99 v1(136.03,66.61)
PCH_AZ_CODEC_SYNC: length 151.1
  TOP w0.108: v1(51.5,92.31) 50.73,93.07 50.73,96.43 51.5,97.19 52.94,97.19 54.26,98.52 54.26,103.31 56.85,105.9 56.85,110.65 55.53,111.98 55.53,112.37 54.23,113.67 54.23,115.17 53.83,115.56 53.83,117.56 v2(52.72,118.68) 52.72,119.34 53.78,120.4 53.78,123.06 52.9,123.93 52.6,123.93 51.98,124.55 47.76,124.55 47.38,124.17 45.07,124.17 44.97,124.07 U17.10 ; RC24.1 v1(135.34,66.56)
  IN3 w0.089: v1(135.34,66.56) 132.65,63.87 114.06,63.87 113.24,64.69 105.26,64.69 95.66,74.29 95.66,76.8 89.32,83.13 86.46,83.13 84.68,84.92 73.6,95.99 63.29,95.99 63.09,96.2 59.56,96.2 58.52,95.16 53.66,95.16 52.94,94.44 51.47,94.44 50.93,93.9 50.93,93.37 51.22,93.08 51.22,92.59 v1(51.5,92.31)
PCH_AZ_RST#: length 33.7
  TOP w0.108: v1(135.55,64.02) 135.01,64.55 132.68,64.55 132.52,64.4 RC25.2
  BOTTOM w0.076: UC1.AW22 125.65,82 arc(125.47,81.73) 125.41,81.41 arc(125.4,81.31) 125.37,81.21 125.25,80.87 125.25,80.61 125.26,80.58 125.26,80.25 125.25,80.23 125.25,79.8 125.7,79.34 125.7,79.21 126.58,78.33 126.58,75.43 126.32,75.17 125.66,75.17
  BOTTOM w0.108: 125.66,75.17 123.86,73.37 123.86,67.4 127.24,64.02 v2(134.35,64.02) v1(135.55,64.02)
PCH_AZ_SDIN0_R: length 4.7
  TOP w0.108: U17.8 44.82,123.27 44.91,123.18 45.53,123.18 46.01,123.66 47.72,123.66 v2(47.94,123.89) R136.2
PCH_AZ_SDOUT: length 28.6
  TOP w0.108: v1(137.15,64.38) 136.87,64.66 RC23.2 RC9.2
  BOTTOM w0.076: 126.93,77.59 126.93,78.45 126.03,79.35 126.03,79.73 UC1.BB22
  BOTTOM w0.108: v1(137.15,64.38) v2(136.51,65.01) 135.8,65.72 135.19,65.72 134.59,65.12 129.09,65.12 127.39,66.82 127.39,67.42 124.95,69.86 124.95,73.16 126.93,75.14 126.93,77.59
PCH_AZ_SYNC: length 25
  TOP w0.108: v1(135.67,67.99) 134.81,67.12 133.77,67.12 RC24.2
  BOTTOM w0.076: UC1.BA22 125.68,80.53 126.2,80.01 126.2,79.42 127.17,78.45 127.17,77.97
  BOTTOM w0.108: 127.17,77.97 127.17,75.02 126.82,74.68 126.82,69.34 v2(128.69,67.48) 135.16,67.48 v1(135.67,67.99)
PCH_BATLOW#: length 13.6
  TOP w0.076: v3(135.34,76.25) 135.34,76.29 135.29,76.34 135.29,76.59 v2(134.17,77.71)
  IN1 w0.102: v3(130.15,82.87) 130.15,82.49 132.24,80.4 133.65,80.4 134.21,79.84 134.32,79.73 134.32,78.13 135.34,77.1 v3(135.34,76.25)
  BOTTOM w0.076: RP4808.3 136.49,76.01 136.21,76.29 135.75,76.29 135.71,76.25 v3(135.34,76.25) ; v3(130.15,82.87) 130.28,82.87 UC1.AU13
PCH_CL_CLK1: length 172.3
  IN3 w0.089: v1(142.23,121.28) 142.98,121.28 143.66,120.6 143.66,119.71 143.03,119.07 143.03,113.18 141.1,111.25 141.1,111.05 139.52,109.47 139.52,108.31 137.09,105.88 137.09,105.44 137.18,105.35 137.54,105.35 137.63,105.26 137.63,104.59 137.54,104.5 137.18,104.5 137.09,104.41 137.09,101.66 137.96,100.8 v3(138.49,100.8)
  IN4 w0.089: v1(30.21,126.78) 31.37,125.62 31.37,115.59 32.05,114.91 33.22,114.91 33.61,114.52 41.02,114.52 45.49,118.99 49.88,118.99 53.03,122.15 57.22,122.15 57.61,122.54 60.51,122.54 68,130.04 71.56,130.04 72.32,129.27 78.95,129.27 79.87,130.19 82.43,130.19 84.89,127.74 84.89,126.44 86.61,124.72 90.5,124.72 90.61,124.83 91.17,125.39 97.9,125.39 99.99,127.48 106.41,127.48 107.74,128.81 111.39,128.81 112.08,128.13 114.1,128.13 116.49,128.13 118.5,130.14 122.39,130.14 123.1,129.44 123.1,128.98 123.71,128.37 124.17,128.37 126.43,126.11 132.26,126.11 134.83,123.55 138.77,123.55 139.16,123.94 140.63,123.94 141.9,122.67 141.9,121.62 v1(142.23,121.28)
  BOTTOM w0.076: UC1.G3 136.77,99.2 137.16,99.6 137.62,99.6 137.71,99.63 137.91,99.83 137.91,99.94 138.49,100.52 v3(138.49,100.8)
  BOTTOM w0.108: v2(141.46,120.92) 141.83,121.28 v1(142.23,121.28) ; v1(30.21,126.78) 30.23,126.77 JWLAN1.42
PCH_CL_DATA1: length 172.2
  TOP w0.108: v2(142.89,121.63) 142.58,121.63 v1(142.3,121.91)
  IN3 w0.089: v1(142.3,121.91) 142.94,121.91 144.05,120.79 144.05,119.55 143.42,118.91 143.42,112.41 142.96,111.95 142.96,110.99 137.93,105.96 137.93,104.03 137.48,103.57 137.48,102.01 138.12,101.36 v3(138.49,101.36)
  IN4 w0.089: v1(30.21,127.39) 31.77,125.84 31.77,115.75 32.22,115.3 33.38,115.3 33.77,114.92 40.75,114.92 45.22,119.39 49.71,119.39 52.87,122.54 57.06,122.54 57.45,122.94 60.35,122.94 67.84,130.43 71.73,130.43 72.49,129.67 78.79,129.67 79.7,130.59 82.61,130.59 83.2,129.99 85.28,127.92 85.28,126.61 86.78,125.11 90.33,125.11 90.59,125.36 91.01,125.79 97.74,125.79 99.9,127.95 106.22,127.95 107.47,129.2 111.61,129.2 112.29,128.52 113.94,128.52 113.94,128.52 115.09,128.52 116.33,128.53 118.75,130.94 124.43,130.94 128.87,126.51 132.42,126.51 134.99,123.94 137.37,123.94 137.86,124.42 141.01,124.42 142.73,122.7 142.73,122.34 v1(142.3,121.91)
  BOTTOM w0.076: v3(138.49,101.36) 138.87,100.98 138.87,100.56 137.78,99.47 137.74,99.47 137.66,99.43 137.43,99.43 UC1.G2
  BOTTOM w0.108: JWLAN1.40 30.34,127.27 v1(30.21,127.39)
PCH_CL_RST1#: length 171
  TOP w0.108: R223.2 v1(27.75,127.75) 27.58,127.58 v2(27.06,127.58)
  IN3 w0.089: v1(141.39,121.65) 141.67,121.37 141.67,121.24 141.91,120.99 141.91,120.8 141.92,120.8 141.92,120.64 142.56,120 142.56,114.19 142.12,113.75 142.12,113.09 140.63,111.6 140.63,111.24 138.14,108.75 v1(138.14,108.09)
  IN4 w0.089: v1(141.39,121.65) 141.39,122.51 140.43,123.47 139.35,123.47 138.96,123.08 134.63,123.08 132.07,125.64 126.23,125.64 123.97,127.9 122.9,127.9 122.63,128.16 122.63,129.24 122.2,129.67 118.75,129.67 116.67,127.6 114.59,127.6 114,127.01 100.18,127.01 98.1,124.92 91.37,124.92 90.69,124.25 86.42,124.25 84.42,126.25 84.42,127.55 82.24,129.72 80.06,129.72 79.14,128.8 72.39,128.8 71.55,127.97 66.6,127.97 60.7,122.07 60.31,122.07 60.31,122.07 57.81,122.07 57.42,121.68 53.3,121.68 50.11,118.49 45.83,118.49 41.39,114.05 33.41,114.05 33.02,114.44 30.48,114.44 28.79,116.14 28.79,126.71 v1(27.75,127.75)
  BOTTOM w0.076: UC1.G1 137.98,99.34 137.98,99.44 139.04,100.49 139.04,101.93 138.75,102.22
  BOTTOM w0.108: CC288.2 137.88,108.09 v1(138.14,108.09) 138.14,107.84 137.74,107.44 137.74,107.42 137.63,107.31 137.63,103.34 138.75,102.22
PCH_CL_RST1#_R: length 3.8
  TOP w0.108: v2(30.91,128.35) 30.69,128.13 v1(30.16,128.13) 29.78,127.75 R223.1
  BOTTOM w0.108: v1(30.16,128.13) 30.54,128.13 30.91,127.77 JWLAN1.38
PCH_DPWROK: length 182.8
  TOP w0.108: v1(161.91,96.61) 160.21,94.91 160.21,93.32 159.41,92.52 159.22,92.52 v2(159.09,92.39) 158.96,92.27 CC266.1 PR6091.1 155.94,92.27 155.89,92.32 RC375.1 ; v1(236.68,63.27) 236.52,63.27 236.25,62.99 U38.A36
  IN1 w0.089: v1(161.91,96.61) 161.46,96.16 161.46,93.43 162.85,92.04 162.85,84.7 v1(162.04,83.89)
  IN2 w0.089: v3(127.26,79.15) 128.09,79.98 130.61,79.98 132.75,77.84 135.24,77.84 136.51,76.57 147,76.57 149.3,78.87 152.27,78.87 153.53,80.13 157.06,80.13 157.65,80.71 158.2,80.71 160.3,82.81 160.96,82.81 v1(162.04,83.89)
  IN3 w0.089: v1(234.63,68.19) 233.84,67.39 233.18,67.39 232.91,67.13 231.71,67.13 231.53,66.95 226.28,66.95 226,66.66 224.63,66.66 223.19,65.22 220.17,65.22 219.73,65.67 217.03,65.67 215.6,64.24 214.66,64.24 213.81,63.38 208.49,63.38 206.87,61.76 206.02,61.76 205.67,61.41 204.53,61.41 204.21,61.41 202.74,59.94 196.09,59.94 194.93,61.11 192.55,61.11 191.55,62.11 191.55,62.5 190.06,64 186.87,64 184.87,65.99 184.87,70.83 183.6,72.11 183.6,79.8 184.51,80.72 184.51,90.94 182.62,92.83 181.14,92.83 180.92,93.05 178.2,93.05 178.03,93.22 165.73,93.22 162.34,96.61 v1(161.91,96.61)
  IN4 w0.089: v1(236.68,63.27) 236.19,63.76 236.19,66.63 v1(234.63,68.19)
  BOTTOM w0.076: UC1.BB20 127.32,79.64 127.32,79.21 v3(127.26,79.15) 127.26,78.83 127.67,78.41 127.67,76.11 CC280.2
  BOTTOM w0.108: CC280.2 128.28,75.5 RC79.1
PCH_JTAG_TCK: length 41.5
  IN4 w0.089: v1(87.51,117.36) 87.96,117.81 93.09,117.81 93.65,117.24 96.19,117.24 97.6,115.83 103.68,115.83 104.96,114.55 v7(104.96,114.36)
  BOTTOM w0.076: 105.34,106.16 105.34,105.4 106.23,104.51 106.23,102.15 106.14,102.06 UC1.B56
  BOTTOM w0.108: v7(104.96,114.36) 105.34,113.99 105.34,112.05 RC369.2 105.34,111.14 105.34,106.16 ; JXDP1.55 82.3,121.64 82.88,121.06 84.68,121.06 86.97,118.76 86.97,117.6 87.21,117.36 v1(87.51,117.36)
PCH_JTAG_TDI: length 57.8
  TOP w0.108: v5(100.06,114.08) 100.16,114.19 v1(100.16,114.8)
  IN3 w0.089: v1(65.47,114.44) 65.71,114.2 69.16,114.2 69.65,113.71 73.5,113.71 73.88,113.32 76.31,113.32 77.32,114.33 79.27,114.33 79.41,114.47 85.67,114.47 86.77,113.38 98.29,113.38 98.77,113.86 99.22,113.86 v1(100.16,114.8)
  BOTTOM w0.076: 103.64,106.04 103.64,105.83 105.37,104.1 105.37,103.51 104.91,103.05 104.91,102.29 104.85,102.24 104.85,102.01 arc(104.83,101.89) 104.76,101.79 104.72,101.75 104.46,101.75 104.37,101.65 104.36,101.65 arc(104.28,101.53) 104.25,101.38 104.25,101.31 104.29,101.27 arc(104.34,101.2) 104.35,101.12 104.35,100.99 UC1.D59
  BOTTOM w0.108: v1(65.47,114.44) 65.72,114.19 66.17,114.19 66.61,113.75 66.61,113.18 66.15,112.71 RC600.1 ; 103.64,106.04 103.64,106.51 103.48,106.68 103.48,108.62 103.19,108.91 103.19,110.81 102.32,111.67 RC366.2 102.12,112.41 101.53,112.99 101.53,113.65 101.26,113.93 101.03,113.93 v1(100.16,114.8)
PCH_JTAG_TDO: length 55.8
  TOP w0.108: v1(100.8,114.77) 101.64,113.93 v5(101.92,113.93)
  IN3 w0.089: v1(64.86,114.44) 65.31,113.98 68.9,113.98 69.38,113.49 73.41,113.49 73.79,113.11 76.4,113.11 77.4,114.1 85.74,114.1 86.85,112.99 99.05,112.99 100.14,114.08 100.14,114.11 v1(100.8,114.77)
  BOTTOM w0.089: 104.85,106.16 104.85,105.46 105.94,104.37 UC1.A56
  BOTTOM w0.108: 104.85,106.16 104.85,110.85 104.42,111.27 104.42,112.04 RC367.2 103.6,112.87 102.02,112.87 101.77,113.11 101.77,113.8 v1(100.8,114.77) ; RC95.1 64.91,114.34 64.91,114.39 v1(64.86,114.44)
PCH_JTAG_TMS: length 60.1
  IN3 w0.089: v1(104.07,108.8) 102.65,110.22 95.82,110.22 94.3,108.71 90.18,108.71 86.35,112.54 83.09,112.54 82.2,113.43 79.16,113.43 78.98,113.25 77.03,113.25 76.54,112.76 73.65,112.76 73.29,113.13 69.36,113.13 69.31,113.08 67.26,113.08 67.17,113.17 65.53,113.17 64.95,113.75 62.04,113.75 61.64,113.35 60.32,113.35 v1(59.77,113.91)
  BOTTOM w0.076: 104.31,105.42 105.76,103.96 105.76,102.96 105.67,102.87 105.67,102.17 105.55,102.05 105.14,102.05 105.01,101.91 arc(104.99,101.85) 104.97,101.8 104.97,101.57 104.81,101.41 UC1.C59
  BOTTOM w0.108: RC101.2 59.17,113.91 v1(59.77,113.91) ; RC365.2 103.8,109.08 v1(104.07,108.8) 104.07,106.06 v2(104.31,105.83) 104.31,105.42
PCH_OPIRCOMP: length 7.8
  TOP w0.254: RC89.1 127.9,76.76 127.89,76.76 127.63,77.02 127.63,78.18 128.19,78.74 128.19,79.96 128.69,80.46 v2(128.69,81.83) 128.69,81.98 128.33,82.34 v3(128.33,82.87)
  BOTTOM w0.152: v3(128.33,82.87) 128.65,83.1 UC1.AU16
PCH_PCIE_WAKE#: length 254
  TOP w0.076: v3(134.07,76.4) 134.1,76.37 RC618.1
  TOP w0.108: R9573.2 260.72,43.17 v1(260.64,43.17) ; v1(232.6,60.72) 232.5,60.82 U38.B46
  IN1 w0.089: v1(161.11,32.28) 160.6,32.28 150.82,42.06 150.82,45.95 150.05,46.72 150.05,48.48 149.24,49.29 149.24,59.26 v1(149.63,59.65) ; v1(232.6,60.72) 233.07,60.25 233.07,60.05 233.4,59.71 235.72,59.71 236.03,60.02 236.03,60.82 236.33,61.12 238.65,61.12 239.46,60.31 242.46,60.31 242.7,60.07 242.73,60.11 244.18,60.11 244.23,60.06 251.78,60.06 252.21,59.62 255.28,59.62 255.7,59.2 261.33,59.2 v1(261.81,59.68)
  IN3 w0.089: v1(149.63,59.65) 150.07,60.1 150.07,60.4 147.25,63.22 147.25,63.58 145.41,65.42 143.88,65.42 140.15,69.15 140.15,71.03 139.56,71.62 137.4,71.62 135.75,73.27 135.75,74.72 v3(134.07,76.4) ; v1(235.62,24.04) 237.07,22.59 247.2,22.59 248.22,23.61 250.25,23.61 251.21,24.57 256.1,24.57 258.3,22.37 v1(264.42,22.37)
  IN4 w0.089: v1(161.11,32.28) 161.52,31.87 163.03,31.87 164.7,33.54 172.22,33.54 172.96,34.28 178.29,34.28 179.9,32.66 201.96,32.66 203.57,31.05 203.57,28.3 204.36,27.51 221.1,27.51 223.89,24.73 234.94,24.73 v1(235.62,24.04) ; v1(261.81,59.68) 261.48,59.35 261.48,56.44 262.45,55.48 262.45,51.09 262.2,50.84 262.2,48.21 262.6,47.82 262.6,45.74 261.9,45.03 261.9,44.43 v1(260.64,43.17)
  BOTTOM w0.076: v3(134.07,76.4) 132.54,76.4 132.54,76.4 130.66,78.28 130.66,78.29 130.26,78.69 130.25,78.69 129.86,79.08 129.62,79.08 129.49,79.08 129.3,79.27 UC1.BB15
  BOTTOM w0.108: v1(264.42,22.37) 264.91,22.85 264.91,24.77 264.48,25.2 264.48,27.22 265.93,28.67 265.93,29.72 265.63,30.02 265.39,30.02 264.67,30.75 264.67,34.18 261.12,37.72 v2(261.12,39.7) 261.13,39.71 261.13,42.68 v1(260.64,43.17)
PCH_PLTRST#: length 51.3
  TOP w0.108: UC3.2 151.61,81.27 v1(150.96,81.92) ; v1(150.96,81.92) 150.51,81.47 v5(150.35,81.47) ; v1(150.96,81.92) UC3.1 152.44,81.92 152.97,81.4 154.27,81.4 v1(154.37,81.29) 154.56,81.49 154.56,81.84 154.65,81.93 RC612.2
  IN1 w0.076: 141.16,77.09 138.2,77.09 137.07,78.22
  IN1 w0.089: 137.07,78.22 133.38,81.9 133.35,81.9 132.54,82.72 132.54,84.93 v3(131.99,85.48) ; 141.16,77.09 141.94,77.09 143.07,78.22 148.25,78.22 149.92,79.9 151.77,79.9 152.32,80.44 153.52,80.44 v1(154.37,81.29)
  IN4 w0.089: v1(150.43,86.86) 150.43,82.45 v1(150.96,81.92)
  BOTTOM w0.108: CC275.2 152.04,94.98 RC587.2 151.51,94.45 RC582.2 151.51,91.68 RC586.2 RC590.2 151.51,89.4 RC613.2 150.43,88.32 v1(150.43,86.86) ; v3(131.99,85.48) 132.12,85.48 UC1.AN10
PCH_PLTRST#_AND: length 507.7
  TOP w0.108: v1(173.8,67.43) 173.42,67.04 CE14.1 ; RI33.2 105.86,138.85 v1(105.15,139.56) ; v1(261.72,36.26) U6202.13 ; UC3.4 154.26,80.84 154.75,80.84 RC611.2 155.36,81.45 155.36,82.31 155.14,82.53 v1(155.14,82.54)
  IN1 w0.089: v1(190.82,113.02) 189.55,113.02 188.53,114.03 188.53,125.72 v1(190.69,127.88) ; v1(27.49,123.48) 27.49,115.63 30.69,112.43 33.48,112.43 33.87,112.82 46.2,112.82 47.43,114.06 48.63,114.06 49.7,115.13 55.14,115.13 64.65,124.65 64.65,126.01 68.24,129.59 68.24,131.94 75.82,139.52 90.9,139.52 92.21,138.21 95.13,138.21 96.96,136.38 v1(96.96,135.97) 97.2,136.2 97.2,136.93 97.5,137.22 99.12,137.22 99.78,136.56 102.86,136.56 103.24,136.94 103.24,138.34 103.44,138.55 104.46,138.55 105.15,139.24 v1(105.15,139.56) 105.15,139.88 104.05,140.98 104.05,141.59 103.4,142.24 103.4,142.67 105.96,145.23 116.72,145.23 v1(116.9,145.4) 117.66,146.17 124.27,146.17 125.32,145.12 132.6,145.12 133.17,144.55 134.53,144.55 138.79,140.29 138.79,138.97 139.2,138.56 139.38,138.39 141.07,138.39 141.91,137.55 144.39,137.55 144.89,137.05 150.37,137.05 152.03,135.39 152.03,132.99 155.11,129.91 158,129.91 158.68,129.23 v1(158.68,128.26) 158.68,126.35 159.57,125.46 168.2,116.83 168.2,105.4 169.06,104.55 169.06,102.34 170.24,101.16 170.24,100.16 170.24,97.76 168.36,95.88 168.36,93.73 169.15,92.95 169.15,83.15 169.35,82.94 v1(169.35,82.91) 168.72,82.27 168.72,81.7 170.2,80.22 170.2,72.3 174.2,68.3 174.2,67.83 v1(173.8,67.43) 173.4,67.03 173.4,63.63 173.92,63.11 173.92,57.91 175.56,56.27 175.56,52.1 176.56,51.1 176.56,49.36 176.04,48.84 176.04,46.51 177.01,45.54 v1(177.01,44.36) 177.01,39.39 179.62,36.78 184.53,36.78 189.75,31.56 213.63,31.56 213.73,31.46 219.72,25.47 228.7,25.47 229.16,25.93 238.1,25.93 239.29,27.13 241.81,27.13 242.21,27.52 245.76,27.52 246.74,28.51 255.57,28.51 257.14,26.94 257.14,26.7 258.07,25.77 260.3,25.77 v1(261.34,24.73)
  IN2 w0.089: v1(158.68,128.26) 159.22,127.72 159.22,125.24 159.22,125.03 160.34,123.91 160.34,122.85 162.77,120.42 165.13,120.42 166.71,118.83 170.27,118.83 170.79,118.31 173.63,118.31 174.3,118.98 180.66,118.98 182.81,116.83 v1(183.96,116.83)
  IN3 w0.089: v1(177.01,44.36) 176.96,44.31 176.06,44.31 175.25,45.12 169.78,45.12 168.36,43.7 165.93,43.7 v1(165.5,44.13) ; v1(155.14,82.54) 155.14,82.53 155.54,82.13 156.69,82.13 157.84,80.99 158.78,80.99 158.83,81.04 158.84,81.04 159.51,81.72 159.51,82.28 160.19,82.96 163.36,82.96 163.91,82.41 168.22,82.41 168.71,82.91 v1(169.35,82.91)
  IN4 w0.089: v1(261.72,36.26) 261.35,35.89 261.35,31.92 260.32,30.89 260.32,25.75 v1(261.34,24.73) ; v1(183.96,116.83) 184.52,116.83 188.33,113.02 v1(190.82,113.02)
  BOTTOM w0.108: JEPC1.21 183.63,57.84 183.1,58.37 183.1,59.52 v2(175.75,66.87) 175.19,67.43 v1(173.8,67.43) ; v1(27.49,123.48) 28.28,124.27 JWLAN1.52 ; R9641.1 164.77,43.4 v1(165.5,44.13) ; v1(96.96,135.97) 96.96,135.55 97.62,134.89 98.16,134.89 RI32.1 ; JGFX1.57 117.7,143.97 116.9,144.77 v1(116.9,145.4) ; R2723.1 191.2,128.31 191.1,128.21 191.02,128.21 v1(190.69,127.88) ; JSEC1.21 174.69,41.01 177.01,43.33 v1(177.01,44.36)
PCH_PLTRST#_EC: length 124.7
  TOP w0.108: v1(237.09,57.73) 237.51,58.15 237.81,58.15 238.28,58.63 U38.B30 ; C9491.2 v1(243.27,59.3)
  IN1 w0.089: v1(153.48,90.82) 153.88,90.42 154.3,90.42 154.44,90.56 159.75,90.56 161.22,89.08 v1(161.22,85.84)
  IN2 w0.089: v1(237.09,57.73) 236.77,57.41 229.88,57.41 228.11,55.64 227.06,55.64 226.16,54.73 219.76,54.73 217.98,56.51 212.55,56.51 212.43,56.63 208.95,56.63 208.23,55.91 206.97,54.65 194.84,54.65 194,55.49 190.61,55.49 189.21,56.89 188.33,56.89 185.18,60.04 183.03,60.04 175.15,67.92 175.15,84.26 174.32,85.09 168.83,85.09 168.24,84.49 163.71,84.49 162.79,85.42 161.65,85.42 v1(161.22,85.84)
  BOTTOM w0.108: v1(153.48,90.82) 153.2,90.54 RC590.1 ; v1(237.09,57.73) 237.51,58.15 237.88,58.15 238.99,59.26 241.21,59.26 241.86,59.91 v2(242.65,59.91) v1(243.27,59.3)
PCH_PLTRST#_SSD: length 9.4
  BOTTOM w0.108: R9641.2 163.44,43.84 v2(162.89,43.84) 162.24,44.49 161.89,44.49 159.52,46.85 JSTRG1.37
PCH_PLTRST#_USB: length 4.4
  BOTTOM w0.108: U92.26 188.58,129.68 188.8,129.46 C3063.1 189.83,129.46 189.84,129.45 R2721.2 R2723.2 v2(191.2,130.39)
PCH_PLTRST#_WWAN: length 3.9
  BOTTOM w0.108: JWWAN1.50 100.08,133.83 RI32.2 98.79,134.15 97.7,134.15 v2(97.47,134.38)
PCH_PLTRST#_WWAN1: length 3.9
  TOP w0.108: v2(106.28,136.51) 106.28,136.72 v1(105.85,137.15) 105.98,137.28 RI33.1
  BOTTOM w0.108: JWWAN1.67 106.02,138.08 105.85,137.91 v1(105.85,137.15)
PCH_PWROK: length 137.8
  TOP w0.108: RC595.1 124.52,70.34 125.8,69.07 126.93,69.07 127.54,68.46 127.55,68.46 v1(129.78,66.23) ; v1(67.36,118.38) 67.52,118.54 67.52,120 PR5814.1
  IN1 w0.089: v1(82.66,80.33) 82.66,80.05 81.6,78.98 77.15,78.98 75.37,80.76 75.37,87.36 76.88,88.87 76.88,98.43 74.74,100.57 74.74,102.1 72.45,104.38 70.69,104.38 68.95,106.11 68.95,107.12 69.52,107.69 69.52,110.79 68.84,111.47 67.65,111.47 66.93,112.19 66.93,117.95 v1(67.36,118.38)
  IN3 w0.089: v1(82.66,80.33) 84.46,82.13 88.76,82.13 94.72,76.17 94.72,73.9 105.44,63.18 134.13,63.18 136.43,65.48 136.43,66.95 135.79,67.59 135.23,67.59 135.23,67.58 134.5,67.58 133.15,66.23 v1(129.78,66.23)
  BOTTOM w0.108: v2(130.52,66.23) v1(129.78,66.23)
PCH_PWROK_R: length 10.6
  TOP w0.108: v3(126.85,79.53) 126.6,79.29 126.6,75.27 CC279.2 124.62,73.95 v2(124.27,73.6) 124.52,73.34 RC595.2
  BOTTOM w0.076: UC1.BA20 126.61,80.47 126.61,79.77 v3(126.85,79.53)
PCH_RSMRST#: length 118.6
  TOP w0.108: v1(230.62,65.51) 230.33,65.22 230.33,64.51 CC286.2 230.77,63.79 231.75,62.82 U38.A45 ; v1(232.45,68.21) 232.42,68.24 R377.2 ; UC9.1 155.03,89.71 155.89,90.57 158.08,90.57 158.89,91.38 164.12,91.38 165.03,92.29 v1(165.72,92.29)
  IN3 w0.089: v1(230.62,65.51) 230.62,65.52 230.33,65.52 230.2,65.65 230.2,66.32 229.97,66.56 226.45,66.56 226.12,66.23 224.75,66.23 223.35,64.83 220.01,64.83 219.56,65.27 217.19,65.27 215.76,63.84 214.82,63.84 213.97,62.99 208.65,62.99 207.04,61.37 206.18,61.37 205.83,61.02 204.37,61.02 202.9,59.55 195.9,59.55 194.73,60.71 192.39,60.71 191.15,61.96 191.15,62.35 189.89,63.6 186.47,63.6 184.44,65.63 184.44,70.63 183.2,71.86 183.2,80.26 184.12,81.17 184.12,89.18 180.66,92.63 180.33,92.63 179.83,92.13 178.3,92.13 177.61,92.83 166.25,92.83 v1(165.72,92.29)
  BOTTOM w0.108: v1(232.45,68.21) 232.05,67.81 232.05,67.8 v2(231.39,67.15) 231.01,66.77 231.01,65.9 v1(230.62,65.51)
PCH_RSMRST#_Q: length 216.3
  TOP w0.108: RC374.2 RC375.2 154.7,91.86 154.84,91.72 155.47,91.72 155.96,91.24 UC9.4 157.58,91.24 158.18,91.83 160.26,91.83 161.86,93.43 v1(161.86,94.73)
  IN1 w0.089: v1(161.86,94.73) 161.86,93.59 163.24,92.2 163.24,84.53 162.19,83.48 159.5,83.48 158.94,82.92 158.94,82.33 158.61,82.01 158.3,82.01 155.72,79.43 155.72,76.57 150.16,71.01 v1(149.69,71.01) ; v1(51.52,95.49) 50.84,96.18 50.84,98.85 52.67,100.68 52.67,105.8 54.12,107.25 54.12,113.03 59.78,118.69 61.33,118.69 63.69,121.05 63.69,122.62 66.79,125.72 66.79,126.81 67.68,127.7 73.7,127.7 74.2,128.21 v1(74.2,130.35)
  IN3 w0.076: 101.33,74.84 99.17,77
  IN3 w0.089: v1(129.78,72.66) 126.27,69.15 125.3,69.15 124.36,68.21 119.42,68.21 117.31,70.31 105.68,70.31 104.24,68.88 103.91,68.88 101.33,71.46 101.33,74.84 ; 99.17,77 99.17,80.05 97.5,81.73 97.5,83.43 96.15,84.77 86.79,84.77 85.53,86.03 74.44,97.11 63.78,97.11 63.44,97.44 58.33,97.44 57.17,96.28 55.59,96.28 55.53,96.34 52.37,96.34 v1(51.52,95.49)
  BOTTOM w0.108: v1(74.2,130.35) 74.81,129.74 RC373.1 ; v1(149.69,71.01) 148.91,70.22 146.57,70.22 v2(146.16,70.63) 145.98,70.8 144.94,70.8 144.23,71.52 137.55,71.52 137.38,71.69 135.77,71.69 135.37,71.29 132.16,71.29 130.79,72.66 v1(129.78,72.66) 129.78,73.52 130.02,73.76 RC591.1
PCH_RSMRST#_R: length 9.9
  BOTTOM w0.076: UC1.AY17 128.1,81.28 127.94,81.12 127.9,81.07 127.9,81 127.84,80.82 127.84,80.65 127.87,80.52 127.87,80.27 127.84,80.19 127.84,78.71 128.71,77.84 128.71,77.08 128.97,76.82 129.47,76.82 129.6,76.7 129.6,76.09 CC277.2
  BOTTOM w0.108: v2(129.14,73.78) RC79.2 129.14,75.12 129.09,75.17 CC277.2 129.58,75.58 129.59,75.59 RC591.2
PCH_RTCRST#: length 88.4
  TOP w0.076: v3(128.33,86.09) 128.6,86.37 129.44,86.37 129.71,86.64 129.71,86.89 129.88,87.06 130.42,87.06 130.63,86.85 130.63,86.69 130.85,86.47 133.28,86.47 133.61,86.81 134.66,86.81
  TOP w0.108: v1(160.28,82.16) 160.16,82.03 160.01,82.03 159.88,81.91 JAPS1.9 ; CC26.1 135.19,88.44 135.19,87.34 134.66,86.81 ; v1(146.19,60.84) 146.35,60.84 147.82,59.37 149.15,59.37 RC57.1
  IN1 w0.076: 135.16,74.84 134.91,74.84 134.25,75.5 133.56,75.5 132.57,76.49 132.57,78.24 131.66,79.16 131.66,79.53 130.31,80.87 129.38,80.87 127.81,82.45 127.81,85.57 v3(128.33,86.09)
  IN1 w0.089: v1(160.28,82.16) 160.28,81.98 160.74,81.52 160.92,81.52 161.43,81.01 161.43,80.71 161.25,80.53 161.25,80.28 160.82,79.85 160.02,79.85 159.84,79.66 159.84,78.58 157.16,75.9 157.16,74.37 156.41,73.62 156.41,70.11 155.27,68.96 147.78,68.96 147.17,69.57 146.17,69.57 145.9,69.3 145.9,68.91 145.93,68.87 145.93,68.64 v1(145.4,68.11) 142.42,68.11 140.42,70.11 140.42,71.22 139.91,71.72 137.02,71.72 135.42,73.32 135.42,74.44 135.28,74.58 135.28,74.73 135.16,74.84
  BOTTOM w0.108: UC1.AM16 128.43,86.09 v3(128.33,86.09) ; v1(145.4,68.11) 144.51,67.22 140.96,67.22 CMOS1.1 141.74,64.81 142.89,64.81 143.85,63.84 v2(143.85,63.28) 143.85,63.11 146.12,60.84 v1(146.19,60.84)
PCH_RTCX1: length 31.7
  IN4 w0.089: v3(127.41,86.13) 127.07,86.47 127.07,87.08 127.21,87.22 127.21,87.78 127.7,88.28 130.26,88.28 130.61,87.93 130.61,87.72 130.89,87.44 132.27,87.44 132.98,86.73 134.86,86.73 136.92,84.67 136.92,79.24 139.2,76.95 140.75,76.95 v1(142.35,75.35)
  BOTTOM w0.108: UC1.AM18 127.55,86.13 v3(127.41,86.13) ; YC3.1 145.85,75.95 v2(145.46,75.56) 145.45,75.55 144.13,75.55 CC91.1 RC341.1 142.94,75.93 v1(142.35,75.35)
PCH_RTCX2: length 29.3
  IN4 w0.089: v3(127.43,86.73) 127.43,87.73 127.79,88.1 130.19,88.1 130.43,87.86 130.43,87.65 130.82,87.26 132.19,87.26 132.96,86.49 134.85,86.49 136.73,84.61 136.73,79.17 139.13,76.77 140.04,76.77 v1(142.04,74.78)
  BOTTOM w0.108: RC341.2 141.84,75.78 141.84,74.97 v1(142.04,74.78) 142.04,74.76 142.26,74.54 RC340.1 142.75,74.17 143.19,73.72 143.7,73.72 v2(143.98,73.44) ; v3(127.43,86.73) 127.23,86.73 UC1.AM20
PCH_RTCX2_R: length 4.7
  BOTTOM w0.108: RC340.2 144.21,74.54 144.31,74.44 CC92.1 145.21,74.86 145.94,74.86 146.14,75.05 YC3.4 v2(146.93,73.9)
