# Allegro board CORE_COMBO_B2_A00_PCB view only.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 47.9
  TOP w0.203: U17.26 38.47,124.47 38.03,124.91 v1(37.96,124.91)
  TOP w0.221: U17.37 38.89,119.82 v1(38.29,119.22)
  TOP w0.254: 36.38,138.67 35.88,138.67 35.59,138.38 Q4209.4
  TOP w0.305: 36.38,136.77 34.48,136.77 34.29,136.57 Q4209.1
  TOP w0.381: 41.26,132.91 41.57,132.6 R9617.1 40.93,132.17 v1(40.88,132.22)
  TOP w0.432: R9627.2 v1(39.33,129.66)
  TOP w0.508: C9903.2 37.56,118.72 38.06,119.22 v1(38.29,119.22) ; v1(34.38,127.55) 34.82,127.55 C131.2 ; v2(28.76,140.58) v1(28.76,139.82) ; v1(34.35,126.89) 34.65,126.58 C9901.2 ; v1(38.7,133.26) 38.21,132.78 C9897.2
  IN3 w0.089: v1(26.22,139.82) v1(25.33,139.82) ; v1(27.37,139.82) v1(28.76,139.82)
  IN3 w0.508: v1(25.33,139.82) v1(24.45,139.82)
  BOTTOM w0.203: C385.2 38.03,123.61 37.91,123.61 37.52,123.99 37.52,124.48 v1(37.96,124.91)
  BOTTOM w0.254: v1(40.88,132.22) 40.4,131.74 39.51,131.74 39.25,131.48 38.68,131.48 Q3606.2
  BOTTOM w0.508: C9898.2 35.62,118.02 v1(35.62,117.34) ; v1(32.47,139.33) 32.95,138.84 v1(32.95,138.8) ; v1(22.49,142.61) 22.23,142.35 JSIMUAJ1.20 ; JSIMUAJ1.5 19.23,138.9 18.65,139.48 v1(18.48,139.48) ; R163.2 34.02,131.2 C137.2 34,130.37 33.97,130.34 v1(33.97,129.78) ; v1(17.12,139.51) 17.23,139.4 JSIMUAJ1.9 ; v1(37.96,124.91) 37.97,124.92 C115.2 ; 36.05,136.93 Q217.2 36.66,136.16 ; v1(31.68,139.82) v1(30.54,139.82) v1(28.76,139.82) v1(27.37,139.82) v1(26.22,139.82) v1(25.33,139.82) ; C150.2 37.12,119.93 37.83,119.22 v1(38.29,119.22) ; v1(23,137.86) 22.6,137.86 JSIMUAJ1.19 ; 16.73,142.54 JSIMUAJ1.10 16.73,140.1 v1(16.7,140.07) ; C9904.2 36.74,116.98 v1(36.38,117.34)
  vias: v1(17.69,142.56) v1(19.98,142.56) v1(25.06,142.56) v1(28.59,142.56) v1(31.38,142.59) v1(33.8,142.54) v1(34.2,129.15) v1(35.88,116.75) v1(36.61,142.51) v1(36.77,139.94) v1(36.79,138.42) v1(36.76,136.89) v1(36.74,135.37) v1(37.73,133.75) v1(37.9,127.88) v1(39.79,133.24) v1(41.26,133.19)
VCC_GT_SENSE: length 46.9
  TOP w0.108: v1(65.24,111.82) 64.76,112.31 PC5821.1 64.3,113.45 v2(63.85,113.45) 63.23,113.45 PR5826.2 62.49,113.22 62.44,113.22 PC5822.2 PC5813.1
  BOTTOM w0.076: 95.31,97.24 96.21,97.24 97.06,98.1 97.3,98.1 97.72,97.97 UC1.J70
  BOTTOM w0.108: v1(65.24,111.82) 65.24,111.21 66.63,109.82 67.56,109.82 69.45,107.93 69.45,106.21 76.87,98.79 82.88,98.79 83.47,99.39 88.72,99.39 88.91,99.2 90.69,99.2 91.81,98.08 93.18,98.08 93.46,97.8 RC448.2 95.31,97.24
VCC_SW: length 0.8
  BOTTOM w0.508: v2(112.2,125.46) 112,125.26 v1(112,124.74)
VCC_VIN:
  vias: v1(113.79,129.36) v1(115.33,129.39) v2(113.7,128.66) v4(114.52,129.46) v4(115.15,130.14) v4(115.71,130.88)
VCCIO_SENSE: length 99.7
  TOP w0.076: v3(124.65,86.16) 125.03,85.78 125.03,82.69 124.32,81.98
  TOP w0.108: v1(143.39,70.44) 143.39,69.93 142.66,69.2 142.66,68.9 137.08,63.32 v2(134.69,63.32) 130.22,63.32 129.19,64.35 129.19,65.52 126.74,67.96 125.7,67.96 123.25,70.41 123.25,72.17 122.43,72.98 122.43,74 122.17,74.27 121.87,74.27 RC420.2 122.29,75.07 122.29,75.43 121.85,75.86 121.85,78.17 122.92,79.24 122.92,79.57 124.32,80.96 124.32,81.98
  IN3 w0.089: v1(174.56,65.22) 174.13,65.22 173.56,64.65 169.69,64.65 169.59,64.54 159.93,64.54 157.02,67.45 156.67,67.8 152.81,67.8 152.29,68.33 149.26,68.33 146.62,70.97 143.91,70.97 v1(143.39,70.44)
  IN4 w0.089: v1(176.59,82.03) 176.41,81.85 176.41,80.53 175.47,79.59 175.47,75.66 174.2,74.39 174.2,66.31 174.05,66.16 174.05,65.72 v1(174.56,65.22)
  BOTTOM w0.108: PR5603.2 176.22,81.66 v1(176.59,82.03) ; v3(124.65,86.16) 124.5,86.16 UC1.AM23
VCCSENSE: length 59
  TOP w0.108: PC5841.2 71.74,108.07 71.74,107.86 PR5850.1 PC5838.1 PC5840.2 77.94,107.35 78.22,107.63 v2(78.32,107.63) 78.42,107.53 78.5,107.45 80.78,107.45 82.18,106.06 v1(84.26,106.06) ; v3(119.18,100.3) 119.61,99.87 RC250.2
  IN4 w0.089: v3(119.18,100.3) 118.61,99.73 118.12,99.73 117.69,99.3 117.69,98.88 117.47,98.66 104.41,98.66 103.97,99.1 103.97,99.78 103.48,100.27 103.48,100.58 103.69,100.79 103.69,101.61 100.75,104.56 99.81,104.56 97.36,107.02 96.42,107.02 96.12,106.72 94.8,106.72 94.57,106.95 91.07,106.95 90.93,106.81 86.65,106.81 86.31,106.47 84.68,106.47 v1(84.26,106.06)
  BOTTOM w0.108: UC1.E32 119.33,100.3 v3(119.18,100.3)
VCCST_PWRGD: length 264.1
  TOP w0.108: v1(220.58,65.62) 220.56,65.65 R9582.2 220.56,67.44 220.46,67.54 U6218.4 ; v1(87.59,102.22) 87.59,102.86 88.71,103.98 88.71,105.91 87.82,106.8 87.39,106.8 86.77,107.41 86.77,112.91 81.38,118.3 79.54,118.3 79.19,118.66 v1(79.19,120.78) 79.19,120.91 77.8,122.3 77,122.3 75.81,123.49 75.81,126.45 v5(75.54,126.72) 75.45,126.81 v1(75.45,130.39)
  IN4 w0.089: v1(219.04,44.31) 219.04,44.29 219.02,44.31 217.03,44.31 214.63,46.71 213.24,46.71 212.53,47.42 197.22,47.42 195.57,45.76 190.46,45.76 190.12,46.1 185.09,46.1 177.62,53.57 177.62,55.93 177.34,56.21 177.34,58.85 176.39,59.81 172.98,59.81 172.52,60.27 172.52,69.52 167.89,74.15 167.89,80.6 168.06,80.77 168.06,83.86 168.34,84.15 168.34,93.48 161.69,100.13 161.69,101.88 161.69,101.88 161.69,102.21 160.53,103.38 160.53,104.75 159.62,105.65 157.72,105.65 157.01,106.36 157.01,110.49 155.17,112.33 154.09,112.33 148.9,117.52 146.17,117.52 145.81,117.88 142.23,117.88 141.82,118.29 137.95,118.29 136.71,119.53 131.82,119.53 131.07,120.28 126.81,120.28 124.48,117.96 106.91,117.96 105.92,118.95 99.11,118.95 97.62,120.43 97.01,120.43 96.04,119.47 85.18,119.47 84.07,120.57 79.39,120.57 v1(79.19,120.78)
  BOTTOM w0.108: RC372.1 76.02,129.96 75.88,129.96 v1(75.45,130.39) ; v1(219.04,44.31) 219.04,44.94 218.75,45.24 218.75,52.53 219.13,52.91 219.13,54.49 218.51,55.11 218.51,60.52 219.81,61.82 219.81,62.95 220.58,63.72 v1(220.58,65.62) ; RC455.2 v1(87.59,102.22) 87.9,102.22 87.97,102.14 RC278.1
VCCST_PWRGD_CPU: length 13.8
  TOP w0.108: v3(101.41,102.35) 100.47,102.35 v5(100.33,102.49) 100.22,102.59 97.26,102.59 96.89,102.22 93.94,102.22 93.56,101.84 v1(92.04,101.84)
  BOTTOM w0.102: UC1.B65 100.98,102.27 101.06,102.35 v3(101.41,102.35)
  BOTTOM w0.108: RC278.2 89.61,101.74 90.94,101.74 CC270.2 91.5,102.22 91.88,101.84 v1(92.04,101.84)
VCCST_PWRGD_EC: length 19.8
  TOP w0.108: v1(232.18,62.65) 232.25,62.58 U38.A44 ; v1(221.21,65.62) 221.21,66.1 R9582.1
  IN4 w0.089: v1(221.21,65.62) 222.54,66.95 231.61,66.95 232,66.56 232,65.48 233.21,64.28 233.21,62.35 233.08,62.22 232.61,62.22 v1(232.18,62.65)
  BOTTOM w0.108: v2(221.44,66.38) 221.44,65.85 v1(221.21,65.62)
VDDA18CR: length 4.7
  BOTTOM w0.108: v2(187.34,137.04) C3059.1
  BOTTOM w0.279: U92.14 C3060.1 C3059.1
VDDA18PLL: length 8.2
  BOTTOM w0.108: C3061.1 182.42,121.92 v2(182.21,121.7)
  BOTTOM w0.254: C3061.1 182.42,123.04 181.87,123.58 181.87,124.24 182.42,124.79 C3062.1 182.89,124.98 183.4,125.49 183.4,126.33 184.1,127.03 U92.34
VIN_1V_PRIM:
  vias: v2(172.43,107.84)
VIN_1VS_VCCIO: length 4.3
  BOTTOM w0.254: 171.77,72.66 171.92,72.51 171.92,71.16 v2(172.43,70.65)
  BOTTOM w0.457: 170.94,75.71 PC5602.1 170.47,76.21 ; 170.94,74.87 PC5603.1 170.47,74.33
VSS_GT_SENSE: length 55.2
  TOP w0.108: PU5801.6 68.24,113.45 v1(68.22,113.48) 68.1,113.6 PC5820.2 67.35,113.3 67.21,113.3 67.03,113.12 66.44,113.12 66.31,112.99 PC5821.2
  BOTTOM w0.076: UC1.J69 98.52,97.88 98.23,98.16 97.67,98.16 97.42,98.23 97.32,98.26 96.99,98.26 96.17,97.44 95.39,97.44
  BOTTOM w0.108: 95.39,97.44 94.07,97.44 93.9,97.61 93.9,98.11 94.03,98.24 94.32,98.24 94.47,98.39 94.47,98.77 94.35,98.9 RC449.1 92.93,98.37 91.85,98.37 91.04,99.18 91.04,99.51 90.87,99.68 v2(90.82,99.68) 90.57,99.44 89.01,99.44 88.82,99.63 83.37,99.63 82.78,99.03 76.97,99.03 69.71,106.29 69.71,108 67.64,110.07 66.91,110.07 66.66,110.33 66.66,110.53 66.76,110.63 67.96,110.63 68.06,110.73 68.06,110.99 67.96,111.09 66.88,111.09 66.75,111.21 66.75,111.39 66.9,111.54 67.85,111.54 67.98,111.68 67.98,111.87 67.85,112 67.08,112 66.98,112.1 66.98,112.25 67.12,112.38 67.98,112.38 68.11,112.51 68.11,112.76 67.98,112.89 67.63,112.89 67.52,112.99 67.52,113.37 67.63,113.48 v1(68.22,113.48)
VSSIO_SENSE: length 100
  TOP w0.076: 124.53,81.89 125.19,82.55 125.19,85.73 v3(125.59,86.12)
  TOP w0.108: 124.53,81.89 124.53,80.85 123.2,79.52 123.2,79.13 122.13,78.07 122.13,76.01 122.64,75.5 122.64,74.95 RC421.1 122.67,74 122.67,73.08 123.48,72.27 123.48,70.51 125.79,68.2 126.84,68.2 129.42,65.61 129.42,64.45 130.31,63.56 132.72,63.56 v2(133.01,63.84) 133.09,63.76 134.94,63.76 135.14,63.56 136.99,63.56 139.37,65.94 139.37,66.1 139.03,66.43 139.03,66.59 139.32,66.87 139.47,66.87 139.81,66.53 139.96,66.53 140.24,66.81 140.24,66.97 139.9,67.3 139.9,67.46 140.19,67.74 140.34,67.74 140.61,67.47 140.77,67.47 141.05,67.75 141.05,67.9 140.93,68.02 140.93,68.03 140.73,68.24 140.73,68.47 140.85,68.59 141.23,68.59 141.55,68.27 141.7,68.27 142.42,68.99 142.42,69.4 142.68,69.66 v1(142.68,70.47)
  IN3 w0.089: v1(174.53,65.88) 174.41,65.88 173.4,64.87 169.61,64.87 169.5,64.76 160.02,64.76 157.24,67.54 156.76,68.02 152.9,68.02 152.38,68.54 149.35,68.54 146.71,71.18 143.39,71.18 v1(142.68,70.47)
  IN4 w0.089: v1(174.53,65.88) 174.43,65.98 174.43,74.32 175.7,75.59 175.7,79.46 176.1,79.86 176.24,79.86 v1(176.72,79.39)
  BOTTOM w0.108: v1(176.72,79.39) 176.59,79.26 PR5602.2 ; UC1.AM22 125.46,86.12 v3(125.59,86.12)
VSSSENSE: length 63.1
  TOP w0.108: PU5801.18 72.56,109.75 PC5841.1 PC5842.2 73.44,109.26 73.52,109.34 73.52,109.69 73.72,109.89 74.04,109.89 74.17,109.77 74.17,108.34 74.02,108.19 73.46,108.19 73.33,108.06 73.33,107.67 73.41,107.59 77.66,107.59 78.14,108.07 78.5,108.07 78.88,107.69 80.88,107.69 81.34,107.23 v2(81.65,107.23) 81.65,106.97 82.33,106.29 83.89,106.29 84.06,106.47 84.48,106.47 v1(84.87,106.07) ; v3(119.18,99.71) 118.68,99.22 118.68,98.92 118.6,98.84 RC260.1
  IN4 w0.089: v1(84.87,106.07) 86.22,106.07 86.74,106.6 91.02,106.6 91.16,106.74 94.38,106.74 94.64,106.48 96.19,106.48 96.21,106.5 96.51,106.8 97.27,106.8 99.69,104.38 100.67,104.38 103.52,101.54 103.52,100.87 103.26,100.61 103.26,100.24 103.8,99.7 103.8,99.02 104.23,98.59 104.34,98.48 117.54,98.48 117.67,98.61 117.87,98.81 117.87,99.23 118.19,99.56 119.02,99.56 v3(119.18,99.71)
  BOTTOM w0.108: UC1.E33 119,99.71 v3(119.18,99.71)
+BL_PWR_SRC: length 3.9
  BOTTOM w0.254: 55.53,100.7 JEDP1.5 ; 57.03,100.7 JEDP1.2 ; 56.03,100.7 JEDP1.4 ; 56.53,100.7 JEDP1.3
  vias: v1(52.56,109.3) v1(52.56,108.69) v1(55.93,100.66) v1(55.94,100.05) v2(53.05,111.77)
+CAP_LDO: length 5.2
  TOP w0.279: U37.B46 258.78,57.67 258.68,57.57 v1(258.67,57.57)
  TOP w0.508: C336.1 257.74,60.77 v1(257.9,60.62)
  BOTTOM w0.508: v1(258.67,57.57) 258.49,57.74 v2(258.49,58.67) 258.46,58.71 258.46,60.19 258.05,60.59 257.92,60.59 v1(257.9,60.62)
+COINCELL: length 4.4
  TOP w0.508: v1(73.19,31.52) 73.2,31.51 73.85,31.51 v2(74.04,31.32) C9929.1 RTCR1.1
  BOTTOM w0.508: JRTC1.2 v1(73.19,31.52)
+CRT_VCC: length 13.6
  IN1 w0.762: 85.28,144.26 86.45,143.09 95.77,143.09 v4(96.23,143.55)
  BOTTOM w0.762: v4(96.23,143.55) 95.32,142.64 R2739.2
  vias: v1(84.01,144.34) v1(84.62,144.34) v2(84.01,143.6)
+DC_IN: length 430.3
  TOP w0.229: PQ5104.4 75.87,70.16 76.01,70.3 77.99,70.3 v1(78.19,70.5)
  TOP w0.381: PR5237.2 246.3,34.34 v1(246.57,34.07) ; PQ5103.3 69.99,85.18 69.78,85.38 PR5112.1 PR5115.1
  TOP w0.508: PQ5105.2 72.77,85.36 72.53,85.12 PQ5103.1
  IN1 w0.508: v1(80.89,27.21) 80.82,27.14 80.82,26.36 82.96,24.23 143.93,24.23 145.86,26.15 145.86,26.74 145.87,26.75 145.87,27.15 147.73,29.01 147.73,29.82 148.5,30.59 149.58,30.59 150.34,29.83 156.72,29.83 159.85,26.71 165.24,26.71 169.61,31.08 177.89,31.08 178.42,30.54 185.74,30.54 187.78,28.5 196.9,28.5 198.41,26.99 206.98,26.99 211.52,22.44 245.76,22.44 246.19,22.87 v1(246.19,23.48)
  IN1 w1.016: 33.72,87.75 49.47,87.75 49.69,87.52 54.73,87.52 56.79,89.59 64.23,89.59 69.15,84.67 69.15,82.92
  IN2 w0.508: v1(80.89,27.21) 80.11,27.21 78.68,28.63 78.68,34.18 82.36,37.86 84.49,37.86 86.52,39.89 86.52,42.12 85.28,43.36 85.28,48.09 84.24,49.14 81.24,49.14 79.84,50.54 79.84,56.68 80.33,57.16 80.33,62.91 80,63.24 80,69.28 78.78,70.5 v1(78.19,70.5) 76.01,72.68 76.01,75.17 73.38,77.8 73.21,77.97 73.09,78.09 73.09,78.7 70.93,80.86 v4(70.93,81.9)
  IN2 w1.016: 69.15,82.92 69.15,84.7 68.29,85.56 66,87.85 64.26,89.59 56.79,89.59 54.69,87.49 33.77,87.49
  IN3 w1.016: 33.47,87.49 54.7,87.49 56.79,89.59 64.28,89.59 69.15,84.72 69.15,82.92
  IN4 w1.016: 69.15,82.92 69.15,84.67 64.22,89.6 56.75,89.6 54.65,87.49 33.47,87.49
  BOTTOM w0.508: v1(246.57,34.07) 246.57,33.77 247.56,32.78 247.56,29.73 246.49,28.66 246.49,25.27 v2(246.19,24.97) v1(246.19,23.48)
  vias: v4(32.06,89.09) v4(32.06,88.2) v4(32.06,87.32) v4(32.94,89.09) v4(32.94,88.2) v4(32.94,87.32) v4(70.06,82.84) v4(70.06,81.98) v4(70.93,82.79) v4(71.79,82.79) v4(71.79,81.91)
+DC_IN_SS: length 526.5
  TOP w1.27: 149.97,22.77 82.93,22.77 80.84,24.86 79.65,26.97 77.51,29.12 77.51,56.15 76.9,56.76 76.9,64.66
  IN1 w1.27: 150.35,22.77 76.72,22.77 75.88,23.61 75.88,37.94 77.4,39.46 77.4,44.06 77.51,44.16 77.51,56.15 76.9,56.76 76.9,64.47
  IN1 w2.54: 182.66,24.96 179.61,28 176.01,28 173.65,25.64 167.6,25.64 165.19,23.23 151.22,23.23
  IN4 w1.27: 76.9,64.63 76.9,56.76 77.61,56.05 77.61,39.66 75.78,37.83 75.78,25.11 78.12,22.77 150.07,22.77
  IN4 w2.54: 153.1,23.23 165.19,23.23 167.6,25.64 173.65,25.64 176.01,28 179.61,28 182.66,24.96
  BOTTOM w1.27: 150.35,22.77 78.03,22.77 76.89,23.92 76.89,26.11 77.14,26.36 77.14,33.53 78.64,35.03 78.64,40.63 77.53,41.75 77.53,56.12 76.9,56.76 76.9,63.87
  vias: v1(71.26,76.34) v2(76.82,64.68) v4(71.34,77.16) v4(71.94,75.49) v4(72.22,77.15) v4(72.27,76.29) v4(77.91,65.7) v4(77.93,64.75) v4(77.93,63.85) v4(78.74,64.19) v4(150.05,25.46) v4(150.05,24.59) v4(150.91,25.46) v4(150.91,24.59) v4(205.65,24.4) v4(205.65,23.51) v4(206.54,24.4) v4(206.54,23.51) v4(207.45,23.51)
+DCIN_JACK:
  vias: v2(30.16,87.9) v4(27.5,88.26) v4(27.5,87.37) v4(28.39,88.26) v4(28.39,87.37) v4(29.27,88.26) v4(29.27,87.37)
+DCPRTC: length 13.1
  TOP w0.076: v2(132.51,80.19) v3(132.51,79.52)
  IN4 w0.254: v3(132.51,79.52) 132.51,78.97 133.01,78.47 135.15,78.47 137.54,76.08 137.54,75.24 138.62,74.16 v1(138.62,73.9)
  BOTTOM w0.254: v1(138.62,73.9) 139.08,73.9 139.46,74.28 139.67,74.28 139.89,74.51 C9884.1 ; v3(132.51,79.52) 132.28,79.74 UC1.BB10
+DDR_VREF_A_CA: length 3.9
  TOP w0.508: RD15.1 129.44,37.68 129.86,37.68 v2(130.16,37.38) 130.24,37.46 RC69.1 RC68.1 RC67.2
+DDR_VREF_B_CA: length 5
  TOP w0.254: v2(132.62,24.7) 132.37,24.96 RC126.1
  TOP w0.508: RD14.1 129.03,24.84 129.02,24.85 RC130.2 129.58,25.39 130.01,24.96 RC132.1 RC126.1
+DDR_VREF_B_DQ: length 85.7
  TOP w0.508: v2(131.58,54.73) v1(130.9,54.73) ; RC126.2 132.34,25.82 132.4,25.77 CC69.1 133.22,26.21 132.88,26.56 132.88,27.29 133.08,27.5 v1(133.52,27.5)
  IN3 w0.508: v1(130.9,54.73) 130.83,54.66 130.83,47.17 132.17,45.84 132.17,43.22 133.22,42.17 133.22,33 133.52,32.7 v1(133.52,27.5)
  BOTTOM w0.152: UC1.BA67 99.31,80.41 99.31,79.85 98.46,78.99 98.45,78.99 98.22,78.76 98.22,78.76 98.11,78.64 98.11,78.14 98.28,77.97
  BOTTOM w0.508: 98.28,77.97 98.28,75.91 97.95,75.58 97.95,73.57 108.35,63.18 128.74,63.18 131.15,60.77 131.15,54.98 v1(130.9,54.73)
+DDR_VREF_CA: length 72.8
  TOP w0.508: v2(132.21,37.88) CC67.1 131.18,39.11 RC68.2 131.2,39.23 131.2,41.91 v1(130.92,42.19)
  IN3 w0.508: v1(130.44,55.18) 130.19,54.94 130.19,46.91 130.2,46.9 130.2,46.86 131.53,45.53 131.53,42.8 v1(130.92,42.19)
  BOTTOM w0.127: UC1.AY67 99.45,81.21 99.45,81.12 98.66,80.32 98.66,79.87 97.29,78.5
  BOTTOM w0.254: 97.29,78.5 96.68,77.89
  BOTTOM w0.508: v1(130.44,55.18) 130.44,60.35 128.39,62.41 107.95,62.41 96.68,73.67 96.68,77.89
+DOCK_DC_IN: length 27.8
  TOP w0.254: v1(227.92,33.88) 228.76,34.72 228.76,38.49 228.59,38.67 228.59,41.75 PR5252.2
  BOTTOM w0.305: 157.9,79.15 JDOCK1.50 156.4,79.15 ; 157.9,80.15 JDOCK1.48 156.4,80.15 ; 156.4,79.65 JDOCK1.49 157.9,79.65 ; 157.9,81.15 JDOCK1.46 156.4,81.15 ; 156.4,80.65 JDOCK1.47 157.9,80.65 ; 156.4,76.65 JDOCK1.55 157.9,76.65 ; 156.4,78.65 JDOCK1.51 157.9,78.65 ; 157.9,77.65 JDOCK1.53 156.4,77.65 ; 156.4,77.15 JDOCK1.54 157.9,77.15 ; 156.4,78.15 JDOCK1.52 157.9,78.15
  BOTTOM w1.016: 158.88,76.44 158.88,75.74 158.56,75.43
  BOTTOM w1.524: 155.66,75.48 155.66,77.71
  vias: v1(154.49,48.45) v1(158.11,79.9) v1(158.11,79.29) v2(156.04,75.07) v2(156.04,73.32) v2(156.07,71.49) v4(153.6,71.21) v4(153.6,70.35) v4(154.05,47.71) v4(154.05,46.82) v4(154.47,71.21) v4(154.47,70.35) v4(154.94,47.84) v4(154.94,46.95) v4(154.94,46.06) v4(155.33,71.21) v4(155.33,70.35) v4(207.2,41.63) v4(208.06,41.62) v4(211.26,40.77) v4(211.26,39.88) v4(212.15,40.77) v4(212.15,39.88) v4(213.04,40.77) v4(213.04,39.88) v4(226.86,29.15) v4(226.86,28.26) v4(226.86,27.37) v4(227.75,29.15) v4(227.75,28.26) v4(227.75,27.37)
+PBATT: length 93
  TOP w0.508: PD5206.1 229.42,32.85 v1(230.22,33.66) ; PR5249.1 238.42,38.7 v1(238.19,38.47)
  IN1 w0.508: v1(230.65,28.02) 230.03,28.63 230.03,31.33 230.54,31.84 230.54,33.29 230.22,33.6 v1(230.22,33.66)
  IN2 w0.762: v4(161.27,28.93) 161.27,29.6 162.01,30.34 173.22,30.34 173.81,30.93 196.23,30.93 200.91,26.24 226,26.24 226.64,25.6 228.22,25.6 v1(230.65,28.02)
  BOTTOM w0.508: v1(238.19,38.47) v2(237.09,37.38) 236.74,37.02 232.45,37.02 231.58,36.16 231.58,35.93 230.22,34.57 v1(230.22,33.66)
  vias: v2(156.93,31.56) v2(157.82,33.34) v2(159.7,33.34) v2(164.83,31.69)
+PECI_VREF: length 7.4
  TOP w0.254: v2(224.7,63.41) 224.88,63.59 225.97,63.59 R374.1
  TOP w0.305: U38.B51 230,61.39 229.25,62.14 227.66,62.14 C360.1 226.95,63.15 226.6,63.49 226.6,64.07 R374.1
+PWR_SRC: length 441.4
  TOP w0.381: PR5810.1 74.2,124.96 73.31,125.85 v1(72.97,125.85)
  TOP w0.508: v4(67.22,81.01) 66.86,81.37 66.86,85.84 66.71,85.99 66.71,86.75 65.11,88.35 65.1,88.35 64.45,88.8 64.02,88.99 63.03,89.33 58.68,89.33 56.9,88.93 55.6,88.33 55.29,88.02 54.14,88.02 53.66,88.51 53.66,89.42 v4(53.37,89.7) ; 178.19,34.94 174.56,34.94 174.23,35.27 169.34,35.27 168.54,36.07 168.54,38.62 167.5,39.66 163.05,39.66 162.75,39.36 v1(162.75,38.98)
  TOP w5.08: 151.12,122.06 153.5,119.68 153.75,119.68 159.08,114.34 161.15,114.34
  IN1 w0.508: v1(72.97,125.85) 72.53,125.41 68.95,125.41 68.62,125.09 67.95,125.09 64.89,122.03 64.89,120.56 61.82,117.49 60.46,117.49 58.39,115.42 58.39,114.17 v4(56.7,112.48)
  IN1 w1.016: v4(53.37,89.7) 53.37,92.61 53.7,92.94 53.7,95.01 54.12,95.43 54.12,102.94 56.56,105.38 56.56,112.34 v4(56.7,112.48)
  IN2 w1.016: v4(46.81,111.17) 49.59,111.17 51.22,112.8 54.01,112.8 54.58,113.37 55.81,113.37 v4(56.7,112.48)
  IN2 w2.032: 167.65,25.39 173.72,25.39 176.13,27.8 181.62,27.8 ; 164.6,22.95 77.24,22.95 76.01,24.18 76.01,35.27 77.91,37.17 77.91,59.42 ; 68.26,78.47 68.26,75.28 75.65,67.89 75.65,63.36 76.52,62.5 76.52,60.95
  IN3 w2.032: 181.62,27.8 176.13,27.8 173.72,25.39 167.57,25.39 ; 68.26,78.47 68.26,75.29 75.65,67.9 75.65,63.62 75.68,63.59 75.68,63.34 76.52,62.5 ; 77.89,59.53 77.89,37.15 75.19,34.46 75.19,24.47 76.69,22.98 164.4,22.98
  BOTTOM w0.457: R9576.1 163.05,41.87 162.75,41.57 v1(162.75,38.98)
  vias: v1(78.67,62.47) v1(78.67,60.47) v1(79.31,62.47) v1(79.31,60.47) v1(162.95,28.13) v2(68.16,79.85) v4(67.22,80.13) v4(67.24,79.24) v4(67.24,78.35) v4(129.86,134.01) v4(129.86,133.15) v4(129.86,132.28) v4(130.74,134.01) v4(130.74,133.15) v4(130.74,132.28) v4(148.01,124.51) v4(148.01,123.62) v4(148.01,122.73) v4(148.87,124.51) v4(148.87,123.62) v4(148.87,122.73) v4(162.62,28.82) v4(163.49,28.66) v4(163.51,27.65) v4(178.75,55.51) v4(178.75,54.62) v4(178.78,53.76) v4(179.64,55.51) v4(179.64,54.62) v4(179.67,53.76) v4(183.35,28.51) v4(183.35,27.65) v4(184.29,28.51) v4(184.29,27.65) v4(185.23,28.51) v4(185.23,27.65) v4(186.14,28.51) v4(186.14,27.65)
+PWR_SRC_AC:
  vias: v2(222.54,31.38)
+PWR_SRC_R: length 3.2
  BOTTOM w0.432: v2(165.8,42.84) 165.66,42.84 R9576.2
  BOTTOM w0.457: R9576.2 JSEC1.1
+RSVD_VCC3P3_1: length 3.3
  TOP w0.203: R178.1 141.16,129.78 v2(141.34,129.96) 142,129.29 U21.1
+RTC_CELL: length 352.2
  TOP w0.254: v1(78.98,68.47) 78.98,67.22 78.58,66.82 77.04,66.82 76.5,66.28 PR5117.1 ; v1(219.09,42.91) 219.09,43.65 221.7,46.27 221.7,47.38 222.36,48.04 R327.2 R347.2 223.84,48.88 223.96,49.01 R328.2 223.78,49.75 R346.2 222.87,49.52 R332.1 ; v1(35.62,141.34) 34.68,140.4 R208.2
  TOP w0.508: RC434.1 148.61,57.74 RC56.2 149.92,57.74 RC57.2 150.8,57.73 ; 150.8,57.73 152.39,56.15 152.39,52.87 v1(151.7,52.19) ; 150.8,57.73 R9557.2 ; v1(78.29,24.77) 75.98,24.77 75.8,24.94 C50.1 RTCD1.3
  IN1 w0.508: v4(68.13,104.38) 68.9,103.62 72.36,103.62 74.1,101.88 74.1,100.32 76.27,98.15 76.27,89.66 74.48,87.87 74.48,80.38 79.21,75.65 79.21,68.7 v1(78.98,68.47) 79.26,68.19 79.26,65.29 80.33,64.22 80.33,53.35 78.9,51.93 78.9,43.58 78.8,43.48 78.8,34.66 77.68,33.54 77.68,25.15 78.07,24.77 v1(78.29,24.77)
  IN2 w0.254: v1(49.13,115.18) 49.13,116.32 46.65,118.8 46.65,126.14 42.12,130.67 39.49,130.67 35.62,134.53 v1(35.62,141.34)
  IN2 w0.508: v1(211.02,35.89) 210.47,36.44 206.46,36.44 204.57,38.33 190.21,38.33 189.23,39.3 175.1,39.3 172.2,42.2 160.27,42.2 156.08,46.39 156.08,50.3 155.34,51.04 154.24,51.04 153.1,52.19 v1(151.7,52.19)
  IN3 w0.508: v1(151.7,52.19) 148.45,52.19 146.19,54.45 144.84,54.45 144.44,54.85 144.44,55.52 143.6,56.35 138.13,56.35 137.97,56.52 105.22,56.52 89.6,72.14 89.6,74.14 87.75,75.99 80.01,75.99 79.31,75.28 79.31,68.8 v1(78.98,68.47)
  BOTTOM w0.254: v4(68.13,104.38) 67.26,103.51 63.99,103.51 61.78,105.72 61.78,107.71 59.95,109.54 58.42,109.54 57.25,110.72 54.96,110.72 52.82,112.87 51.88,112.87 50.89,113.86 50.89,114.75 50.46,115.18 v1(49.13,115.18)
  BOTTOM w0.508: v1(211.02,35.89) 211.95,36.82 213.22,36.82 v2(216.35,39.96) 219.09,42.69 v1(219.09,42.91)
+RTC_CELL_VBAT: length 15.5
  TOP w0.254: v1(230.57,54.12) 230.57,54.18 230.11,54.63 U38.B64
  TOP w0.381: C345.1 221.55,51.21 v1(221.55,50.53) 221.7,50.38 R332.2
  IN1 w0.305: v1(221.55,50.53) 222.06,50.03 225.55,50.03 226.25,50.72 226.25,51.46 228.37,53.58 230.1,53.58 230.57,54.05 v1(230.57,54.12)
  BOTTOM w0.508: v2(221.8,49.59) 221.55,49.85 v1(221.55,50.53)
+SDC_IN: length 49.8
  TOP w0.254: PR5226.2 241.74,28.66 242.1,29.02 v1(242.35,29.02) ; PR5206.2 202.71,26.79 PD5202.3
  TOP w0.508: PD5206.2 228.12,33.03 228.86,33.77 v1(228.97,33.77)
  IN3 w0.254: v1(236.54,27.5) 236.54,28.44 237.17,29.07 240.42,29.07 241.08,28.41 241.74,28.41 v1(242.35,29.02)
  BOTTOM w0.508: v1(235.9,27.5) 235.65,27.75 v2(234.13,27.75) 228.97,32.92 v1(228.97,33.77)
  BOTTOM w0.762: v4(211.12,24.58) 212.06,25.52 235.14,25.52 236.28,26.66
+SIM_PW: length 13.4
  TOP w0.508: v1(244.54,97.65) 245.86,98.97 v5(247.43,98.97) 248.02,99.56 248.02,100.22
  BOTTOM w0.406: C7106.1 C7112.1 244.84,97.96 v1(244.54,97.65) 244.16,98.03 243.39,98.03 243.09,98.34 R7102.2
  BOTTOM w0.508: JSIM1.1 246.9,98.75 246.57,98.41 246.57,97.65 246.06,97.14 245.04,97.14 v1(244.54,97.65)
+SIM_PWR: length 142.7
  TOP w0.254: v1(102.02,131.69) 103.08,131.69 103.97,132.58 103.97,136.69 v1(102.81,137.85) ; C263.1 14.73,140.34 v1(15,140.07) 15.17,139.89 15.17,139.19 15.7,138.67 v5(15.89,138.67)
  IN1 w0.254: v1(102.81,137.85) 102.81,137.93 101.27,139.47 100.58,139.47 99.15,140.89 87.37,140.89 86.85,140.37 71.82,140.37 67.1,135.65 67.1,129.63 63.72,126.25 63.72,125.03 56.21,117.52 54.37,117.52 53.17,116.32 48.4,116.32 47.23,115.15 46.39,115.15 44.89,113.66 32.93,113.66 32.68,113.91 31,113.91 29,115.91 29,119.91 31.15,122.06 31.15,130.87 26.99,135.03 22.62,135.03 21.37,136.29 17.25,136.29 15,138.55 v1(15,140.07)
  BOTTOM w0.254: JWWAN1.36 101.62,130.33 102.02,130.72 v1(102.02,131.69) ; JSIMUAJ1.14 14.73,140.34 v1(15,140.07)
+SM_VREF_CA_DIMMA: length 10.6
  TOP w0.508: v1(127.01,40.5) 126.4,40.5 v2(126.33,40.42) 126.33,39.41 CD13.1 127.24,38.93 127.43,39.12 CD12.1 128.89,39.12 RD15.2
  IN2 w0.508: v1(127.01,40.5) 126.83,40.5 126.27,39.94 126.27,39.64 125.77,39.13 124.88,39.13 v1(124.01,39.99)
  BOTTOM w0.305: JDIMM1.164 v1(124.01,39.99)
+SM_VREF_CA_DIMMB: length 7.4
  TOP w0.508: v1(124.01,26.53) 124.01,26.02 124.71,25.32 CD60.1 125.28,24.42 v2(125.41,24.3) 126.48,24.3 CD61.1 127.32,24.5 127.57,24.25 128.14,24.25
  BOTTOM w0.254: JDIMM2.164 v1(124.01,26.53)
+SM_VREF_DQ0: length 7.4
  BOTTOM w0.127: 97.96,81.72 98.13,81.54 98.24,81.54 98.42,81.41
  BOTTOM w0.152: T6211.1 92.75,81.19 93.78,81.19 93.79,81.19 94.11,81.19 94.12,81.19 96.08,81.19 96.32,81.43 96.53,81.43 96.89,81.79 96.89,81.98 97.08,82.18 97.5,82.18 97.96,81.72 ; 98.42,81.41 98.42,81.41 98.99,81.13
+UZ12_TPM: length 6.3
  BOTTOM w0.279: U25.8 192.06,148.42 192.23,148.59 192.23,149.04 192.21,149.05 C9567.1
  BOTTOM w0.457: C9981.1 194.04,148.93 R9524.1 194.55,148.12 195.01,147.66 R9523.1
  BOTTOM w0.508: C9981.1 193.44,149.53 C9567.1
+V_DDR_REF: length 1.2
  TOP w0.254: PC5411.1 87.95,53.62 v2(87.95,52.57)
+VCHGR:
  vias: v2(161.33,22.7) v2(163.31,22.72) v2(165.24,22.75) v2(167.19,22.72)
+VHDMI_VCC: length 8.9
  BOTTOM w0.508: HDMIU1.2 16.52,120.71 16.45,120.64 C88.1 15.68,119.75 15.62,119.69 C87.1 v2(14.18,119.24) 12.61,119.24 JHDMI1.18
+VR_CAP: length 19.7
  TOP w0.254: U38.B12 235.5,52.8 v1(235.9,53.2)
  TOP w0.508: v1(243.27,53.58) 243.39,53.71 C366.1
  IN1 w0.254: v1(235.9,53.2) 238.62,53.2 238.97,52.85 242.91,52.85 243.27,53.2 v1(243.27,53.58)
  IN2 w0.254: v1(243.27,53.58) 243.27,53.05 242.86,52.64 239.51,52.64 238.95,53.2 v1(235.9,53.2)
  BOTTOM w0.254: v1(243.27,53.58) 243.27,53.66 242.62,54.31 v2(242.62,54.45)
+VREFOUT: length 24.3
  TOP w0.221: 39.92,126 U17.23
  TOP w0.254: C131.1 37.37,127.97 37.37,127.6 37.63,127.34 38.57,127.34 39.92,126
  TOP w0.508: v1(36.82,127.57) 36.82,128.27 C131.1
  IN1 w0.381: v1(33.95,119.88) 37.11,119.88 38.53,121.3 38.53,125.97 36.93,127.57 v1(36.82,127.57)
  BOTTOM w0.254: v1(33.95,119.88) 34.2,119.88 34.38,119.7 35.55,119.7 35.75,119.9 R9624.1
  BOTTOM w0.381: v1(36.82,127.57) 35.75,127.57 v2(35.14,126.96) R9623.1
/BATPRES: length 16.2
  TOP w0.108: v1(229.61,34.63) 229.61,34.67 229.61,34.67 229.65,34.71 PR5257.1 ; PU5201.15 237.86,35.1 238.01,35.24 239.15,35.24 v1(239.33,35.42) 239.84,35.93 239.84,36.13 PR5246.1
  IN2 w0.089: v1(239.33,35.42) 239.15,35.24 237.6,35.24 237.4,35.04 236.36,35.04 235.56,35.84 233.43,35.84 232.55,34.96 229.91,34.96 229.61,34.67 229.61,34.67 v1(229.61,34.63)
  BOTTOM w0.108: v1(239.33,35.42) v2(240.14,35.42)
A_ON: length 234.4
  TOP w0.108: R372.2 244.88,48.94 244.88,47.28 244.39,46.8 243.95,46.8 v1(243.52,47.23) ; v1(190.74,94.93) 190.18,94.93 v2(190.08,95.03) 189.72,95.39 189.39,95.39 R424.1 ; v1(232.04,50.58) 231.75,50.88 U38.A4
  IN1 w0.089: v1(243.52,47.23) 242.49,48.27 240.89,48.27 239.18,49.98 232.64,49.98 v1(232.04,50.58) ; v1(215.24,62.54) 213.46,62.54 208.04,57.12 207.11,57.12 206,58.24 206,58.34 205.03,59.3 194.86,59.3 194.25,59.91 189.45,59.91 184.71,64.65 184.71,73.26 187.94,76.48 187.94,90.45 190,92.52 190,94.2 v1(190.74,94.93)
  IN2 w0.089: v1(190.74,94.93) 190.96,95.16 190.96,104.6 190.16,105.4 190.16,106.26 187.95,108.47 187.95,113.99 184.21,117.72 183.07,117.72 181.23,119.55 166.74,119.55 165.35,120.95 162.99,120.95 160.87,123.07 160.87,124.2 160.77,124.3 159.85,125.21 159.85,129.63 158.51,130.98 158.51,134.79 157.41,135.88 156.53,135.88 155.81,136.6 146.45,136.6 146.24,136.39 141.54,136.39 140.27,137.66 139.12,137.66 133.13,143.64 114.17,143.64 v1(113.7,143.17)
  IN4 w0.089: v1(212.66,53.94) 212.66,52.25 213.51,51.4 223.82,51.4 224.24,51.82 228.9,51.82 229.68,51.04 231.58,51.04 v1(232.04,50.58)
  BOTTOM w0.108: JGFX1.73 v1(113.7,143.17) ; v1(212.66,53.94) 212.66,56.1 213.55,56.99 213.55,57.14 213.48,57.21 213.48,61.51 214.5,62.54 v1(215.24,62.54)
AC_DIS: length 42.8
  TOP w0.108: PQ5217.1 246.13,27.11 246.31,27.29 246.31,28.08 246.75,28.51 246.75,29.79 246.17,30.37 245.96,30.37 PR5225.1 245.73,31.26 245.94,31.47 v1(246.37,31.47) ; v1(253.66,56.76) 253.73,56.83 U37.A50
  IN1 w0.089: v1(254.16,31.87) 253.89,32.14 247.04,32.14 v1(246.37,31.47)
  BOTTOM w0.108: v1(254.16,31.87) 254.16,32.53 v2(254.14,32.54) 254.11,32.58 254.11,33.86 254.83,34.59 254.83,35.7 253.91,36.62 253.91,40.1 254.68,40.87 254.68,42.07 254.77,42.15 254.77,45.32 254.52,45.57 254.52,48.75 255.02,49.25 255.02,50.54 254.75,50.81 254.75,55.66 v1(253.66,56.76)
AC_PRESENT: length 135.8
  TOP w0.108: U38.A54 227.84,57.88 v1(227.34,58.38)
  IN2 w0.076: 134.2,76.85 v3(133.72,76.85)
  IN2 w0.089: 134.2,76.85 135.57,75.48 139.2,75.48 140.5,74.18 148.42,74.18 149.08,74.84 152.23,74.84 153.02,74.05 163.95,74.05 166.51,71.49 168.52,71.49 171.91,68.1 171.91,65.66 176.07,61.51 177.73,61.51 182.1,57.14 184.51,57.14 184.94,56.71 185.75,56.71 187.35,55.11 188.47,55.11 189.87,53.71 193.23,53.71 194.07,52.87 205.37,52.87 207.98,50.26 217.39,50.26 218.42,51.3 220.79,51.3 v1(221.55,52.06)
  BOTTOM w0.076: UC1.AY15 129.57,81.06 129.57,79.91 129.48,79.83 129.48,79.45 129.69,79.24 129.93,79.24 130.32,78.85 130.33,78.85 130.82,78.35 130.82,78.35 132.32,76.85 v3(133.72,76.85) 134.17,76.85 134.41,76.61 136.75,76.61 136.96,76.4 136.96,76.26 136.99,76.24 RP4808.5
  BOTTOM w0.108: v1(221.55,52.06) 221.55,51.75 v2(221.87,51.43) 221.98,51.32 223.68,51.32 224.19,51.83 224.19,52.85 225.46,54.12 225.46,55.65 224.99,56.13 224.99,57.67 224.25,58.41 224.09,58.41 223.6,58.9 223.6,59.24 226.08,61.72 227.65,61.72 228.33,61.03 228.33,59.38 v1(227.34,58.38)
ACAV_IN: length 441.8
  TOP w0.108: Q17.5 46.42,98.97 46.22,98.78 45.58,98.78 45.42,98.94 45.42,100.07 45.95,100.61 45.95,102.9 45.12,103.73 45.12,105.04 44.67,105.49 42.33,105.49 42.09,105.73 41.38,105.73 41.21,105.9 41.21,107.15 38.82,109.54 38.82,110.82 39.34,111.34 41.92,111.34 44.11,113.53 44.11,113.58 v1(44.84,114.31) ; U38.A64 228.19,52.88 228,52.69 228,51.58 v1(227.84,51.42) ; PQ5106.5 72.83,73.47 v2(73.26,73.9) 73.6,74.24 73.6,77.85 v1(74.23,78.47) ; PR5224.2 240.93,27.57 PR5221.2 241.92,28.06 PQ5217.3 243.39,28.06 243.67,28.33 243.67,29.55 v1(243.52,29.71)
  TOP w0.127: PR5224.2 239.61,27.37 239.05,27.37 238.24,28.18 238.24,29.91 237.93,30.21 237.55,30.21 237.06,30.7 PU5201.5
  IN1 w0.089: v1(115.38,148.07) 115.38,147.94 113.63,146.19 105.56,146.19 102.21,142.84 98.58,142.84 97.69,141.94 85.18,141.94 84.31,142.81 72.15,142.81 71.44,142.1 69.61,142.1 66.23,138.72 66.23,129.99 62.85,126.61 62.85,125.68 60.34,123.17 59.13,123.17 57.34,121.38 57.34,119.64 55.52,117.82 53.58,117.82 v1(53.22,117.46) 52.77,117.92 47.45,117.92 44.84,115.31 v1(44.84,114.31) ; v1(160.09,44.01) 160.09,39.12 161.28,37.94 163.92,37.94 166.58,35.27 v1(166.58,32.78) ; v1(240.35,47.23) 240.35,48.56 239.1,49.8 231.89,49.8 230.88,50.81 230.08,50.81 229.05,49.78 228.5,49.78 228.26,50.01 228.26,51 v1(227.84,51.42) ; v1(54.64,90.57) 56.01,91.94 56.01,94.54 55.36,95.19 55.36,102.43 57.86,104.93 57.86,110.39 58.24,110.77 v1(58.24,110.8)
  IN2 w0.089: v1(243.52,29.71) 242.81,29.71 242.58,29.93 241.15,29.93 240.48,29.26 229.29,29.26 227.74,30.8 221.19,30.8 219.5,32.49 177.93,32.49 177.24,33.18 166.98,33.18 v1(166.58,32.78)
  IN3 w0.089: v1(54.64,90.57) 55.11,91.04 56.96,91.04 57.36,90.65 65.56,90.65 72.88,83.33 72.88,79.83 v1(74.23,78.47) 74.23,77.41 74.94,76.7 87.64,76.7 90.23,74.11 90.23,72.11 105.31,57.02 138.28,57.02 138.52,56.78 143,56.78 144.85,56.78 145.22,56.41 145.22,56.09 148.45,52.86 151.96,52.86 154.3,50.52 154.3,50.15 155.13,49.31 155.61,49.31 156.91,48.02 157.45,48.02 160.26,45.21 160.26,44.18 v1(160.09,44.01)
  BOTTOM w0.108: v1(115.38,148.07) 115.38,143.85 115.7,143.53 JGFX1.65 ; v1(243.52,29.71) 243.01,30.21 243.01,37.35 242.05,38.32 242.05,39.16 241.54,39.66 241.54,46.03 v1(240.35,47.23) ; JHS1.3 165.28,31.12 165.72,31.56 166.15,31.56 166.58,31.99 v1(166.58,32.78)
  BOTTOM w0.127: v1(58.24,110.8) 58,111.04 55.58,111.04 54.54,112.07 54.54,115.61 53.22,116.93 v1(53.22,117.46)
ACAV_IN#: length 40.5
  TOP w0.108: v1(61.3,119.41) 61.55,119.16 61.56,119.16 v2(61.9,118.82) 62.01,118.71 62.01,116.09 61.37,115.45 60.08,115.45 58.92,114.29 UC12.2 ; Q17.3 47.07,96.46 47.05,96.44 R9668.1 47.4,95.92 47.58,95.75 v1(48.86,95.75)
  IN1 w0.089: v1(61.3,119.41) 60.97,119.08 59.94,119.08 59.94,119.08 59.61,119.08 53.73,113.19 53.73,107.41 52.28,105.96 52.28,100.84 50.44,99.01 50.44,97.33 v1(48.86,95.75)
ACAV_IN_DOCK: length 285.5
  TOP w0.254: PQ5216.1 252.47,35.23 v1(252.26,35.01) 252.26,33.95 252.08,33.77 PQ5214.5 ; v1(78.42,67.98) 76.57,67.98 76.09,67.5 75.5,67.5 75.37,67.63 PQ5104.2 ; v1(240.9,54.99) 240.64,54.99 240.53,54.88 U38.A21 ; PR5256.1 225.92,40.91 v1(226.4,40.91)
  IN3 w0.254: v1(78.42,67.98) 79.22,67.98 79.82,68.59 79.82,75.07 80.22,75.48 87.54,75.48 88.99,74.03 88.99,72.03 105.09,55.93 137.84,55.93 137.92,55.84 143.39,55.84 143.83,55.41 143.83,47.99 147.15,44.67 148.29,44.67 159.37,33.59 159.37,33.06 161.71,30.72 168.19,30.72 168.39,30.52 177.13,30.52 177.68,29.97 187.36,29.97 188.99,28.33 196.07,28.33 197.34,27.06 208.11,27.06 210.65,29.6 224.75,29.6 225.31,30.16 229.17,30.16 230.44,28.89 232.18,28.89 234.94,26.14 238.35,26.14 239.51,27.29 244.92,27.29 247.46,29.83 v1(252.66,29.83) ; v1(226.4,40.91) 226.88,40.42 227.75,40.42 228.56,41.24 232.95,41.24 234.13,40.06 239.65,40.06 240.69,41.1 245.3,41.1 245.73,41.54 249.89,41.54 250.28,41.92 v1(250.96,41.92)
  IN4 w0.254: v1(250.96,41.92) 249.46,43.42 249.46,43.52 248.58,44.41 248.58,50.71 247.16,52.13 247.16,53.5 247.13,53.53 247.13,53.53 246.9,53.76 246.9,54.45 246.35,54.99 v1(240.9,54.99)
  BOTTOM w0.254: v2(79.31,69.48) 78.19,69.48 77.81,69.1 77.81,68.57 78.4,67.98 v1(78.42,67.98) ; v1(250.96,41.92) 251.47,41.42 251.47,40.34 251.27,40.15 251.27,36.13 252.26,35.14 v1(252.26,35.01) 252.26,33.87 250.51,32.12 250.51,30.72 251.39,29.83 v1(252.66,29.83)
ACAV_IN_NB: length 37.6
  TOP w0.108: v1(237.91,53.71) 237.99,53.63 U38.B20 ; PR5243.2 242.76,38.37 242.71,38.42 v1(242.71,38.72)
  IN1 w0.089: v1(250.58,51.27) 247.94,51.27 245.23,53.98 242.27,53.98 242.23,53.94 239.94,53.94 239.71,53.71 v1(237.91,53.71) ; v1(252.35,43.22) 252.35,43.5 252.19,43.67 250.4,43.67 246.22,39.49 243.47,39.49 v1(242.71,38.72)
  BOTTOM w0.108: v1(252.35,43.22) 252.35,43.81 251.59,44.57 v2(251.59,46.44) 251.59,49.1 251.64,49.15 251.64,51.58 251.5,51.73 251.04,51.73 v1(250.58,51.27)
ALC3235_CBN: length 5.8
  TOP w0.203: v2(34.96,117.01) 34.96,117.44 35.44,117.92 35.89,117.92 36.07,118.1 C134.1 36.64,118.48 38.63,120.47 U17.36
ALC3235_CBP: length 6.1
  TOP w0.203: v2(33.97,118.48) C134.2 35.18,118.77 35.49,119.09 36.68,119.09 36.93,119.34 37.02,119.34 38.55,120.87 U17.35
ALC3235_CPVEE: length 3.5
  TOP w0.203: U17.34 38.51,121.27 37.64,120.4 37.36,120.4 v2(37.12,120.16) 36.59,119.62 C9900.1
ALC3235_LDO1_CAP: length 6.6
  TOP w0.221: U17.21 40.72,126.24
  TOP w0.254: C9897.1 38.21,129.68 38.47,129.43 R9627.1 38.97,128.46 39.71,128.46 39.89,128.28 39.89,127.06 40.72,126.24
ALC3235_LDO2_CAP: length 4.1
  TOP w0.216: v1(39.25,118.53) 39.25,118.71 39.41,118.86 39.76,118.86 40.32,119.42 U17.39
  BOTTOM w0.508: v1(39.25,118.53) 38.92,118.53 v2(38.59,118.2) 38.14,118.2 37.94,118.4 37.27,118.4
ALC3235_LDO3_CAP: length 3.8
  TOP w0.108: v2(47.81,121.98) 46.75,121.98 C9899.1 45.46,122.87 U17.7
ALC3235_MIC_CAP: length 3.8
  TOP w0.108: v2(36.43,121.99) 36.75,121.99 37.15,122.39 v1(37.43,122.39)
  TOP w0.221: v1(37.43,122.39) 37.5,122.47 U17.31
  BOTTOM w0.254: C385.1 37.98,122.39 v1(37.43,122.39)
ALC3235_VREF: length 4.9
  TOP w0.221: U17.25 38.87,125.52
  TOP w0.254: v2(35.9,125.31) 35.9,125.92 C9901.1 37.05,126.1 38.29,126.1 38.87,125.52
ALS_DET#: length 274.8
  TOP w0.108: v1(257.28,49.52) U37.B3 ; v1(251.22,50.66) 251.45,50.43 251.45,48.35 251.52,48.28 251.52,46.6 251.67,46.44 252.49,46.44 R9405.2
  IN3 w0.089: v1(86.37,79.03) 87.66,79.03 92,74.7 92,72.68 106,58.67 138.96,58.67 139.21,58.43 141.85,58.43 142.36,58.94 146.31,58.94 147.32,57.92 148.23,57.92 149.44,56.71 152.49,56.71 156.35,52.85 157.84,52.85 162.08,48.6 164.85,48.6 167.13,46.32 175.93,46.32 176.77,45.48 178.66,45.48 181.43,42.71 202.12,42.71 204.15,44.74 211.78,44.74 212.02,44.98 217.95,44.98 219.08,46.11 219.08,46.8 220.15,47.87 222.81,47.87 226.77,51.82 228.83,51.82 229.52,51.13 229.52,50.49 230.39,49.61 233.39,49.61 234.25,50.48 234.25,50.6 234.58,50.93 234.91,50.93 235.15,50.7 235.15,50.57 235.84,49.88 242.16,49.88 242.76,50.48 242.76,50.67 243.5,51.41 243.56,51.41 245.24,53.09 245.74,53.09 246.06,52.77 246.06,51.75 246.91,50.9 249.76,50.9 249.79,50.87 251.01,50.87 v1(251.22,50.66) 252.88,49 255.03,49 255.54,49.52 v1(257.28,49.52)
  IN4 w0.089: v1(39.18,91.12) 39.95,90.35 52.62,90.35 53.31,91.05 56.14,91.05 56.53,90.66 57.71,90.66 58.38,91.33 58.38,92.11 59.24,92.97 63.11,92.97 73.5,82.59 73.5,81.5 77.75,77.24 85.05,77.24 86.37,78.56 v1(86.37,79.03)
  BOTTOM w0.108: v1(39.18,91.12) 39.18,92.57 38.33,93.42 38.33,94.26 37.6,94.99 37.6,98.43 39.25,100.08 39.25,100.27 40.03,101.04 JEDP1.36 ; v2(86.83,79.49) v1(86.37,79.03)
ALS_INT: length 174.4
  IN3 w0.089: v1(174.37,47.6) 173.85,47.09 169.63,47.09 165.52,51.19 161.11,51.19 156.93,55.37 156.13,55.37 153.89,57.61 149.56,57.61 147.59,59.58 142.09,59.58 141.58,59.08 139.53,59.08 139.28,59.32 106.27,59.32 92.64,72.95 92.64,74.97 87.7,79.91 v1(85.48,79.91)
  IN4 w0.089: v1(85.48,79.91) 85.09,79.91 83.4,78.22 77.71,78.22 74.14,81.78 74.14,82.91 63.44,93.62 58.97,93.62 57.73,92.38 57.73,91.6 57.44,91.31 56.8,91.31 56.41,91.69 53.04,91.69 52.35,91 42.45,91 41.47,91.98 38.65,91.98 v1(38.47,92.16)
  BOTTOM w0.108: JEDP1.37 39.53,101.02 39.02,100.51 39.02,100.18 37.36,98.53 37.36,94.9 38.03,94.23 38.03,93.08 38.47,92.65 v1(38.47,92.16) ; v1(174.37,47.6) 174.01,47.25 JSH1.14 ; v1(85.48,79.91) 85.25,80.14 v2(85.25,80.58)
ALS_SCLK: length 179
  IN3 w0.089: v1(85.74,79.06) 86.11,79.43 87.57,79.43 92.21,74.79 92.21,72.77 106.09,58.89 139.05,58.89 139.3,58.64 141.76,58.64 142.27,59.15 146.41,59.15 147.43,58.14 148.32,58.14 149.27,57.18 153.48,57.18 156.54,54.12 157.01,54.12 161.64,49.5 164.86,49.5 165.42,48.94 165.42,48.72 167.49,46.65 174.58,46.65 v1(175.59,47.66)
  IN4 w0.089: v1(85.74,79.06) 84.14,77.46 77.84,77.46 73.71,81.59 73.71,82.68 63.2,93.19 59.15,93.19 58.16,92.2 58.16,91.42 57.62,90.88 56.62,90.88 56.23,91.26 53.22,91.26 52.53,90.57 41.74,90.57 40.76,91.55 37.82,91.55 v1(37.04,92.32)
  BOTTOM w0.108: v1(175.59,47.66) 175,48.25 JSH1.12 ; v1(37.04,92.32) 37.43,92.7 37.43,94.17 36.89,94.7 36.89,98.72 38.57,100.4 38.57,100.91 38.53,100.96 JEDP1.39 ; v2(85.74,78.04) v1(85.74,79.06)
ALS_SDAT: length 176.6
  IN3 w0.089: v1(174.98,47.66) 174.98,47.65 174.2,46.87 169.48,46.87 166.01,50.34 161.45,50.34 156.87,54.92 156.27,54.92 153.8,57.39 149.47,57.39 147.5,59.37 142.18,59.37 141.67,58.86 139.39,58.86 139.14,59.11 106.18,59.11 92.43,72.86 92.43,74.88 87.66,79.65 85.95,79.65 85.79,79.49 85.42,79.49 v1(85.02,79.09)
  IN4 w0.089: v1(85.02,79.09) 83.6,77.67 77.93,77.67 73.93,81.68 73.93,82.83 63.35,93.4 59.06,93.4 57.95,92.29 57.95,91.51 57.53,91.09 56.71,91.09 56.32,91.48 53.13,91.48 52.44,90.79 42.18,90.79 41.2,91.76 38.03,91.76 37.79,92 v1(37.79,92.36)
  BOTTOM w0.108: v1(37.79,92.36) 37.79,94.14 37.13,94.8 37.13,98.62 38.78,100.28 38.78,100.76 39.03,101.01 JEDP1.38 ; v1(174.98,47.66) 174.63,48.01 174.02,48.01 173.76,47.75 JSH1.13 ; v2(84.31,79.09) v1(85.02,79.09)
ALW_PWRGD_3V_5V: length 81.3
  TOP w0.108: UC9.2 155.68,89.78 155.89,89.99 157.09,89.99 157.18,90.07 158.22,90.07 159.07,90.92 v2(161.17,90.92) 164.27,90.92 165.11,91.76 v1(166.1,91.76) ; PR5306.2 192.72,60.34 v1(192.72,61.51)
  IN3 w0.089: v1(166.1,91.76) 164.27,91.76 161.46,94.56 161.46,96.73 161.74,97.01 162.49,97.01 165.89,93.61 178.19,93.61 178.36,93.44 180.56,93.44 180.85,93.73 182.27,93.73 184.9,91.1 184.9,80.55 183.99,79.64 183.99,72.31 191.96,64.34 191.96,62.27 v1(192.72,61.51)
ALWON: length 133.1
  TOP w0.108: PR5313.1 190.81,61.44 v1(190.1,61.44) ; v1(227.77,54.85) 227.8,54.88 U38.A60
  IN2 w0.089: v1(228.18,65.52) 227.65,66.05 224.45,66.05 223.22,64.82 220.68,64.82 219.31,63.45 217.2,63.45 216.88,63.12 215.22,63.12 214.7,62.6 208.61,62.6 206.82,60.81 206.18,60.81 205.53,60.16 203.94,60.16 202.72,58.93 196.24,58.93 194.32,60.85 191.88,60.85 191.27,61.46 190.12,61.46 v1(190.1,61.44)
  IN4 w0.089: v1(172.17,34.07) 172.2,34.07 172.86,34.74 178.52,34.74 180.12,33.14 200.86,33.14 206.25,38.52 214.74,38.52 216.42,40.2 227.16,40.2 227.67,40.7 v1(227.67,41.21)
  BOTTOM w0.108: v1(227.67,41.21) 227.77,41.31 227.77,44.47 226.38,45.86 226.38,47.45 226.71,47.78 226.71,49.08 225.61,50.18 225.61,51.95 227.77,54.12 v1(227.77,54.85) 227.77,55.64 228.9,56.77 228.9,58.52 229.29,58.91 229.29,63.74 v2(228.48,64.54) 228.18,64.84 v1(228.18,65.52) ; v1(172.17,34.07) 172.17,33.85 PR5264.2
ANTCTL0: length 9.6
  BOTTOM w0.108: T7157.1 108.9,130.37 108.9,135.75 108.58,136.08 JWWAN1.59
ANTCTL1: length 2.5
  TOP w0.108: v1(108.85,137.02) 108.82,137.05 T7158.1
  BOTTOM w0.108: v1(108.85,137.02) 108.4,136.58 JWWAN1.61
ANTCTL2: length 9.8
  BOTTOM w0.108: T7159.1 109.71,143.52 109.71,138.54 108.25,137.08 JWWAN1.63
ANTCTL3: length 8.9
  BOTTOM w0.108: JWWAN1.65 108.24,137.58 109.43,138.77 109.43,140.23 109.44,140.23 109.44,140.57 109.43,140.57 109.43,140.86 109.44,140.86 109.44,141.2 109.43,141.21 109.43,141.5 109.44,141.5 109.44,141.84 109.43,141.84 109.43,142.8 108.46,143.78 T7160.1
AUD_HP_NB_SENSE: length 366.9
  TOP w0.108: v1(259.95,60.29) 259.95,59.63 260.03,59.55 U37.A41
  IN1 w0.089: v1(254.09,30.29) 251.48,30.29 251.36,30.16 251.34,30.16 250.04,28.86 246.56,28.86 245.63,27.93 241.62,27.93 240.83,28.71 235.72,28.71 234.07,27.06 229.6,27.06 228.37,25.83 219.89,25.83 213.8,31.92 190.36,31.92 187.92,34.36 187.92,38.82 177.58,49.17 177.58,51.61 176.52,52.66 176.52,57.21 176.13,57.6 176.13,76.39 175.76,76.77 175.76,83.64 176.2,84.09 176.2,98.17 174.43,99.94 174.43,102.08 172.64,103.87 171.64,103.87 169.52,105.99 169.52,117.38 169.26,117.64 167.62,119.29 167.62,120.37 167.3,120.68 164.17,123.81 163.88,123.81 163.88,123.81 163.21,123.81 160.49,126.54 160.49,129.8 158.5,131.79 155.15,131.79 153.35,133.58 153.35,135.94 150.39,138.9 145.81,138.9 145.43,139.28 144.67,139.28 144.45,139.49 144.14,139.49 143.29,140.35 140.6,140.35 135.08,145.87 133.76,145.87 133.05,146.58 125.88,146.58 123.48,148.98 115.1,148.98 114.11,147.99 114.11,147.44 113.42,146.75 105.36,146.75 101.99,143.37 98.36,143.37 97.48,142.49 85.78,142.49 84.9,143.37 71.82,143.37 71.16,142.72 69.08,142.72 65.62,139.26 65.62,139.08 65.47,138.93 65.47,129.98 64.02,128.53 61.89,128.53 58.51,131.91 45.91,131.91 44.67,130.67 38.82,130.67 37.31,129.16 v1(36.97,129.16)
  BOTTOM w0.108: v1(36.97,129.16) 36.93,129.12 R9450.2 ; v1(254.09,30.29) 254.47,30.29 v2(254.91,30.73) 255.2,31.03 255.2,32.54 255.9,33.24 255.9,36.5 255.33,37.08 255.33,37.68 254.54,38.47 254.54,39.83 255.31,40.6 255.31,41.8 256.08,42.57 256.08,44.16 257.76,45.84 257.76,47.32 259.68,49.24 259.68,50.76 259.37,51.06 259.37,58.41 259.95,58.99 v1(259.95,60.29)
AUD_HP_OUT_L: length 41.9
  TOP w0.381: v1(17.39,140.07) 17.39,140.69 R9442.2 ; v1(34.53,120.64) R162.2
  IN1 w0.381: v1(17.39,140.07) 18.57,141.25 32.58,141.25 34.81,139.02 34.81,131.07 35.84,130.04 35.84,124.07 35.55,123.77 35.55,121.78 34.53,120.77 v1(34.53,120.64)
  BOTTOM w0.381: v1(34.53,120.64) 34.81,120.64 v2(35.14,120.31) ; v1(17.39,140.07) 17.73,140.41 JSIMUAJ1.8
AUD_HP_OUT_L_CON: length 6.5
  BOTTOM w0.305: L7101.2 C7111.1 D7102.1 250.68,110.06 v2(250.81,110.2) 250.81,110.78 250.51,111.08 JUAJ1.1
AUD_HP_OUT_L_D: length 11.4
  TOP w0.305: v1(246,108.69) 244.96,107.66 JSIMUAJ2.11
  BOTTOM w0.305: L7101.1 R7104.1 246.13,110.93 245.93,110.73 245.93,109.79 245.6,109.46 v2(245.6,109.34) 245.6,109.09 v1(246,108.69)
AUD_HP_OUT_R: length 38.9
  TOP w0.381: R166.2 34.3,122.87 v1(34.02,122.59) ; R2704.2 17.84,139.51 v1(17.87,139.54)
  IN1 w0.381: v1(17.87,139.54) 17.87,139.25 18.33,138.79 21.19,138.79 22.77,140.36 32.21,140.36 33.92,138.65 33.92,130.7 34.95,129.67 34.95,124.44 34.66,124.14 34.66,123.23 v1(34.02,122.59)
  BOTTOM w0.381: v2(34.76,122.06) 34.55,122.06 v1(34.02,122.59) ; JSIMUAJ1.7 18.23,138.84 17.87,139.2 v1(17.87,139.54)
AUD_HP_OUT_R_CON: length 19.9
  BOTTOM w0.305: L7102.2 C7110.1 D7103.1 v2(245.32,113.25) 245.32,113.93 249.24,117.84 251.45,117.84 252.69,119.09 255.71,119.09 257.24,120.62 JUAJ1.2
AUD_HP_OUT_R_D: length 9.9
  TOP w0.305: v1(243.44,109.28) 243.93,108.8 v5(243.98,108.8) 244.26,108.52 244.26,104.51 244.46,104.31 JSIMUAJ2.12
  BOTTOM w0.305: v1(243.44,109.28) 243.17,109.56 R7103.1 L7102.1
AUD_HP_SENSE: length 34.8
  IN4 w0.254: v1(18.48,140.12) 18.48,140.53 19.06,141.11 32.52,141.11 35.04,138.59 35.04,130.87 36.18,129.73 v1(37.31,129.73)
  BOTTOM w0.254: R9451.1 36.54,129.73 v1(37.31,129.73) 37.46,129.88 Q3606.1 38.9,129.36 v2(38.9,128.54) 38.85,128.49 RC317.1 ; v1(18.48,140.12) 18.73,140.37 JSIMUAJ1.6
AUD_HP_SENSE_A: length 17.3
  BOTTOM w0.254: C137.1 34.89,130.52 R9451.2 R9450.1 R9452.1 ; C137.1 R163.1 34.52,132.56 34.52,132.92 34.15,133.28 Q217.1 34.15,137.07 v2(34.86,137.78) ; C137.1 35.44,130.62 36.46,130.62 37.02,131.18 38.21,131.18 38.87,130.52 40.37,130.52 40.68,130.83 Q3606.3
AUD_HP_SENSE_D: length 23.5
  TOP w0.305: v1(243.88,103.75) 243.96,103.66 JSIMUAJ2.13
  BOTTOM w0.305: v1(243.88,103.75) 243.62,104 v2(243.62,105.32) 243.34,105.6 243.34,108.52 242.5,109.36 242.5,111.62 242.33,111.79 D7117.1 241.92,112.87 248.18,119.12 JUAJ1.5
AUD_NB_MUTE: length 3.8
  TOP w0.108: v2(33.64,139.22) 34.01,138.85 R208.1 ; Q4209.6 34.29,138.45 R208.1 ; Q4209.5 34.94,138.6 R208.1
AUD_NB_MUTE#: length 321.5
  TOP w0.108: v1(37.45,130.7) 36.7,130.7 36.48,130.47 35.76,130.47 35.72,130.51 34.86,131.38 34.86,131.56 R142.1 ; U17.48 43.92,119.61 44.97,118.56 C410.1 R9631.1 ; R9631.1 45.58,117.48 45.58,116.32 46.29,115.61 46.49,115.61 48.17,113.92 50.57,113.92 50.8,113.69 52.21,113.69 53.74,112.15 53.74,111.54 54.35,110.94 55.18,110.94 55.84,110.27 55.84,106.22 53.32,103.7 53.32,99.03 52.47,98.18 51.15,98.18 49.36,96.39 49.36,93.6 v1(48.23,92.47) ; R9631.1 46.04,118.78 45.83,118.99 45.83,119 v2(45.28,119) 45.1,119.18 v1(45.1,119.8) ; U37.A39 261.03,59.77 v1(260.56,60.24)
  IN3 w0.089: v1(260.26,50.21) 259.78,49.73 259.78,49.46 258.99,48.67 255.56,48.67 255.18,48.28 253.71,48.28 251.95,46.52 247.23,46.52 246.49,45.78 241.16,45.78 240.6,45.23 240.6,43.05 239.05,41.5 234.72,41.5 231.41,44.82 227.39,44.82 226.68,45.52 219.18,45.52 218.16,44.51 212.22,44.51 211.6,43.89 203.97,43.89 202.32,42.24 180.86,42.24 179.52,43.58 178.36,43.58 176.93,45.01 176.57,45.01 175.85,45.72 167.07,45.72 165.26,47.52 162.46,47.52 157.6,52.38 155.01,52.38 151.98,55.4 148.89,55.4 146.72,57.57 145.86,57.57 144.96,58.47 142.55,58.47 142.04,57.96 139.01,57.96 138.77,58.2 105.8,58.2 91.53,72.48 91.53,74.5 88.06,77.97 77.03,77.97 73.52,81.47 73.52,83.35 65.76,91.12 58.44,91.12 v1(57,92.56) ; v1(45.1,119.8) 45.68,120.38 45.68,122.24 47.66,124.22 47.66,125.8 42.73,130.73 37.49,130.73 v1(37.45,130.7)
  IN4 w0.089: v1(48.23,92.47) 48.64,92.88 51.83,92.88 52.14,92.56 v1(57,92.56) ; v1(260.56,60.24) 260.16,59.84 260.16,58.2 260.21,58.15 260.21,56.63 260.75,56.09 260.75,50.71 v1(260.26,50.21)
AUD_OUT_L: length 18.2
  TOP w0.381: v1(40.09,131.2) 40.77,131.2 C9515.1 ; v1(37.32,120.87) 36.92,120.87 36.69,120.64 R162.1
  IN4 w0.381: v1(37.32,120.87) 36.04,120.87 34.75,122.16 34.75,125.42 36.26,126.94 37.73,126.94 40.09,129.3 v1(40.09,131.2)
  BOTTOM w0.381: v1(37.32,120.87) 36.87,121.32 v2(36.76,121.32)
AUD_OUT_R: length 20.3
  TOP w0.381: 37.09,121.58 v1(37.27,121.76) ; C9516.1 39.38,131.41 40.07,132.09 v1(40.07,132.25) ; 37.04,121.53 36.92,121.4 35.81,121.4 35.51,121.7 35.14,121.7 R166.1 33.97,121.15 v2(33.97,121.1)
  IN4 w0.381: v1(37.27,121.76) 36.65,121.76 35.63,122.77 35.63,125.05 36.62,126.04 38.09,126.04 40.98,128.93 40.98,131.35 40.08,132.25 v1(40.07,132.25)
AUD_PC_BEEP: length 3.6
  TOP w0.127: C143.1 C133.1 45.96,125.59 v2(45.73,125.36) 45.24,124.87 U17.12
AUD_PWR_EN: length 260.8
  TOP w0.108: v2(52.99,127.56) 53.1,127.45 v1(53.1,126.84)
  IN1 w0.089: v1(172.91,75.93) 174.43,75.93 175.58,77.08 175.58,83.72 176.03,84.16 176.03,97.71 172.78,100.96 172.78,103.24 172.4,103.62 172.4,103.62 172.35,103.67 171.58,103.67 169.35,105.91 169.35,117.31 169.09,117.57 167.44,119.21 167.44,120.29 167.23,120.5 164.1,123.64 163.95,123.64 163.14,123.64 160.31,126.46 160.31,129.72 158.42,131.61 155.02,131.61 153.17,133.46 153.17,135.86 150.31,138.72 145.73,138.72 145.38,139.08 144.61,139.08 144.37,139.32 144.07,139.32 143.21,140.17 140.53,140.17 135.01,145.69 133.69,145.69 133.12,146.26 125.95,146.26 123.51,148.7 115.19,148.7 114.29,147.8 114.29,147.36 113.47,146.55 105.41,146.55 102.06,143.19 98.43,143.19 97.55,142.31 85.58,142.31 84.69,143.19 71.89,143.19 71.18,142.48 69.25,142.48 65.8,139.03 65.8,139 65.72,138.93 65.72,129.98 62.9,127.17 60.29,127.17 60.24,127.12 60.24,127.12 58.65,125.53 54.4,125.53 v1(53.1,126.84)
  IN3 w0.076: 141.16,81.03 140.9,81.28 v3(140.9,81.4)
  IN3 w0.089: 141.16,81.03 143.58,78.6 147.39,78.6 148.61,79.82 153.8,79.82 156.68,76.94 158.41,76.94 159.14,76.21 165.44,76.21 166.07,76.84 172,76.84 v1(172.91,75.93)
  BOTTOM w0.076: UC1.BA7 134.14,80.55 134.59,80.1 134.88,80.1 135.87,79.1 137.79,79.1 139.16,80.48 139.74,80.48 140.02,80.76 140.27,80.76 v3(140.9,81.4) 140.9,80.97 141.16,80.72
  BOTTOM w0.108: v1(53.1,126.84) 54.16,127.9 R154.1 ; 141.16,80.72 143.43,78.45 148.41,78.45 148.99,79.03 148.99,81.02 150.25,82.28 150.25,83.76 150.55,84.06 RP9.5
AUD_SENSE_A: length 4
  TOP w0.221: 44.51,125.97 44.14,125.97 43.92,125.75 U17.13
  TOP w0.254: R152.2 v2(45.1,127.45) 45.1,126.25 44.82,125.97 44.51,125.97
AUD_SENSE_B: length 4
  TOP w0.221: U17.14 43.52,125.92
  TOP w0.254: v1(44.33,127.17) 43.88,126.71 43.88,126.28 43.52,125.92
  BOTTOM w0.254: v2(45.53,128.13) 45.35,127.95 R9634.1 44.36,127.19 v1(44.33,127.17)
AUD_SENSE_C: length 2.8
  TOP w0.221: 40.32,126.1 U17.22
  TOP w0.254: R9635.1 39.33,127.09 40.32,126.1
AUIDO_GND: length 76.3
  TOP w0.292: JSIMUAJ2.14 v1(243.46,100.1) ; JSIMUAJ2.10 245.46,102.49 245.57,102.59 v1(245.57,102.62) ; v1(245.68,103.24) 246.09,102.83 246.09,102.4 245.96,102.27 JSIMUAJ2.9
  TOP w0.508: JUAJ1.6 250.51,119.94 ; JUAJ1.6 249.3,120.72 ; JUAJ1.6 252.22,120.72 ; JUAJ1.6 250.51,121.65 ; JUAJ1.7 256.11,111.52 ; JUAJ1.7 257.73,112.32 ; JUAJ1.7 254.7,112.32 ; JUAJ1.7 256.11,113.16 ; JUAJ1.8 255.11,120.55 ; JUAJ1.8 255.11,122.19 ; JUAJ1.8 256.66,121.52 ; JUAJ1.8 253.86,121.52
  IN1 w0.508: 256.11,111.63 JUAJ1.7 ; JUAJ1.7 256.11,113.01 ; JUAJ1.7 255.03,112.32 ; JUAJ1.7 257.19,112.32 ; JUAJ1.6 251.59,120.72 ; JUAJ1.6 250.51,121.41 ; JUAJ1.6 249.43,120.72 ; JUAJ1.6 250.51,120.03 ; JUAJ1.8 256.19,121.52 ; JUAJ1.8 255.11,122.21 ; JUAJ1.8 255.11,120.83 ; JUAJ1.8 254.03,121.52
  IN2 w0.508: 250.51,120.03 JUAJ1.6 ; JUAJ1.6 250.51,121.41 ; JUAJ1.6 249.43,120.72 ; JUAJ1.6 251.59,120.72 ; 256.11,111.63 JUAJ1.7 ; JUAJ1.7 256.11,113.01 ; JUAJ1.7 255.03,112.32 ; JUAJ1.8 256.19,121.52 ; JUAJ1.8 255.11,120.83 ; JUAJ1.8 255.11,122.21 ; JUAJ1.8 254.03,121.52
  IN3 w0.508: JUAJ1.8 256.19,121.52 ; JUAJ1.8 255.11,120.83 ; JUAJ1.8 254.03,121.52 ; JUAJ1.8 255.11,122.21 ; JUAJ1.6 251.59,120.72 ; JUAJ1.6 250.51,121.41 ; JUAJ1.6 250.51,120.03 ; JUAJ1.6 249.43,120.72 ; JUAJ1.7 257.19,112.32 ; JUAJ1.7 256.11,111.63 ; JUAJ1.7 256.11,113.01 ; JUAJ1.7 255.03,112.32
  IN4 w0.508: 254.03,121.52 JUAJ1.8 ; JUAJ1.8 255.11,122.21 ; JUAJ1.8 256.19,121.52 ; JUAJ1.8 255.11,120.83 ; 249.43,120.72 JUAJ1.6 ; JUAJ1.6 251.59,120.72 ; JUAJ1.6 250.51,121.41 ; JUAJ1.6 250.51,120.03 ; 255.03,112.32 JUAJ1.7 ; JUAJ1.7 257.19,112.32 ; JUAJ1.7 256.11,111.63 ; JUAJ1.7 256.11,113.01
  BOTTOM w0.406: C7110.2 244.13,110.27 244.03,110.17 R7103.2 244.03,109.51 244.31,109.23
  BOTTOM w0.457: C7111.2 v1(248.47,111.77)
  BOTTOM w0.508: 256.11,111.63 JUAJ1.7 ; JUAJ1.7 255.03,112.32 ; JUAJ1.7 256.11,113.01 ; JUAJ1.7 257.19,112.32 ; R7104.2 v1(246.57,109.46) ; JUAJ1.8 255.11,122.21 ; JUAJ1.8 254.03,121.52 ; JUAJ1.8 255.11,120.83 ; JUAJ1.8 256.19,121.52 ; 249.43,120.72 JUAJ1.6 ; JUAJ1.6 250.51,120.03 ; JUAJ1.6 250.51,121.41 ; JUAJ1.6 251.59,120.72 ; D7117.2 v1(240.86,110.94) ; D7102.2 v1(249.62,111.88) ; D7103.2 v1(245.32,110.05)
  vias: v1(239.1,116.12) v1(239.1,114.29) v1(239.1,111.95) v1(239.1,110.4) v1(239.1,107.89) v1(239.1,102.83) v1(239.13,101.33) v1(239.46,121.66) v1(239.46,119.12) v1(239.46,116.96) v1(239.71,102.78) v1(239.89,106.46) v1(239.86,105.83) v1(240.35,101.38) v1(240.49,108.36) v1(240.98,121.66) v1(240.98,116.96) v1(242.8,100.58) v1(242.96,112.71) v1(243.96,100.6) v1(244.44,112.64) v1(244.74,109.28) v1(246.01,105.4) v1(246.29,113.73) v1(246.44,111.88) v1(247.15,116.96) v1(247.71,122.42) v1(248.42,120.72) v1(248.52,118.28) v1(249.24,113.78) v1(249.74,117.08) v1(250.25,122.42) v1(251.17,117.06) v1(251.78,111.29) v1(252.79,122.42) v1(253.15,119.9) v1(253.23,118.33) v1(253.3,113.2) v1(253.76,112.03) v1(254.9,111.42) v1(255,119.9) v1(255.31,118.3) v1(256.45,114.09) v1(257.37,122.42) v1(257.49,114.98) v1(258.31,116.25) v1(259.29,109.26) v1(259.91,122.42) v1(260.03,115.28) v1(260.59,110.99) v1(261.02,118.2) v1(261.05,116.22) v1(261.76,122.16) v1(262.45,120.39) v1(262.45,117.85) v1(262.45,115.31) v1(262.45,112.77) v1(262.49,110.78) v1(262.49,109.03) v2(245.58,107.46)
